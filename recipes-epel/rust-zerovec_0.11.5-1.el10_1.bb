# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerovec"
PV = "0.11.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-zerovec+alloc-devel \
 rust-zerovec+databake-devel \
 rust-zerovec+default-devel \
 rust-zerovec+derive-devel \
 rust-zerovec+hashmap-devel \
 rust-zerovec+serde-devel \
 rust-zerovec+std-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerovec-0.11.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e668ee1d715fed8f37b61aafb5cef4ea0203aa47423778187de2652262d2d2e2"

URI_x86_64_v2_rust-zerovec+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+alloc-devel-0.11.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerovec+alloc-devel.sha256sum] = "e8bb1dbe23834a6b30e934eeb235787e88ab81f21cc6a89619dd6e4f381d74fb"

URI_x86_64_v2_rust-zerovec+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+databake-devel-0.11.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+databake-devel}"
SRC_URI[x86_64_v2_rust-zerovec+databake-devel.sha256sum] = "1d41167c8c85e211fc4809e760b9b85ed2a5aaec7669c4622209bcfb3d298d26"

URI_x86_64_v2_rust-zerovec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+default-devel-0.11.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+default-devel}"
SRC_URI[x86_64_v2_rust-zerovec+default-devel.sha256sum] = "b36f8c5ce77f79a536c9790a1a64f5571cce127925fda4eeda85dceb75a233d0"

URI_x86_64_v2_rust-zerovec+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+derive-devel-0.11.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+derive-devel}"
SRC_URI[x86_64_v2_rust-zerovec+derive-devel.sha256sum] = "7495ba1070c6234b6e53ec52f290bb77f5400a9d49feb88440430ca93b11021e"

URI_x86_64_v2_rust-zerovec+hashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+hashmap-devel-0.11.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+hashmap-devel}"
SRC_URI[x86_64_v2_rust-zerovec+hashmap-devel.sha256sum] = "580ae9685ed78ff2d17186472aab3f460eda0ab4f380dfdf728b920010469e13"

URI_x86_64_v2_rust-zerovec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+serde-devel-0.11.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+serde-devel}"
SRC_URI[x86_64_v2_rust-zerovec+serde-devel.sha256sum] = "eb804c62a587fc733b1221872b389a52df1f6a41f392cadbbaa373d3331fa361"

URI_x86_64_v2_rust-zerovec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+std-devel-0.11.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+std-devel}"
SRC_URI[x86_64_v2_rust-zerovec+std-devel.sha256sum] = "b294d1fec68654561327ecf4d3f43b6dc2eaddb4bb09f3341360ee1bde655363"

URI_x86_64_v2_rust-zerovec+yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+yoke-devel-0.11.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+yoke-devel}"
SRC_URI[x86_64_v2_rust-zerovec+yoke-devel.sha256sum] = "e7bb2501d4e29a07d4147a5a0ecfa4590cb60f9e6109f847033c6ecf3151d3c0"

URI_x86_64_v2_rust-zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-devel-0.11.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec-devel}"
SRC_URI[x86_64_v2_rust-zerovec-devel.sha256sum] = "de43aa204ddcc60b9a363064694ff51a0dcef499c6c24723a72a8e7f05016192"

URI_aarch64_rust-zerovec+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+alloc-devel-0.11.5-1.el10_1.noarch.rpm;name=aarch64_rust-zerovec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+alloc-devel}"
SRC_URI[aarch64_rust-zerovec+alloc-devel.sha256sum] = "f2f30ea2eb91c1e4f1718750b9cbf48f0a8c6d719b2a0d5600b4848716e7560e"

URI_aarch64_rust-zerovec+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+databake-devel-0.11.5-1.el10_1.noarch.rpm;name=aarch64_rust-zerovec+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+databake-devel}"
SRC_URI[aarch64_rust-zerovec+databake-devel.sha256sum] = "d0543d349e4ff1653bd581cfbd111b1df8925399d76c546e663aef35738cf8f9"

URI_aarch64_rust-zerovec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+default-devel-0.11.5-1.el10_1.noarch.rpm;name=aarch64_rust-zerovec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+default-devel}"
SRC_URI[aarch64_rust-zerovec+default-devel.sha256sum] = "6334629883258d8318f2a20c709cf76bc0ed47258e8c0c333d7db3e0cd605e4a"

URI_aarch64_rust-zerovec+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+derive-devel-0.11.5-1.el10_1.noarch.rpm;name=aarch64_rust-zerovec+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+derive-devel}"
SRC_URI[aarch64_rust-zerovec+derive-devel.sha256sum] = "3eed644a3766a7b556f11e31b94fa386a4a07d658240d6fd2b6eb1a6a40af53e"

URI_aarch64_rust-zerovec+hashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+hashmap-devel-0.11.5-1.el10_1.noarch.rpm;name=aarch64_rust-zerovec+hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+hashmap-devel}"
SRC_URI[aarch64_rust-zerovec+hashmap-devel.sha256sum] = "0f17173ba59e33317f2ae210c32b515097de5f01559b95d1333bc3c9dc658cb7"

URI_aarch64_rust-zerovec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+serde-devel-0.11.5-1.el10_1.noarch.rpm;name=aarch64_rust-zerovec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+serde-devel}"
SRC_URI[aarch64_rust-zerovec+serde-devel.sha256sum] = "c66add5c4cc2adb8fd1c0c092aa93e8cb1ab1d63a0ca7f6543bdc19a99b1fdfe"

URI_aarch64_rust-zerovec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+std-devel-0.11.5-1.el10_1.noarch.rpm;name=aarch64_rust-zerovec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+std-devel}"
SRC_URI[aarch64_rust-zerovec+std-devel.sha256sum] = "5f9cb7e8045d4219272328d9971dad55fc7e7657cf28b2d43e2cb7684d7bcf1f"

URI_aarch64_rust-zerovec+yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+yoke-devel-0.11.5-1.el10_1.noarch.rpm;name=aarch64_rust-zerovec+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+yoke-devel}"
SRC_URI[aarch64_rust-zerovec+yoke-devel.sha256sum] = "2741c65c59b9b71edb4cc518cfa31c404b8fb1ca9f038b116865ebcad7c131b3"

URI_aarch64_rust-zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-devel-0.11.5-1.el10_1.noarch.rpm;name=aarch64_rust-zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec-devel}"
SRC_URI[aarch64_rust-zerovec-devel.sha256sum] = "e08caa8bed24b7ba7c8a6aa5f2e4296dc5924a0a187014cb733ae3e6d4089879"

RDEPENDS:rust-zerovec+alloc-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+default-devel = " \
 cargo \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+derive-devel = " \
 cargo \
 rust-zerovec-derive-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+hashmap-devel = " \
 cargo \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+serde-devel = " \
 cargo \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+std-devel = " \
 cargo \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+yoke-devel = " \
 cargo \
 rust-yoke-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec-devel = " \
 cargo \
 rust \
 rust-zerofrom-devel \
 "
