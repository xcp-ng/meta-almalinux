# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-data-encoding-macro"
PV = "0.1.21"
PR = "1.el10_3"
PACKAGES = " \
 rust-data-encoding-macro+default-devel \
 rust-data-encoding-macro-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-data-encoding-macro-0.1.21-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e322b8071e02b15bea56b0ab841b36ca86789f7289d2d6ae3c2243cae3023643"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding-macro+default-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding-macro+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-data-encoding-macro+default-devel.sha256sum] = "76972e11786a9c76634c072eb0a3a050a11a9b10e3ad1ca6e48fe0afcd2fcd13"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding-macro-devel-0.1.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-data-encoding-macro-devel.sha256sum] = "94ff3e2d008ad7270dee074f3c9e6be5c917f9743a0d643db540318ca80997cb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding-macro+default-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding-macro+default-devel;unpack=0"
SRC_URI[aarch64_rust-data-encoding-macro+default-devel.sha256sum] = "9850a9681c4dc005997d50bbafd9b8f5ea31f92d4069a2870a1b21f0aef91d6e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding-macro-devel-0.1.21-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding-macro-devel;unpack=0"
SRC_URI[aarch64_rust-data-encoding-macro-devel.sha256sum] = "29bc1a25c42cb12f5dbd77de772742a52b91eb949ac47f7950e4f75dacea20ba"

RDEPENDS:rust-data-encoding-macro+default-devel = " \
 cargo \
 rust-data-encoding-macro-devel \
 "
RDEPENDS:rust-data-encoding-macro-devel = " \
 cargo \
 rust \
 rust-data-encoding-devel \
 rust-data-encoding-macro-internal+default-devel \
 "
