# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "numpy"
PE = "1"
PV = "1.26.4"
PR = "7.el10_2"
PACKAGES = " \
 python3-numpy \
 python3-numpy-f2py \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/numpy-1.26.4-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4de63ac05b9a6c6878b5ff6109019a2d72ef43b271960674d4f16520b5d85613"

URI_x86_64_v2_python3-numpy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-numpy-1.26.4-7.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-numpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-numpy}"
SRC_URI[x86_64_v2_python3-numpy.sha256sum] = "f7378784d25fa9da61d81f82ef10d81b9d5b65a70d3d2ecd747e30ae903d95c7"

URI_x86_64_v2_python3-numpy-f2py = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-numpy-f2py-1.26.4-7.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-numpy-f2py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-numpy-f2py}"
SRC_URI[x86_64_v2_python3-numpy-f2py.sha256sum] = "31345e20441a9c859d1e015796deb8e0ab04b9bdbb78184a03ee58efa428db3a"

URI_aarch64_python3-numpy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-numpy-1.26.4-7.el10_2.aarch64.rpm;name=aarch64_python3-numpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-numpy}"
SRC_URI[aarch64_python3-numpy.sha256sum] = "47777ea740dd33c56ff29401bc070231f637b6dde989b38954c1e4218e38724f"

URI_aarch64_python3-numpy-f2py = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-numpy-f2py-1.26.4-7.el10_2.aarch64.rpm;name=aarch64_python3-numpy-f2py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-numpy-f2py}"
SRC_URI[aarch64_python3-numpy-f2py.sha256sum] = "18f18149fe39c0824e812693720a474834a64fe794433d820d0c88e4c7237377"

RDEPENDS:python3-numpy:x86_64_v2 = " \
 flexiblas-netlib \
 glibc \
 libstdc++ \
 python3 \
"
RDEPENDS:python3-numpy:aarch64 = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
"
RDEPENDS:python3-numpy-f2py = " \
 python3 \
 python3-devel \
 python3-numpy \
 "
