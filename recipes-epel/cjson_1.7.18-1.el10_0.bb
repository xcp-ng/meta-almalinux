# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cjson"
PV = "1.7.18"
PR = "1.el10_0"
PACKAGES = " \
 cjson \
 cjson-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cjson-1.7.18-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e4a4bbde625c1ecce8e52a7fe692ad2e11d01cfca661812f95ef2703a0dc3bb"

URI_x86_64_v2_cjson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cjson-1.7.18-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cjson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cjson}"
SRC_URI[x86_64_v2_cjson.sha256sum] = "4b1177585584b3f62c3ff0a9ddc73b12734707354c40dedff5437147e8c8dd01"

URI_x86_64_v2_cjson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cjson-devel-1.7.18-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cjson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cjson-devel}"
SRC_URI[x86_64_v2_cjson-devel.sha256sum] = "ba45f0fd8509584a3ed274be5493b1e9be6da4dccec84a4497f077b6cad35570"

URI_aarch64_cjson = "${EPEL_MIRROR}/aarch64/Packages/c/cjson-1.7.18-1.el10_0.aarch64.rpm;name=aarch64_cjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_cjson}"
SRC_URI[aarch64_cjson.sha256sum] = "8b15a969ae3bd25fbc85f8d0381cc25b3862b08cec396b5e81035b0bae1a85cf"

URI_aarch64_cjson-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cjson-devel-1.7.18-1.el10_0.aarch64.rpm;name=aarch64_cjson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cjson-devel}"
SRC_URI[aarch64_cjson-devel.sha256sum] = "11d6a6e379741c871b8899a2e888426b400d35c852be21c86dd248875fd2dae0"

RDEPENDS:cjson = " \
 glibc \
 "
RDEPENDS:cjson-devel = " \
 cjson \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
