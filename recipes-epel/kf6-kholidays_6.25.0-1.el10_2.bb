# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kholidays"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kholidays \
 kf6-kholidays-devel \
 kf6-kholidays-doc \
 kf6-kholidays-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kholidays-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da7cf208b8679d96c66dcfadda86342498a2c0711307580a22394fed4f75fcc8"

URI_x86_64_v2_kf6-kholidays = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kholidays;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays}"
SRC_URI[x86_64_v2_kf6-kholidays.sha256sum] = "5cf86aa92f784281c6da534b7037ddb4b5fe63ca0a0ed89e4a8a73def39a8efc"

URI_x86_64_v2_kf6-kholidays-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kholidays-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays-devel}"
SRC_URI[x86_64_v2_kf6-kholidays-devel.sha256sum] = "fd4d60bd1db0d700505d6bcfe741027f66ba6061c1b75aa9b14580eef70e8226"

URI_x86_64_v2_kf6-kholidays-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kholidays-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays-doc}"
SRC_URI[x86_64_v2_kf6-kholidays-doc.sha256sum] = "cc0fca0993ce3f5540c8c61f608d5a16fbedf58a4c51f92c5585c41a99c65e4e"

URI_x86_64_v2_kf6-kholidays-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kholidays-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays-html}"
SRC_URI[x86_64_v2_kf6-kholidays-html.sha256sum] = "f7f241ccf550727cfde667057a2f11a13e160997c0df00c0a348a883b629e237"

URI_aarch64_kf6-kholidays = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kholidays;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays}"
SRC_URI[aarch64_kf6-kholidays.sha256sum] = "fcf948bad915af936053d9a77bf6e8df11408a7abea2f83b677f5337904c8430"

URI_aarch64_kf6-kholidays-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kholidays-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays-devel}"
SRC_URI[aarch64_kf6-kholidays-devel.sha256sum] = "7c9594afeb5ace2edd0e6605e7ccdf66147e969911bb2cc57466e0441db5aa1b"

URI_aarch64_kf6-kholidays-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kholidays-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays-doc}"
SRC_URI[aarch64_kf6-kholidays-doc.sha256sum] = "6138a7655945afb80423db0127745b0e4a738b7fa8afa315ce79b929a5eb11a0"

URI_aarch64_kf6-kholidays-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kholidays-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays-html}"
SRC_URI[aarch64_kf6-kholidays-html.sha256sum] = "96e8913225d291116839aeb6d0b1d15b883b6cdc0529528690b2bdb9e7e86205"

RDEPENDS:kf6-kholidays = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kholidays-devel = " \
 cmake-filesystem \
 kf6-kholidays \
 "
RDEPENDS:kf6-kholidays-doc = " \
 "
RDEPENDS:kf6-kholidays-html = " \
 "
