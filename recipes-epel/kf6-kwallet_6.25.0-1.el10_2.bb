# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwallet"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kwallet \
 kf6-kwallet-devel \
 kf6-kwallet-doc \
 kf6-kwallet-html \
 kf6-kwallet-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kwallet-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "730a8fa62aef6d2def4aa82456780029ad60918ec8b786f22ac29a6b5532589a"

URI_x86_64_v2_kf6-kwallet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet}"
SRC_URI[x86_64_v2_kf6-kwallet.sha256sum] = "ff43ea6eff8541b54fc072c1054d44527c5266b77e7964845f6674ca3a3673fd"

URI_x86_64_v2_kf6-kwallet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-devel}"
SRC_URI[x86_64_v2_kf6-kwallet-devel.sha256sum] = "7fdbb84430876d098bb01cb87b0537be07097c918fae6386b0006c3970dd1ebc"

URI_x86_64_v2_kf6-kwallet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwallet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-doc}"
SRC_URI[x86_64_v2_kf6-kwallet-doc.sha256sum] = "ac43db873683be0d9d9ab1e6131963ed39b9796883c8fc9d1a3943096e92492a"

URI_x86_64_v2_kf6-kwallet-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwallet-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-html}"
SRC_URI[x86_64_v2_kf6-kwallet-html.sha256sum] = "c441d96fd58f416dea772e2694995d71e7ca920eb0cf1ec9cc00d8ae90a227d4"

URI_x86_64_v2_kf6-kwallet-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-libs-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-libs}"
SRC_URI[x86_64_v2_kf6-kwallet-libs.sha256sum] = "0d272766f034de3c742ab67d711c76bae3642d2e6e7b13d16cd6fedbd6083450"

URI_aarch64_kf6-kwallet = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kwallet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet}"
SRC_URI[aarch64_kf6-kwallet.sha256sum] = "7fba34041c675f436838368b2380ef9e19c02b0f5636e8a23b82ce56db5e9d9f"

URI_aarch64_kf6-kwallet-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kwallet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-devel}"
SRC_URI[aarch64_kf6-kwallet-devel.sha256sum] = "b377cefc268adb6211c0ee557cc9ee58f8c0d900a1f3244e56e7f17cae3bb469"

URI_aarch64_kf6-kwallet-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kwallet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-doc}"
SRC_URI[aarch64_kf6-kwallet-doc.sha256sum] = "05e5871b176755f2d299c20e42b8e9e8677913dc615366be8a0779569cd540a2"

URI_aarch64_kf6-kwallet-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kwallet-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-html}"
SRC_URI[aarch64_kf6-kwallet-html.sha256sum] = "ae5fc70ecce9114fcf2c9aa61dab62561f00b8b73a437bef4448a472231c8cbb"

URI_aarch64_kf6-kwallet-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-libs-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kwallet-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-libs}"
SRC_URI[aarch64_kf6-kwallet-libs.sha256sum] = "f0d84d263a689178bdca5c9291331d0d5f74566cebc08b5f5d3832c045cfaaec"

RDEPENDS:kf6-kwallet = " \
 glib2 \
 glibc \
 gpgmepp \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libgcc \
 libsecret \
 libstdc++ \
 pinentry-gnome3 \
 qca-qt6 \
 qca-qt6-ossl \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwallet-devel = " \
 cmake-filesystem \
 kf6-kwallet-libs \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kwallet-doc = " \
 "
RDEPENDS:kf6-kwallet-html = " \
 "
RDEPENDS:kf6-kwallet-libs = " \
 glibc \
 gpgmepp \
 kf6-kconfig \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwallet \
 kf6-kwidgetsaddons \
 libgcrypt \
 libstdc++ \
 qt6-qtbase \
 "
