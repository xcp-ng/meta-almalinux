# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-predicates"
PV = "3.1.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-predicates+color-devel \
 rust-predicates+default-devel \
 rust-predicates+diff-devel \
 rust-predicates+float-cmp-devel \
 rust-predicates+normalize-line-endings-devel \
 rust-predicates+regex-devel \
 rust-predicates+unstable-devel \
 rust-predicates-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-predicates-3.1.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2633b8d6699ef72eabdb0ffdb70cc85048255ff5e00bc2376212fe9f7b23ad0c"

URI_x86_64_v2_rust-predicates+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+color-devel-3.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+color-devel}"
SRC_URI[x86_64_v2_rust-predicates+color-devel.sha256sum] = "1d2ec5ed7d86abb9a7d3619e1550a39719cc6b791ccbb96b692a45f9701c21ff"

URI_x86_64_v2_rust-predicates+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+default-devel-3.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+default-devel}"
SRC_URI[x86_64_v2_rust-predicates+default-devel.sha256sum] = "045d872388ae0bb00662fe8005c5dd1cf4cf04362ed53550602e9f122a2f2b22"

URI_x86_64_v2_rust-predicates+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+diff-devel-3.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+diff-devel}"
SRC_URI[x86_64_v2_rust-predicates+diff-devel.sha256sum] = "3a33cc4eee14a1f4ee8b28afc71b9d6bc5e331b75bea9b9793a980e12c7532a3"

URI_x86_64_v2_rust-predicates+float-cmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+float-cmp-devel-3.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+float-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+float-cmp-devel}"
SRC_URI[x86_64_v2_rust-predicates+float-cmp-devel.sha256sum] = "5389ca316c5a500e3976bf29e4565681beea9601b87fdfdd62f5b7e50e53eaaf"

URI_x86_64_v2_rust-predicates+normalize-line-endings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+normalize-line-endings-devel-3.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+normalize-line-endings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+normalize-line-endings-devel}"
SRC_URI[x86_64_v2_rust-predicates+normalize-line-endings-devel.sha256sum] = "6a253e12a97d997a7ffdfefc8588d0a8998583aa0797c497c34fccb72235cbce"

URI_x86_64_v2_rust-predicates+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+regex-devel-3.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+regex-devel}"
SRC_URI[x86_64_v2_rust-predicates+regex-devel.sha256sum] = "bda9cdb157aad086a8048c9a9deeb67b67d27cc6ab22d3de53174665ea48252a"

URI_x86_64_v2_rust-predicates+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+unstable-devel-3.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+unstable-devel}"
SRC_URI[x86_64_v2_rust-predicates+unstable-devel.sha256sum] = "4c1f705d7885385c844b47edae6db3a508a2ac76cf2e7f58cc7b3796a3c664af"

URI_x86_64_v2_rust-predicates-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-devel-3.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-devel}"
SRC_URI[x86_64_v2_rust-predicates-devel.sha256sum] = "d6404ecffad3bec2fc06309a86ba179c2003741fbbd0e2263b17af51b6ff4a90"

URI_aarch64_rust-predicates+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+color-devel-3.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-predicates+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+color-devel}"
SRC_URI[aarch64_rust-predicates+color-devel.sha256sum] = "549a68e4be06ff32533965eb3611f2bec071f5c9d87d361fc1702cc4cb2fd310"

URI_aarch64_rust-predicates+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+default-devel-3.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-predicates+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+default-devel}"
SRC_URI[aarch64_rust-predicates+default-devel.sha256sum] = "1afba8da662a7ab322aca38982fca7c3407ae739284892dc175812d97d93037f"

URI_aarch64_rust-predicates+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+diff-devel-3.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-predicates+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+diff-devel}"
SRC_URI[aarch64_rust-predicates+diff-devel.sha256sum] = "4a753bfdd5fac240a625f95808ae6538b0e774820715dcc21d522948fe082b87"

URI_aarch64_rust-predicates+float-cmp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+float-cmp-devel-3.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-predicates+float-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+float-cmp-devel}"
SRC_URI[aarch64_rust-predicates+float-cmp-devel.sha256sum] = "6422f714dab06b09ba83911cacecec8db9c75efe737821df63296090e4fecd09"

URI_aarch64_rust-predicates+normalize-line-endings-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+normalize-line-endings-devel-3.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-predicates+normalize-line-endings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+normalize-line-endings-devel}"
SRC_URI[aarch64_rust-predicates+normalize-line-endings-devel.sha256sum] = "aacb3cb270d4e18f7d9d026e210089bde1d76f4421eeb486166257744a3293af"

URI_aarch64_rust-predicates+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+regex-devel-3.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-predicates+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+regex-devel}"
SRC_URI[aarch64_rust-predicates+regex-devel.sha256sum] = "d76a6243e7b755db273aa4991c59b77cf07721a691e05dc48835d16d1154c736"

URI_aarch64_rust-predicates+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+unstable-devel-3.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-predicates+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+unstable-devel}"
SRC_URI[aarch64_rust-predicates+unstable-devel.sha256sum] = "413fdb7e74b9163a3598b839dfaaa0187784f65dd293a627c2d11dc7f20d9193"

URI_aarch64_rust-predicates-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-devel-3.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-predicates-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-devel}"
SRC_URI[aarch64_rust-predicates-devel.sha256sum] = "0fdf9f161b46608b42ab5071bee81aa9e9d3ad1f8680a3f86b6ae9027f811657"

RDEPENDS:rust-predicates+color-devel = " \
 cargo \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+default-devel = " \
 cargo \
 rust-predicates+color-devel \
 rust-predicates+diff-devel \
 rust-predicates+float-cmp-devel \
 rust-predicates+normalize-line-endings-devel \
 rust-predicates+regex-devel \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+diff-devel = " \
 cargo \
 rust-difflib+default-devel \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+float-cmp-devel = " \
 cargo \
 rust-float-cmp+default-devel \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+normalize-line-endings-devel = " \
 cargo \
 rust-normalize-line-endings+default-devel \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+regex-devel = " \
 cargo \
 rust-predicates-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-predicates+unstable-devel = " \
 cargo \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-predicates-core+default-devel \
 "
