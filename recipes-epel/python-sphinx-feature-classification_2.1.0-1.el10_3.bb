# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-feature-classification"
PV = "2.1.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-sphinx-feature-classification \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-feature-classification-2.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a89e8c3f040ea7877b9a690a8f917b4644c091aa11238fe246271cb86045678a"

URI_x86_64_v2_python3-sphinx-feature-classification = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-feature-classification-2.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-feature-classification;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-feature-classification}"
SRC_URI[x86_64_v2_python3-sphinx-feature-classification.sha256sum] = "89811b9814e428360d3e2691707d6cc2f92497c5502101ee541adcd52a3ea2f8"

URI_aarch64_python3-sphinx-feature-classification = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-feature-classification-2.1.0-1.el10_3.noarch.rpm;name=aarch64_python3-sphinx-feature-classification;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-feature-classification}"
SRC_URI[aarch64_python3-sphinx-feature-classification.sha256sum] = "78e351374fcfa00a5fc2ab35055a6ab58386b53de776ceca49bf9282b959aa64"

RDEPENDS:python3-sphinx-feature-classification = " \
 python3 \
 python3-docutils \
 python3-pbr \
 "
