# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netatalk"
PE = "5"
PV = "4.4.3"
PR = "1.el10_2"
PACKAGES = " \
 netatalk \
 netatalk-afptest \
 netatalk-devel \
 netatalk-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netatalk-4.4.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7026bfc2575c9605270c8e0bf59d2ac0d9a466bea0f46b4cd737425f81e58998"

URI_x86_64_v2_netatalk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-4.4.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netatalk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netatalk}"
SRC_URI[x86_64_v2_netatalk.sha256sum] = "c88cc4aad8850ef0c56d82b01dc710d96814d9275924cba4ddf5fad76c1e7974"

URI_x86_64_v2_netatalk-afptest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-afptest-4.4.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netatalk-afptest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netatalk-afptest}"
SRC_URI[x86_64_v2_netatalk-afptest.sha256sum] = "2a4d9e23213164a7b9ad1984c7504e8418e7d00aae78605b39f6962260bbf43c"

URI_x86_64_v2_netatalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-devel-4.4.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netatalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netatalk-devel}"
SRC_URI[x86_64_v2_netatalk-devel.sha256sum] = "e1a47ddbdc7f3dfc05fd30b7eb49277038240e5071e96f8dca75be9129f389e6"

URI_x86_64_v2_netatalk-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-doc-4.4.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_netatalk-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netatalk-doc}"
SRC_URI[x86_64_v2_netatalk-doc.sha256sum] = "f1f9599fd06cccb03f21733a255fb29f7578e45dbd4cc5fd1fb9f5c8569c4d25"

URI_aarch64_netatalk = "${EPEL_MIRROR}/aarch64/Packages/n/netatalk-4.4.3-1.el10_2.aarch64.rpm;name=aarch64_netatalk;unpack=0"
SRC_URI:append = " ${URI_aarch64_netatalk}"
SRC_URI[aarch64_netatalk.sha256sum] = "5d16ca7ff26d70a937c387830268b8cdb9709d2125bf6b67417e8f7800d35aa3"

URI_aarch64_netatalk-afptest = "${EPEL_MIRROR}/aarch64/Packages/n/netatalk-afptest-4.4.3-1.el10_2.aarch64.rpm;name=aarch64_netatalk-afptest;unpack=0"
SRC_URI:append = " ${URI_aarch64_netatalk-afptest}"
SRC_URI[aarch64_netatalk-afptest.sha256sum] = "11207ac2529fda6e94fe42ac53fe3c3649172375358a5cf5f51c3fb35e64daa0"

URI_aarch64_netatalk-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netatalk-devel-4.4.3-1.el10_2.aarch64.rpm;name=aarch64_netatalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netatalk-devel}"
SRC_URI[aarch64_netatalk-devel.sha256sum] = "35e8016bfdf0c54b0565938b64b40e6e8959f3df620bbd34942d341464ca7a57"

URI_aarch64_netatalk-doc = "${EPEL_MIRROR}/aarch64/Packages/n/netatalk-doc-4.4.3-1.el10_2.noarch.rpm;name=aarch64_netatalk-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_netatalk-doc}"
SRC_URI[aarch64_netatalk-doc.sha256sum] = "0f97cbc37380fc9219bad81b3731776fc74bcc7f4fe7567acd63a7a7175928f0"

RDEPENDS:netatalk = " \
 avahi-libs \
 bash \
 bstring \
 cracklib \
 dconf \
 glib2 \
 glibc \
 iniparser \
 krb5-libs \
 libacl \
 libdb \
 libevent \
 libgcrypt \
 libtalloc \
 libtirpc \
 libtracker-sparql \
 libxcrypt \
 mariadb-connector-c \
 openldap \
 pam-libs \
 perl-File-Basename \
 perl-File-Temp \
 perl-IO-Socket-IP \
 perl-IPC-Open3 \
 perl-Net-DBus \
 perl-PathTools \
 perl-Socket \
 perl-bignum \
 perl-interpreter \
 perl-libs \
 perl-vars \
 python3-dbus \
 sqlite-libs \
 systemd \
 "
RDEPENDS:netatalk-afptest = " \
 glibc \
 iniparser \
 netatalk \
 "
RDEPENDS:netatalk-devel = " \
 netatalk \
 "
RDEPENDS:netatalk-doc = " \
 "
