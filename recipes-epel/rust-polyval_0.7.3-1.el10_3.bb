# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-polyval"
PV = "0.7.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-polyval+default-devel \
 rust-polyval+hazmat-devel \
 rust-polyval+zeroize-devel \
 rust-polyval-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-polyval-0.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "197d30ba89bc2092012f85eb49474caea5c0c582d0ea90c800e6c2acc5a43edf"

URI_x86_64_v2_rust-polyval+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polyval+default-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polyval+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polyval+default-devel}"
SRC_URI[x86_64_v2_rust-polyval+default-devel.sha256sum] = "e18e26751863c4345c5891d79566606778c9276aaa4b4934211cc82461048b8d"

URI_x86_64_v2_rust-polyval+hazmat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polyval+hazmat-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polyval+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polyval+hazmat-devel}"
SRC_URI[x86_64_v2_rust-polyval+hazmat-devel.sha256sum] = "65fa2acc6a7632483adaea030b5336ea4106ce7a4948cd5a6786393c6792e09c"

URI_x86_64_v2_rust-polyval+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polyval+zeroize-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polyval+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polyval+zeroize-devel}"
SRC_URI[x86_64_v2_rust-polyval+zeroize-devel.sha256sum] = "a7e117a214fa29a8b987adc43510234fa77f8c6b63c166b17e20f1be6913d3a9"

URI_x86_64_v2_rust-polyval-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polyval-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polyval-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polyval-devel}"
SRC_URI[x86_64_v2_rust-polyval-devel.sha256sum] = "f0aa744d36221ccaa553b4faefa39eaaa87a6888799cc2937ce1367f8d4d166e"

URI_aarch64_rust-polyval+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polyval+default-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-polyval+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polyval+default-devel}"
SRC_URI[aarch64_rust-polyval+default-devel.sha256sum] = "b0c21a410ce541885e5b978debbecb43f87b38739778914181578a61c55698c9"

URI_aarch64_rust-polyval+hazmat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polyval+hazmat-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-polyval+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polyval+hazmat-devel}"
SRC_URI[aarch64_rust-polyval+hazmat-devel.sha256sum] = "704290e07f435c0fa2496155c6ae2e143a5c423c491503d41a375f8630a820bf"

URI_aarch64_rust-polyval+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polyval+zeroize-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-polyval+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polyval+zeroize-devel}"
SRC_URI[aarch64_rust-polyval+zeroize-devel.sha256sum] = "47867ff2276d3f74e4f9ac902f21edd73bf37d92668008f22d489b7f4228615e"

URI_aarch64_rust-polyval-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polyval-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-polyval-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polyval-devel}"
SRC_URI[aarch64_rust-polyval-devel.sha256sum] = "b1c1761c36254d2befe17025766c0353b0b13210193dbfabb647d831a8055e35"

RDEPENDS:rust-polyval+default-devel = " \
 cargo \
 rust-polyval-devel \
 "
RDEPENDS:rust-polyval+hazmat-devel = " \
 cargo \
 rust-polyval-devel \
 "
RDEPENDS:rust-polyval+zeroize-devel = " \
 cargo \
 rust-polyval-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-polyval-devel = " \
 cargo \
 rust \
 rust-cpubits+default-devel \
 rust-cpufeatures+default-devel \
 rust-universal-hash+default-devel \
 "
