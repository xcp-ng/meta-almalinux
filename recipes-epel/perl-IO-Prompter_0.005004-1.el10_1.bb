# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Prompter"
PV = "0.005004"
PR = "1.el10_1"
PACKAGES = " \
 perl-IO-Prompter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IO-Prompter-0.005004-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce90c2cf7cf31b71b491ef62b7e1e6b2c48a851e3c090f12b5984576939f45f4"

URI_x86_64_v2_perl-IO-Prompter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IO-Prompter-0.005004-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IO-Prompter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Prompter}"
SRC_URI[x86_64_v2_perl-IO-Prompter.sha256sum] = "033abe499679a8ad3699955765f97c551822ded32e07a013e0f578a105de9cfa"

URI_aarch64_perl-IO-Prompter = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IO-Prompter-0.005004-1.el10_1.noarch.rpm;name=aarch64_perl-IO-Prompter;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Prompter}"
SRC_URI[aarch64_perl-IO-Prompter.sha256sum] = "be5a1e3b5c454ebacd9cd2e982ca874b45ea541c7859b5954e729724f569b255"

RDEPENDS:perl-IO-Prompter = " \
 perl-Carp \
 perl-Contextual-Return \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-libs \
 perl-match-simple \
 "
