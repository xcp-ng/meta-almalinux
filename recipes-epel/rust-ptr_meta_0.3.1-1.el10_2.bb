# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ptr_meta"
PV = "0.3.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-ptr_meta+default-devel \
 rust-ptr_meta+derive-devel \
 rust-ptr_meta+ptr_meta_derive-devel \
 rust-ptr_meta+std-devel \
 rust-ptr_meta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ptr_meta-0.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "669f8773b49cbe06c179dd6cec8d745e82d5f7eb538795c374dc528cc9b178dd"

URI_x86_64_v2_rust-ptr_meta+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+default-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+default-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+default-devel.sha256sum] = "204fb5d8d22db12e90c9098aeaf3926618c7bc4a6b7b29c31ddae4675623a1f2"

URI_x86_64_v2_rust-ptr_meta+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+derive-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+derive-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+derive-devel.sha256sum] = "50920b9b59a4e5b1cc6526541439744c2c1df7d101425695905267ed5db56b19"

URI_x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+ptr_meta_derive-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel.sha256sum] = "317d76fe70b36e5dd1fea6390ab675326f712b431c7eb44b53805b44680d141e"

URI_x86_64_v2_rust-ptr_meta+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+std-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+std-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+std-devel.sha256sum] = "5764b6a6920d86787f455cc2abee32cc4efa9b070c8e1fcc139f5fe43cf31887"

URI_x86_64_v2_rust-ptr_meta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta-devel.sha256sum] = "3f4bc515afba8ad9c97a31e585402c7929693c27889c7e9f4fde27199f493d72"

URI_aarch64_rust-ptr_meta+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+default-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-ptr_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+default-devel}"
SRC_URI[aarch64_rust-ptr_meta+default-devel.sha256sum] = "9cc077f62ea33afe1011d198ac5a08f117495f5ba4091bfb81562e679c42d1a9"

URI_aarch64_rust-ptr_meta+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+derive-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-ptr_meta+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+derive-devel}"
SRC_URI[aarch64_rust-ptr_meta+derive-devel.sha256sum] = "19b135e96f939f89f1bc243e1bab035b347a69ee00ba3e2e17e768a4c6f9ce35"

URI_aarch64_rust-ptr_meta+ptr_meta_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+ptr_meta_derive-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-ptr_meta+ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+ptr_meta_derive-devel}"
SRC_URI[aarch64_rust-ptr_meta+ptr_meta_derive-devel.sha256sum] = "311d1f436064240bda4a946de427ca43fe19dffe9f6c46ae1ed58cb7a19f30f2"

URI_aarch64_rust-ptr_meta+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+std-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-ptr_meta+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+std-devel}"
SRC_URI[aarch64_rust-ptr_meta+std-devel.sha256sum] = "9300506e80b6ff8294dfafb0d5a5977c4cf4fae8b2d5633e60dc8fc96fe4da43"

URI_aarch64_rust-ptr_meta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-ptr_meta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta-devel}"
SRC_URI[aarch64_rust-ptr_meta-devel.sha256sum] = "e99d6342caedc697024faf379a729c26dfd3509aab84c2e9757c9f07d0ccbde3"

RDEPENDS:rust-ptr_meta+default-devel = " \
 cargo \
 rust-ptr_meta+derive-devel \
 rust-ptr_meta+std-devel \
 rust-ptr_meta-devel \
 "
RDEPENDS:rust-ptr_meta+derive-devel = " \
 cargo \
 rust-ptr_meta+ptr_meta_derive-devel \
 rust-ptr_meta-devel \
 "
RDEPENDS:rust-ptr_meta+ptr_meta_derive-devel = " \
 cargo \
 rust-ptr_meta-devel \
 rust-ptr_meta_derive-devel \
 "
RDEPENDS:rust-ptr_meta+std-devel = " \
 cargo \
 rust-ptr_meta-devel \
 "
RDEPENDS:rust-ptr_meta-devel = " \
 cargo \
 rust \
 "
