# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-json5"
PV = "0.12.0"
PR = "2.el10_0"
PACKAGES = " \
 pyjson5 \
 python3-json5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-json5-0.12.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28278ea16808d2ca1616687fd47c6d5363855c5adb17e59adc28800417f617c6"

URI_x86_64_v2_pyjson5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pyjson5-0.12.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pyjson5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyjson5}"
SRC_URI[x86_64_v2_pyjson5.sha256sum] = "d0082c9704fef127949c8e116bcd37696240d13aaff8d33dca8130738045ab0f"

URI_x86_64_v2_python3-json5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-json5-0.12.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-json5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-json5}"
SRC_URI[x86_64_v2_python3-json5.sha256sum] = "f1518956905df59c7deb3f3b63ac3581b91784d784fe2baee9e157e3eb8d9bfe"

URI_aarch64_pyjson5 = "${EPEL_MIRROR}/aarch64/Packages/p/pyjson5-0.12.0-2.el10_0.noarch.rpm;name=aarch64_pyjson5;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyjson5}"
SRC_URI[aarch64_pyjson5.sha256sum] = "f123b49de0b455dcf0ffa1cdaa2251ff0dd9614b2195d6c07602fb1fbeb5ad2e"

URI_aarch64_python3-json5 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-json5-0.12.0-2.el10_0.noarch.rpm;name=aarch64_python3-json5;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-json5}"
SRC_URI[aarch64_python3-json5.sha256sum] = "28f65c8876efb78f48515fef5f7f6489c9949e2d9507a666601072c1d88753fd"

RDEPENDS:pyjson5 = " \
 python3 \
 python3-json5 \
 "
RDEPENDS:python3-json5 = " \
 python3 \
 "
