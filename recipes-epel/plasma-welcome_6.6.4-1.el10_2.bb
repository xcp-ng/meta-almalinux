# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-welcome"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-welcome \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-welcome-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffceeacfd2da94158bf3b5d46eb8809f6af7ec18f6dc42c35dbdde73072936c4"

URI_x86_64_v2_plasma-welcome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-welcome-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-welcome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-welcome}"
SRC_URI[x86_64_v2_plasma-welcome.sha256sum] = "bd6f285853aebed20f4d9b9184b27eb0cdf6daf6ee4cfd3a1cde7641ff5072c4"

URI_aarch64_plasma-welcome = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-welcome-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-welcome;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-welcome}"
SRC_URI[aarch64_plasma-welcome.sha256sum] = "aacae67bf20ea722d8109821f1575be8c161d8c649349d564eaead1dd890ce1e"

RDEPENDS:plasma-welcome = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kuserfeedback \
 kf6-kwindowsystem \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
