# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-byte-unit"
PV = "5.2.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-byte-unit+bit-devel \
 rust-byte-unit+byte-devel \
 rust-byte-unit+default-devel \
 rust-byte-unit+rust_decimal-devel \
 rust-byte-unit+schemars-devel \
 rust-byte-unit+serde-devel \
 rust-byte-unit+std-devel \
 rust-byte-unit+u128-devel \
 rust-byte-unit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-byte-unit-5.2.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df6a3ba4dd5d3c5b9eea7271b5dad9811f0710c040c630ad2bb2208311aabfdb"

URI_x86_64_v2_rust-byte-unit+bit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+bit-devel-5.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+bit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+bit-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+bit-devel.sha256sum] = "3e15b0cf33f925d86d2ea269f28bb2f6268740e8012301ae4bab4692cce697d7"

URI_x86_64_v2_rust-byte-unit+byte-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+byte-devel-5.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+byte-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+byte-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+byte-devel.sha256sum] = "547b2b7b5db8f6cbfb6b1183f1fb2917181149a93a5e4dbedb2d5a1a3b0f12ad"

URI_x86_64_v2_rust-byte-unit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+default-devel-5.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+default-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+default-devel.sha256sum] = "c9057fccd99e7083ae8933c43c191ecd4ec0aa1d2027cded3fa61f949fdef5f9"

URI_x86_64_v2_rust-byte-unit+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+rust_decimal-devel-5.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+rust_decimal-devel.sha256sum] = "41aa4f2d5edc8b377130811923e5de72504ade6d68d5a14b6d093ad06d36916c"

URI_x86_64_v2_rust-byte-unit+schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+schemars-devel-5.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+schemars-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+schemars-devel.sha256sum] = "1945b2e625d16c5f1898d2d7d680d90aa8c85b17bdb46d9b8cc6ce954b1b88e9"

URI_x86_64_v2_rust-byte-unit+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+serde-devel-5.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+serde-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+serde-devel.sha256sum] = "3e72e8e143d10cc0a7639bb8aa3827516e05d829fbb93f546bf9bb42150941e8"

URI_x86_64_v2_rust-byte-unit+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+std-devel-5.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+std-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+std-devel.sha256sum] = "ad73e60aed2403570987c9d498fe43c510655fe8728fedaba2547bb2e9c27fe5"

URI_x86_64_v2_rust-byte-unit+u128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+u128-devel-5.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+u128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+u128-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+u128-devel.sha256sum] = "b404510e3aceb402db11ea1147a8b15865b9988fe82e93f79a997eaf0c30b500"

URI_x86_64_v2_rust-byte-unit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit-devel-5.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit-devel}"
SRC_URI[x86_64_v2_rust-byte-unit-devel.sha256sum] = "ae69b441f8acf4d938cab4e48a059acb2e133522ad600fa7f901728299c53917"

URI_aarch64_rust-byte-unit+bit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+bit-devel-5.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-byte-unit+bit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+bit-devel}"
SRC_URI[aarch64_rust-byte-unit+bit-devel.sha256sum] = "862ee15bfda8e63964487299958af3d5152652331d22038d3307edd1e93cc32d"

URI_aarch64_rust-byte-unit+byte-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+byte-devel-5.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-byte-unit+byte-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+byte-devel}"
SRC_URI[aarch64_rust-byte-unit+byte-devel.sha256sum] = "9f7b31e68ef5da58e86220bbafa3f89237db82bae888f90099ad7f72ef5fdda3"

URI_aarch64_rust-byte-unit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+default-devel-5.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-byte-unit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+default-devel}"
SRC_URI[aarch64_rust-byte-unit+default-devel.sha256sum] = "d3077252eec91f0ece490e0b8182dea9fb1e3bf8c76ce95b05ec24115a736c5a"

URI_aarch64_rust-byte-unit+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+rust_decimal-devel-5.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-byte-unit+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+rust_decimal-devel}"
SRC_URI[aarch64_rust-byte-unit+rust_decimal-devel.sha256sum] = "a6037be926e08bcc0d4156a9842023a29128e406ff7b4c8f65b928dcbccf5dec"

URI_aarch64_rust-byte-unit+schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+schemars-devel-5.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-byte-unit+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+schemars-devel}"
SRC_URI[aarch64_rust-byte-unit+schemars-devel.sha256sum] = "ed0eeaa6c6c3a60a49458e02843e43488b4ef6b382bcbaecc70d6f48e2893b3b"

URI_aarch64_rust-byte-unit+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+serde-devel-5.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-byte-unit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+serde-devel}"
SRC_URI[aarch64_rust-byte-unit+serde-devel.sha256sum] = "acfd546e561c88524c8b36b908d340eae6d4dae81f364707b26e01abaaf0a7f7"

URI_aarch64_rust-byte-unit+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+std-devel-5.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-byte-unit+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+std-devel}"
SRC_URI[aarch64_rust-byte-unit+std-devel.sha256sum] = "55b38cde3bd92e89728fd51751b025ebc05db621e8c762e0639ae555bb711444"

URI_aarch64_rust-byte-unit+u128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+u128-devel-5.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-byte-unit+u128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+u128-devel}"
SRC_URI[aarch64_rust-byte-unit+u128-devel.sha256sum] = "04a9dce17c405ada592671a594a0e8cb1158cb49343ca21064d08060de95699e"

URI_aarch64_rust-byte-unit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit-devel-5.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-byte-unit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit-devel}"
SRC_URI[aarch64_rust-byte-unit-devel.sha256sum] = "7fcf2b34b8db3cacfc7a9d6a126a8a6bb1d2bd658e6471c97fe5523c9ac43d7f"

RDEPENDS:rust-byte-unit+bit-devel = " \
 cargo \
 rust-byte-unit+rust_decimal-devel \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit+byte-devel = " \
 cargo \
 rust-byte-unit+rust_decimal-devel \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit+default-devel = " \
 cargo \
 rust-byte-unit+byte-devel \
 rust-byte-unit+std-devel \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit+rust_decimal-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-byte-unit+schemars-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-byte-unit+serde-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-byte-unit+std-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 rust-schemars+std-devel \
 rust-schemars-devel \
 rust-serde+alloc-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-byte-unit+u128-devel = " \
 cargo \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit-devel = " \
 cargo \
 rust \
 rust-utf8-width+default-devel \
 "
