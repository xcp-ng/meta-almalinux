# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Switch"
PV = "2.17"
PR = "33.el10_1"
PACKAGES = " \
 perl-Switch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Switch-2.17-33.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15cee21fd673e22683c7072a997943dbe34e735c7c1c285aede4d85f7405048a"

URI_x86_64_v2_perl-Switch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Switch-2.17-33.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Switch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Switch}"
SRC_URI[x86_64_v2_perl-Switch.sha256sum] = "9c93785c33a4ab23e05b86a353b6f54177a4ef7ef4892c27322baefa4364416b"

URI_aarch64_perl-Switch = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Switch-2.17-33.el10_1.noarch.rpm;name=aarch64_perl-Switch;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Switch}"
SRC_URI[aarch64_perl-Switch.sha256sum] = "fd470d089ae27612fdf331345dafa46f893f25da95a257360857dc49025bdf48"

RDEPENDS:perl-Switch = " \
 perl-Carp \
 perl-Filter \
 perl-Text-Balanced \
 perl-deprecate \
 perl-if \
 perl-libs \
 perl-overload \
 perl-vars \
 "
