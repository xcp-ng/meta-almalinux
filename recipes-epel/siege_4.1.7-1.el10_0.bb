# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "siege"
PV = "4.1.7"
PR = "1.el10_0"
PACKAGES = " \
 siege \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/siege-4.1.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d13bb66270fe657c6cdb273bd89cb52de82550dd29ca77627c7fe02492de738"

URI_x86_64_v2_siege = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/siege-4.1.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_siege;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_siege}"
SRC_URI[x86_64_v2_siege.sha256sum] = "aae7a46d2a3088133f515df858d06fe0508fdbcb06bc6388677beff6ad53c0b2"

URI_aarch64_siege = "${EPEL_MIRROR}/aarch64/Packages/s/siege-4.1.7-1.el10_0.aarch64.rpm;name=aarch64_siege;unpack=0"
SRC_URI:append = " ${URI_aarch64_siege}"
SRC_URI[aarch64_siege.sha256sum] = "daf39a65766b358697000f0b9c48c7a0741e0b20de8c214e3f277fa7861d4dea"

RDEPENDS:siege = " \
 bash \
 glibc \
 libjoedog \
 openssl-libs \
 perl-interpreter \
 zlib-ng-compat \
 "
