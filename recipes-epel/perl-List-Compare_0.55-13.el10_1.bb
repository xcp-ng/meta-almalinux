# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-List-Compare"
PV = "0.55"
PR = "13.el10_1"
PACKAGES = " \
 perl-List-Compare \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-List-Compare-0.55-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eee8b37d093e5230e01081223a4c3e3ca0a2ec21558454d66b026d509c6bb265"

URI_x86_64_v2_perl-List-Compare = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-List-Compare-0.55-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-List-Compare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-List-Compare}"
SRC_URI[x86_64_v2_perl-List-Compare.sha256sum] = "601bfe654e075ec611544d273326dd3e6a1c3e26696afeeeb1ecbb55899e9eae"

URI_aarch64_perl-List-Compare = "${EPEL_MIRROR}/aarch64/Packages/p/perl-List-Compare-0.55-13.el10_1.noarch.rpm;name=aarch64_perl-List-Compare;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-List-Compare}"
SRC_URI[aarch64_perl-List-Compare.sha256sum] = "068b30ff9e1cf4358094190f2cb25eb17684d3c8eadb76f9442b89516e271ec1"

RDEPENDS:perl-List-Compare = " \
 perl-Carp \
 perl-Exporter \
 perl-List-Compare \
 perl-libs \
 "
