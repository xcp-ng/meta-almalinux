# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-components-pom"
PV = "14.2"
PR = "6.el10_0"
PACKAGES = " \
 plexus-components-pom \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plexus-components-pom-14.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3382b4390fe8cac66ffa25c29c48f4509a209620ebac0d187765b080bfe5cb7"

URI_x86_64_v2_plexus-components-pom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plexus-components-pom-14.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_plexus-components-pom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-components-pom}"
SRC_URI[x86_64_v2_plexus-components-pom.sha256sum] = "548d1a08a0fb5fe9671d5026e5846c3ba4b0823c3d01cc45a38184044f89b88a"

URI_aarch64_plexus-components-pom = "${EPEL_MIRROR}/aarch64/Packages/p/plexus-components-pom-14.2-6.el10_0.noarch.rpm;name=aarch64_plexus-components-pom;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-components-pom}"
SRC_URI[aarch64_plexus-components-pom.sha256sum] = "0209ba360301239b8d1d3d62990a3eafc2e2962fbad21c991936ef93cde97c79"

RDEPENDS:plexus-components-pom = " \
 javapackages-filesystem \
 plexus-containers-component-metadata \
 plexus-pom \
 "
