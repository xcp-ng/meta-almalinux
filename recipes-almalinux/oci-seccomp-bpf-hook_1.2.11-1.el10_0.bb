# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oci-seccomp-bpf-hook"
PV = "1.2.11"
PR = "1.el10_0"
PACKAGES = " \
 oci-seccomp-bpf-hook \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/oci-seccomp-bpf-hook-1.2.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ae27bb2e65a159298c04b61e8afb29a1f84635d81eaa8f8aaab2625a4503192"

URI_x86_64_v2_oci-seccomp-bpf-hook = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/oci-seccomp-bpf-hook-1.2.11-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_oci-seccomp-bpf-hook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oci-seccomp-bpf-hook}"
SRC_URI[x86_64_v2_oci-seccomp-bpf-hook.sha256sum] = "bdc0abc7aba5f051fe0c464a40bc92b8e02be2b61e48f4d6315c6dcf3f2ab18d"

URI_aarch64_oci-seccomp-bpf-hook = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/oci-seccomp-bpf-hook-1.2.11-1.el10_0.aarch64.rpm;name=aarch64_oci-seccomp-bpf-hook;unpack=0"
SRC_URI:append = " ${URI_aarch64_oci-seccomp-bpf-hook}"
SRC_URI[aarch64_oci-seccomp-bpf-hook.sha256sum] = "b1ac0abd4e8cd520b17cbd1d3cbd553d6569cb89bde48e51cb086950ee9d69eb"

RDEPENDS:oci-seccomp-bpf-hook = " \
 bcc \
 glibc \
 libseccomp \
 "
