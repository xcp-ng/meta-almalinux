# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rend0.4"
PV = "0.4.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-rend0.4+bytecheck-devel \
 rust-rend0.4+bytemuck-devel \
 rust-rend0.4+default-devel \
 rust-rend0.4+std-devel \
 rust-rend0.4+validation-devel \
 rust-rend0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rend0.4-0.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfefc0f9f82f040a8c888ae4de35a9baf2275c358fb4280eec93eda1b3d803b6"

URI_x86_64_v2_rust-rend0.4+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend0.4+bytecheck-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend0.4+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend0.4+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rend0.4+bytecheck-devel.sha256sum] = "bd7b49b4e46e5c92359fd8bfa9e682fcdf52fe9fbcf62bc7ee1cc79a3116c855"

URI_x86_64_v2_rust-rend0.4+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend0.4+bytemuck-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend0.4+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend0.4+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-rend0.4+bytemuck-devel.sha256sum] = "36d33752e3b779f0723183851694911512266c7b16e5c6fd930f3a8141fd2c72"

URI_x86_64_v2_rust-rend0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend0.4+default-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend0.4+default-devel}"
SRC_URI[x86_64_v2_rust-rend0.4+default-devel.sha256sum] = "d01c6fe16b29fca08eb35912645458e60c5f9810ac3e775a34bb675453f2048e"

URI_x86_64_v2_rust-rend0.4+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend0.4+std-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend0.4+std-devel}"
SRC_URI[x86_64_v2_rust-rend0.4+std-devel.sha256sum] = "f364ed7609930ad5669de547a14e726985cba597d2d617c1288c09a5d3a1208d"

URI_x86_64_v2_rust-rend0.4+validation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend0.4+validation-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend0.4+validation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend0.4+validation-devel}"
SRC_URI[x86_64_v2_rust-rend0.4+validation-devel.sha256sum] = "3375791e64ba5375138784a31940f25f96ab19dc31a70ca9217aa78df77847bf"

URI_x86_64_v2_rust-rend0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend0.4-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend0.4-devel}"
SRC_URI[x86_64_v2_rust-rend0.4-devel.sha256sum] = "ba01afae154a52eec62e4ab84cd46dc0aa05bc454ad8996b2bfec99dd328d57b"

URI_aarch64_rust-rend0.4+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend0.4+bytecheck-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-rend0.4+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend0.4+bytecheck-devel}"
SRC_URI[aarch64_rust-rend0.4+bytecheck-devel.sha256sum] = "b60751f073bfb2b9223e0d671870d226024a5cb8fbd77f565017a16bd93a74b2"

URI_aarch64_rust-rend0.4+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend0.4+bytemuck-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-rend0.4+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend0.4+bytemuck-devel}"
SRC_URI[aarch64_rust-rend0.4+bytemuck-devel.sha256sum] = "e17df3902a473c747b2f418cce8eec837d245acf8b466b04257a7102f543761a"

URI_aarch64_rust-rend0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend0.4+default-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-rend0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend0.4+default-devel}"
SRC_URI[aarch64_rust-rend0.4+default-devel.sha256sum] = "960c893d9e066ca23cfc1414ea0b96938c9cb4871dcd147c03f510500e1c844a"

URI_aarch64_rust-rend0.4+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend0.4+std-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-rend0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend0.4+std-devel}"
SRC_URI[aarch64_rust-rend0.4+std-devel.sha256sum] = "82e57e0ba6b7a749f28e1f496dbb5e335e7591aa5be0a9a46365bfbed56ef675"

URI_aarch64_rust-rend0.4+validation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend0.4+validation-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-rend0.4+validation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend0.4+validation-devel}"
SRC_URI[aarch64_rust-rend0.4+validation-devel.sha256sum] = "29cc8c09ce82d933ce16ffe7b87d36b2534a1c90bc069b5cac8b2b778103625e"

URI_aarch64_rust-rend0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend0.4-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-rend0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend0.4-devel}"
SRC_URI[aarch64_rust-rend0.4-devel.sha256sum] = "c228cf3f1f76e961961e55396404eebda978d5952eebfae43ad4f9877151009d"

RDEPENDS:rust-rend0.4+bytecheck-devel = " \
 cargo \
 rust-bytecheck0.6-devel \
 rust-rend0.4-devel \
 "
RDEPENDS:rust-rend0.4+bytemuck-devel = " \
 cargo \
 rust-bytemuck+derive-devel \
 rust-bytemuck-devel \
 rust-rend0.4-devel \
 "
RDEPENDS:rust-rend0.4+default-devel = " \
 cargo \
 rust-rend0.4+std-devel \
 rust-rend0.4-devel \
 "
RDEPENDS:rust-rend0.4+std-devel = " \
 cargo \
 rust-bytecheck0.6+std-devel \
 rust-bytecheck0.6-devel \
 rust-rend0.4-devel \
 "
RDEPENDS:rust-rend0.4+validation-devel = " \
 cargo \
 rust-rend0.4+bytecheck-devel \
 rust-rend0.4-devel \
 "
RDEPENDS:rust-rend0.4-devel = " \
 cargo \
 "
