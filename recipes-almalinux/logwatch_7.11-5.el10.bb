# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "logwatch"
PV = "7.11"
PR = "5.el10"
PACKAGES = " \
 logwatch \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/logwatch-7.11-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "488d52823b7ad9f25554bf9184de195b54a6cbaa4084f859c7e33472e336e8bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/logwatch-7.11-5.el10.noarch.rpm;name=x86_64_v2_logwatch;unpack=0"
SRC_URI[x86_64_v2_logwatch.sha256sum] = "d659ccc962ae46c7afb94687a9b4319808114b97ea7a759068a0c30b7f598936"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/logwatch-7.11-5.el10.noarch.rpm;name=aarch64_logwatch;unpack=0"
SRC_URI[aarch64_logwatch.sha256sum] = "d659ccc962ae46c7afb94687a9b4319808114b97ea7a759068a0c30b7f598936"

RDEPENDS:logwatch = " \
 bash \
 crontabs \
 grep \
 perl-Date-Manip \
 perl-Errno \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-HTML-Parser \
 perl-POSIX \
 perl-PathTools \
 perl-Socket \
 perl-Time-Local \
 perl-URI \
 perl-diagnostics \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-subs \
 perl-vars \
 "
