# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-et"
PV = "0.20030606"
PR = "36.el10"
PACKAGES = " \
 hunspell-et \
 hyphen-et \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-et-0.20030606-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b93654425f4c20412e415e2ea49fbd418eb752516e0c03f4c00697f1fec07710"

URI_x86_64_v2_hunspell-et = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-et-0.20030606-36.el10.noarch.rpm;name=x86_64_v2_hunspell-et;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-et}"
SRC_URI[x86_64_v2_hunspell-et.sha256sum] = "4ffd1c67424d6215898eabbdecd88db54f3b79c87ce28eb9018158c9bf83aa7e"

URI_x86_64_v2_hyphen-et = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-et-0.20030606-36.el10.noarch.rpm;name=x86_64_v2_hyphen-et;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-et}"
SRC_URI[x86_64_v2_hyphen-et.sha256sum] = "fb4bbd09eb2d4fd2112e4835c8176e44504234f209f2a4d49cbec1f761e40bff"

URI_aarch64_hunspell-et = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-et-0.20030606-36.el10.noarch.rpm;name=aarch64_hunspell-et;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-et}"
SRC_URI[aarch64_hunspell-et.sha256sum] = "4ffd1c67424d6215898eabbdecd88db54f3b79c87ce28eb9018158c9bf83aa7e"

URI_aarch64_hyphen-et = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-et-0.20030606-36.el10.noarch.rpm;name=aarch64_hyphen-et;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-et}"
SRC_URI[aarch64_hyphen-et.sha256sum] = "fb4bbd09eb2d4fd2112e4835c8176e44504234f209f2a4d49cbec1f761e40bff"

RDEPENDS:hunspell-et = " \
 hunspell-filesystem \
 "
RDEPENDS:hyphen-et = " \
 hyphen \
 "
