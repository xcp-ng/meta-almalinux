# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sscg"
PV = "3.0.5"
PR = "12.el10"
PACKAGES = " \
 sscg \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sscg-3.0.5-12.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ac9681c664ea99dde34e382cb4fc5eb116bc70c0e2bc67d3897a94215ed9a2a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sscg-3.0.5-12.el10.x86_64_v2.rpm;name=x86_64_v2_sscg;unpack=0"
SRC_URI[x86_64_v2_sscg.sha256sum] = "b817c5fa0a78e1e5e998fe44df98b189515eb8ef2537b3d0f114dbefc01295b8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sscg-3.0.5-12.el10.aarch64.rpm;name=aarch64_sscg;unpack=0"
SRC_URI[aarch64_sscg.sha256sum] = "8e3331d0bf8ca057992aa8c4edfbac1978abb9c2ffd3885196561a772ae794fe"

RDEPENDS:sscg = " \
 glibc \
 libpath_utils \
 libtalloc \
 openssl-libs \
 popt \
 "
