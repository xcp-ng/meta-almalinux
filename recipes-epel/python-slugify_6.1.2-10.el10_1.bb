# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-slugify"
PV = "6.1.2"
PR = "10.el10_1"
PACKAGES = " \
 python3-slugify \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-slugify-6.1.2-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5bd1725efebe1ae89a6d851825e59be980313e182213bcc3d823a2b5d6106f1"

URI_x86_64_v2_python3-slugify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-slugify-6.1.2-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-slugify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-slugify}"
SRC_URI[x86_64_v2_python3-slugify.sha256sum] = "ab3e7235dd02b27da0c54ed54592aaf379b9b6dcd683f54cc31251b437264d51"

URI_aarch64_python3-slugify = "${EPEL_MIRROR}/aarch64/Packages/p/python3-slugify-6.1.2-10.el10_1.noarch.rpm;name=aarch64_python3-slugify;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-slugify}"
SRC_URI[aarch64_python3-slugify.sha256sum] = "a981428d13c6cb7b5ddeacf115fbbe6599144da49da0f80796399d6f37a9131d"

RDEPENDS:python3-slugify = " \
 python3 \
 python3-text-unidecode \
 "
