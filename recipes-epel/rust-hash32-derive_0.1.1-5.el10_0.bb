# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hash32-derive"
PV = "0.1.1"
PR = "5.el10_0"
PACKAGES = " \
 rust-hash32-derive+default-devel \
 rust-hash32-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hash32-derive-0.1.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "effb004b3084b6ba2ad1c65b67ba09bd31ee275b00d3fe2137116c8fa137531f"

URI_x86_64_v2_rust-hash32-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hash32-derive+default-devel-0.1.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hash32-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hash32-derive+default-devel}"
SRC_URI[x86_64_v2_rust-hash32-derive+default-devel.sha256sum] = "b596f5fbbc17afe66021a62fd5ab46ede7f2be9a5712be235ba3a2ef66297967"

URI_x86_64_v2_rust-hash32-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hash32-derive-devel-0.1.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hash32-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hash32-derive-devel}"
SRC_URI[x86_64_v2_rust-hash32-derive-devel.sha256sum] = "eb467ad66a39074195b86fed365c114f06f6d51bf2ff26e762cbb0df58e6d250"

URI_aarch64_rust-hash32-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hash32-derive+default-devel-0.1.1-5.el10_0.noarch.rpm;name=aarch64_rust-hash32-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hash32-derive+default-devel}"
SRC_URI[aarch64_rust-hash32-derive+default-devel.sha256sum] = "a820ff009212a4cbc5b34b43d7b37a81d241fcc4f4714b0ceeb43edd5172e0a4"

URI_aarch64_rust-hash32-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hash32-derive-devel-0.1.1-5.el10_0.noarch.rpm;name=aarch64_rust-hash32-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hash32-derive-devel}"
SRC_URI[aarch64_rust-hash32-derive-devel.sha256sum] = "a1ed5d07769e557e8bfb9f2e6246279f6985b02bc0a210b61e6b6dc01cd15210"

RDEPENDS:rust-hash32-derive+default-devel = " \
 cargo \
 rust-hash32-derive-devel \
 "
RDEPENDS:rust-hash32-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 "
