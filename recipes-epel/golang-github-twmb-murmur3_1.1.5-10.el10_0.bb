# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-twmb-murmur3"
PV = "1.1.5"
PR = "10.el10_0"
PACKAGES = " \
 golang-github-twmb-murmur3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-twmb-murmur3-1.1.5-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd63ff42cccc320bfa7d4e77d6ed41daf1220ac71340df9adf62e4d61b33a516"

URI_x86_64_v2_golang-github-twmb-murmur3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-twmb-murmur3-devel-1.1.5-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-twmb-murmur3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-twmb-murmur3-devel}"
SRC_URI[x86_64_v2_golang-github-twmb-murmur3-devel.sha256sum] = "a6959e5b8d41af124c6eb2208649c61960599abebcca5c977690de53d9c66165"

URI_aarch64_golang-github-twmb-murmur3-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-twmb-murmur3-devel-1.1.5-10.el10_0.noarch.rpm;name=aarch64_golang-github-twmb-murmur3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-twmb-murmur3-devel}"
SRC_URI[aarch64_golang-github-twmb-murmur3-devel.sha256sum] = "a83c517c0a88b36e190ebc4de8ead2fd6b6aab3fb841ac4b2dc2d0090467fc3e"

RDEPENDS:golang-github-twmb-murmur3-devel = " \
 go-filesystem \
 "
