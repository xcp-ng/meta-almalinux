# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gobuster"
PV = "3.8.2"
PR = "1.el10_2"
PACKAGES = " \
 gobuster \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gobuster-3.8.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aa0934012c4b8b5b42a83ba70e8f5237553617cedae1363d7eb5a614145140b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gobuster-3.8.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gobuster;unpack=0"
SRC_URI[x86_64_v2_gobuster.sha256sum] = "7c014f4dc898e07eb9b909958a918a6259794b90710987abeec34d6f26f74849"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gobuster-3.8.2-1.el10_2.aarch64.rpm;name=aarch64_gobuster;unpack=0"
SRC_URI[aarch64_gobuster.sha256sum] = "84453410b597b45a87952537ccedd7628be27ace52ffa8933346ad97969e80d8"

RDEPENDS:gobuster = " \
 glibc \
 "
