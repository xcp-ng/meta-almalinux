# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dhcpdump"
PV = "1.10"
PR = "1.el10_2"
PACKAGES = " \
 dhcpdump \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dhcpdump-1.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "592b3f8d3316c4f04751a824c651fb6c93b65b0db779504941bcd36a281acc88"

URI_x86_64_v2_dhcpdump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dhcpdump-1.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dhcpdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dhcpdump}"
SRC_URI[x86_64_v2_dhcpdump.sha256sum] = "28a09ea0ca4e96446424bacfc26101e6ad8d8916d4ab41e71c2b20dfcf9e8be6"

URI_aarch64_dhcpdump = "${EPEL_MIRROR}/aarch64/Packages/d/dhcpdump-1.10-1.el10_2.aarch64.rpm;name=aarch64_dhcpdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_dhcpdump}"
SRC_URI[aarch64_dhcpdump.sha256sum] = "39a966bef1cd80f58a06e0d1f9b81c95dcdb9445367a4f4ae65ec8b7f726fd82"

RDEPENDS:dhcpdump = " \
 glibc \
 libpcap \
 "
