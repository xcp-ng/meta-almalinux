# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "daala"
PV = "0^20250205git24f889a"
PR = "1.el10_1"
PACKAGES = " \
 daala-devel \
 daala-libs \
 daala-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/daala-0^20250205git24f889a-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e02a4e15fc65d2f1a36b05be1d437b6e002b0ec4c7b3331988e68f4d8b365b7"

URI_x86_64_v2_daala-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/daala-devel-0^20250205git24f889a-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_daala-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daala-devel}"
SRC_URI[x86_64_v2_daala-devel.sha256sum] = "ecdaff260b1ca5f79651ce60aeac307be983245e74338acc81d63a1592713efc"

URI_x86_64_v2_daala-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/daala-libs-0^20250205git24f889a-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_daala-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daala-libs}"
SRC_URI[x86_64_v2_daala-libs.sha256sum] = "ef202a463a7902d22523aa27b42521273c431f85c94b785461d334880d46c602"

URI_x86_64_v2_daala-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/daala-tools-0^20250205git24f889a-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_daala-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daala-tools}"
SRC_URI[x86_64_v2_daala-tools.sha256sum] = "47a945fd437462c92c14684e89e8c3c373f90030dd7920051ca19a3247214533"

URI_aarch64_daala-devel = "${EPEL_MIRROR}/aarch64/Packages/d/daala-devel-0^20250205git24f889a-1.el10_1.aarch64.rpm;name=aarch64_daala-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_daala-devel}"
SRC_URI[aarch64_daala-devel.sha256sum] = "2708bf5a53278c71cdd9e29d2f4b400deaace656a2ed3a6be8bdbc63ed51b09e"

URI_aarch64_daala-libs = "${EPEL_MIRROR}/aarch64/Packages/d/daala-libs-0^20250205git24f889a-1.el10_1.aarch64.rpm;name=aarch64_daala-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_daala-libs}"
SRC_URI[aarch64_daala-libs.sha256sum] = "0fc13f54606cc15a179e7dd226beaae45853cbf53cb75b3e607d1e7e685e1246"

URI_aarch64_daala-tools = "${EPEL_MIRROR}/aarch64/Packages/d/daala-tools-0^20250205git24f889a-1.el10_1.aarch64.rpm;name=aarch64_daala-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_daala-tools}"
SRC_URI[aarch64_daala-tools.sha256sum] = "b86b23de349c8db4d75716bb0d66ef961d2ffdd31f9cfba6de54fe576fb49e4c"

RDEPENDS:daala-devel = " \
 daala-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:daala-libs = " \
 glibc \
 "
RDEPENDS:daala-tools = " \
 daala-libs \
 glibc \
 libgcc \
 libgomp \
 libjpeg-turbo \
 libogg \
 libpng \
 "
