# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitstream-io"
PV = "4.9.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-bitstream-io+alloc-devel \
 rust-bitstream-io+default-devel \
 rust-bitstream-io+std-devel \
 rust-bitstream-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bitstream-io-4.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2581817a334894bf8332b7efba0ca2fae0624bd9a42ae74723e9bf4d2c47d211"

URI_x86_64_v2_rust-bitstream-io+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io+alloc-devel-4.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io+alloc-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io+alloc-devel.sha256sum] = "d87b9ed45183b4e90c47e77be755e2ca80150efb6c74e288c9976c775214f79c"

URI_x86_64_v2_rust-bitstream-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io+default-devel-4.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io+default-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io+default-devel.sha256sum] = "8e70273eb3c7fe5672d3aa23a7ca8594f9eaae978d8f775b6aabc257345b4408"

URI_x86_64_v2_rust-bitstream-io+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io+std-devel-4.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io+std-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io+std-devel.sha256sum] = "8284fc4448fae62cdf93b889836efa465070be239bd0279e03ab773e739a6b3b"

URI_x86_64_v2_rust-bitstream-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io-devel-4.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io-devel.sha256sum] = "905c8f0d181456bcd010281ba582dfe058b39637a56279098e4b224c4732849b"

URI_aarch64_rust-bitstream-io+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io+alloc-devel-4.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-bitstream-io+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io+alloc-devel}"
SRC_URI[aarch64_rust-bitstream-io+alloc-devel.sha256sum] = "9ac8c7657666b2fc5bd81938921f7529568656ee42736ce21ee5b388f2079032"

URI_aarch64_rust-bitstream-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io+default-devel-4.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-bitstream-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io+default-devel}"
SRC_URI[aarch64_rust-bitstream-io+default-devel.sha256sum] = "a05488378963f0d6a5f1978c9e1611eccf9511e9e58bb33185e10eb488f809d0"

URI_aarch64_rust-bitstream-io+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io+std-devel-4.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-bitstream-io+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io+std-devel}"
SRC_URI[aarch64_rust-bitstream-io+std-devel.sha256sum] = "40d47bdaddf97a9730a133fb68a10e11295a57f68963987c24bbba9d083eb07c"

URI_aarch64_rust-bitstream-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io-devel-4.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-bitstream-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io-devel}"
SRC_URI[aarch64_rust-bitstream-io-devel.sha256sum] = "68cadf6cdf39f1c784c33bccc2e58e913f32f3f0853414341d0e14ef2b3f121a"

RDEPENDS:rust-bitstream-io+alloc-devel = " \
 cargo \
 rust-bitstream-io-devel \
 rust-core2+alloc-devel \
 "
RDEPENDS:rust-bitstream-io+default-devel = " \
 cargo \
 rust-bitstream-io+std-devel \
 rust-bitstream-io-devel \
 "
RDEPENDS:rust-bitstream-io+std-devel = " \
 cargo \
 rust-bitstream-io+alloc-devel \
 rust-bitstream-io-devel \
 rust-core2+std-devel \
 "
RDEPENDS:rust-bitstream-io-devel = " \
 cargo \
 rust \
 rust-core2-devel \
 "
