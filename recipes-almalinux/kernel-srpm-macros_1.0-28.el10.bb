# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kernel-srpm-macros"
PV = "1.0"
PR = "28.el10"
PACKAGES = " \
 kernel-rpm-macros \
 kernel-srpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/kernel-srpm-macros-1.0-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f8d40806619521a229bdc55c6ce4928be5af1085c2923136b4d152bfacbf830"

URI_x86_64_v2_kernel-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-rpm-macros-205-28.el10.noarch.rpm;name=x86_64_v2_kernel-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-rpm-macros}"
SRC_URI[x86_64_v2_kernel-rpm-macros.sha256sum] = "d6e08458a631754b5b57dcb601a7132783958dd85f8fd750043ea30512d25683"

URI_x86_64_v2_kernel-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-srpm-macros-1.0-28.el10.noarch.rpm;name=x86_64_v2_kernel-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-srpm-macros}"
SRC_URI[x86_64_v2_kernel-srpm-macros.sha256sum] = "2779b47d624953b0d4d882a07b0349ec84014de594f3d28756506c66c1acd4ee"

URI_aarch64_kernel-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-rpm-macros-205-28.el10.noarch.rpm;name=aarch64_kernel-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-rpm-macros}"
SRC_URI[aarch64_kernel-rpm-macros.sha256sum] = "d6e08458a631754b5b57dcb601a7132783958dd85f8fd750043ea30512d25683"

URI_aarch64_kernel-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-srpm-macros-1.0-28.el10.noarch.rpm;name=aarch64_kernel-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-srpm-macros}"
SRC_URI[aarch64_kernel-srpm-macros.sha256sum] = "2779b47d624953b0d4d882a07b0349ec84014de594f3d28756506c66c1acd4ee"

RDEPENDS:kernel-rpm-macros = " \
 bash \
 binutils \
 findutils \
 gawk \
 grep \
 kmod \
 perl-interpreter \
 redhat-rpm-config \
 sed \
 xz \
 "
RDEPENDS:kernel-srpm-macros = " \
 "
