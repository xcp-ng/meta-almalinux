# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-extras"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kio-extras \
 kio-extras-devel \
 kio-extras-info \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kio-extras-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e1bc921747608f999ff2fee519c4f8d6f88d7111f32ee64fcf8caaf4cc1cf084"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-extras-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-extras;unpack=0"
SRC_URI[x86_64_v2_kio-extras.sha256sum] = "8d98b9ae096fb9bcce43756cfb9d63592c15688f47871b606c1e93caa91dba10"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-extras-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-extras-devel;unpack=0"
SRC_URI[x86_64_v2_kio-extras-devel.sha256sum] = "f320ce508c84ff337940354d450d8112b6ecb1097ea9a8dcf18f977fb2b9d14b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-extras-info-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-extras-info;unpack=0"
SRC_URI[x86_64_v2_kio-extras-info.sha256sum] = "78586e5277280eee990c972acf7c85eb89e13c1d255d021898b9bc571453c377"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kio-extras-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kio-extras;unpack=0"
SRC_URI[aarch64_kio-extras.sha256sum] = "c8a90f6e668d4cc47628c058c251a3d943388d867c189c79bc3d3266137bd100"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kio-extras-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kio-extras-devel;unpack=0"
SRC_URI[aarch64_kio-extras-devel.sha256sum] = "e992ebfe49804f771af55c0b455d0c16e3b765710227f6ad846f905e36869d96"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kio-extras-info-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kio-extras-info;unpack=0"
SRC_URI[aarch64_kio-extras-info.sha256sum] = "d91df5360633f7efc2c0c64bcf279ecbb6d2c13250ff48a190855be06396a4bb"

RDEPENDS:kio-extras = " \
 bash \
 glibc \
 kdsoap-ws-discovery-client \
 kdsoap6 \
 kf6-karchive \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-solid \
 kf6-syntax-highlighting \
 libXcursor \
 libgcc \
 libimobiledevice \
 libkexiv2-qt6 \
 libmtp \
 libplist \
 libproxy \
 libsmbclient \
 libssh \
 libstdc++ \
 libtirpc \
 openexr-libs \
 plasma-activities \
 plasma-activities-stats \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 taglib \
 "
RDEPENDS:kio-extras-devel = " \
 cmake-filesystem \
 kio-extras \
 "
RDEPENDS:kio-extras-info = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 "
