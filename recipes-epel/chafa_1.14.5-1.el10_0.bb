# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chafa"
PV = "1.14.5"
PR = "1.el10_0"
PACKAGES = " \
 chafa \
 chafa-devel \
 chafa-doc \
 chafa-libs \
 chafa-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/chafa-1.14.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26ef4e8752c6457b087fb997868c9e401ab6b63a056c329b285606f6bf550e2e"

URI_x86_64_v2_chafa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chafa-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chafa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chafa}"
SRC_URI[x86_64_v2_chafa.sha256sum] = "298814d32a437ce1f944988d96a87d267c383035617295528b75c376593e92de"

URI_x86_64_v2_chafa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chafa-devel-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chafa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chafa-devel}"
SRC_URI[x86_64_v2_chafa-devel.sha256sum] = "1ce8832de66937940304326d112322fdc56ff7c2fc02a6f63d5605b775b89e1d"

URI_x86_64_v2_chafa-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chafa-doc-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chafa-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chafa-doc}"
SRC_URI[x86_64_v2_chafa-doc.sha256sum] = "6a8f4e8eca7790432117172c55538f072cacde33478d208e6d88fc093b259d40"

URI_x86_64_v2_chafa-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chafa-libs-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chafa-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chafa-libs}"
SRC_URI[x86_64_v2_chafa-libs.sha256sum] = "17d4c71fc7407a14485a986f2a2ef4221fb8de19497b17c93a015126e335d617"

URI_x86_64_v2_chafa-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chafa-static-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chafa-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chafa-static}"
SRC_URI[x86_64_v2_chafa-static.sha256sum] = "528a4f4ddb440d15f9208ec6a6f494d27448f6195b34063d3f3af087a4740e48"

URI_aarch64_chafa = "${EPEL_MIRROR}/aarch64/Packages/c/chafa-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_chafa;unpack=0"
SRC_URI:append = " ${URI_aarch64_chafa}"
SRC_URI[aarch64_chafa.sha256sum] = "3c76a54b49c71285bf2b1ec487dd8b98944a96e4055530a96e564b9f36bf0f2d"

URI_aarch64_chafa-devel = "${EPEL_MIRROR}/aarch64/Packages/c/chafa-devel-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_chafa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_chafa-devel}"
SRC_URI[aarch64_chafa-devel.sha256sum] = "7a7e80692669daad2219253aa3ef8a3ff3155ee9c23a8838cd22a771927eb8ba"

URI_aarch64_chafa-doc = "${EPEL_MIRROR}/aarch64/Packages/c/chafa-doc-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_chafa-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_chafa-doc}"
SRC_URI[aarch64_chafa-doc.sha256sum] = "90688b776327a6721c12bb410e3a48f9a4c7fcb2613f90004333a18cd5270e01"

URI_aarch64_chafa-libs = "${EPEL_MIRROR}/aarch64/Packages/c/chafa-libs-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_chafa-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_chafa-libs}"
SRC_URI[aarch64_chafa-libs.sha256sum] = "090274a0c5614adb08ea7ea526369c62e6af2161ca5235245b3ef90f7024b8fd"

URI_aarch64_chafa-static = "${EPEL_MIRROR}/aarch64/Packages/c/chafa-static-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_chafa-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_chafa-static}"
SRC_URI[aarch64_chafa-static.sha256sum] = "e486ec2a4bc65d2c716565fed42d544ef1499c0308cb42603ff788c204a5ade4"

RDEPENDS:chafa = " \
 cairo \
 chafa-libs \
 freetype \
 glib2 \
 glibc \
 libavif \
 libjpeg-turbo \
 librsvg2 \
 libtiff \
 libwebp \
 "
RDEPENDS:chafa-devel = " \
 chafa-libs \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:chafa-doc = " \
 "
RDEPENDS:chafa-libs = " \
 glib2 \
 glibc \
 "
RDEPENDS:chafa-static = " \
 "
