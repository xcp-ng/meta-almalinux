# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-metadata"
PV = "0.2.5"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-metadata \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-metadata-0.2.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52c597b2998d425f9330a2c673333d51ea33d5b6e9c81f7759bf7d7ed9d70010"

URI_x86_64_v2_python3-colcon-metadata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-metadata-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-metadata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-metadata}"
SRC_URI[x86_64_v2_python3-colcon-metadata.sha256sum] = "def29183db35811d4e6fd290d5b22460d2079b6fed74319321214ada7dc5a459"

URI_aarch64_python3-colcon-metadata = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-metadata-0.2.5-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-metadata;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-metadata}"
SRC_URI[aarch64_python3-colcon-metadata.sha256sum] = "d2e68c81c01ac0ee646675a20df8a1f1f2fadb8815d5709e12db5b65b522dff3"

RDEPENDS:python3-colcon-metadata = " \
 python3 \
 python3-colcon-core \
 python3-pyyaml \
 "
