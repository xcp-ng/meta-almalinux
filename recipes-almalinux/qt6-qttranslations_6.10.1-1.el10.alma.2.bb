# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qttranslations"
PV = "6.10.1"
PR = "1.el10.alma.2"
PACKAGES = " \
 qt6-qttranslations \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qttranslations-6.10.1-1.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ecf52aabcd08d393a9986dc34aa3c15178358064a50c746378c303ad5dcd535"

URI_x86_64_v2_qt6-qttranslations = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttranslations-6.10.1-1.el10.alma.2.noarch.rpm;name=x86_64_v2_qt6-qttranslations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttranslations}"
SRC_URI[x86_64_v2_qt6-qttranslations.sha256sum] = "1908fec278521b04d5ec4eecf62642a4b0676eb70c4bfedf3ea6102d557dc271"

URI_aarch64_qt6-qttranslations = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttranslations-6.10.1-1.el10.alma.2.noarch.rpm;name=aarch64_qt6-qttranslations;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttranslations}"
SRC_URI[aarch64_qt6-qttranslations.sha256sum] = "1908fec278521b04d5ec4eecf62642a4b0676eb70c4bfedf3ea6102d557dc271"

RDEPENDS:qt6-qttranslations = " \
 "
