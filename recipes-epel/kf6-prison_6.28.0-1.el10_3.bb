# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-prison"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-prison \
 kf6-prison-devel \
 kf6-prison-doc \
 kf6-prison-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-prison-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "815936d900471c9eec77b5d68df407986d2ce1460a294fbb664ec8517cf436a3"

URI_x86_64_v2_kf6-prison = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-prison;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison}"
SRC_URI[x86_64_v2_kf6-prison.sha256sum] = "b55cfb03a69cb0aa6c75a3bc8f0b718ac8a8f9adf084eadf09ad1bb4f3d432f4"

URI_x86_64_v2_kf6-prison-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-prison-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison-devel}"
SRC_URI[x86_64_v2_kf6-prison-devel.sha256sum] = "aae388a1d7f6c74c90f1a40364064204ec4864efbf35c82672831f3ba3bfe9f9"

URI_x86_64_v2_kf6-prison-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-prison-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison-doc}"
SRC_URI[x86_64_v2_kf6-prison-doc.sha256sum] = "a51a3c26da017f87c466034d9312e2883ab27523b43f9e595944733b112413f1"

URI_x86_64_v2_kf6-prison-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-prison-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison-html}"
SRC_URI[x86_64_v2_kf6-prison-html.sha256sum] = "d663388ff42ee5e32037e6f36dce9a193036e339580dca8f6db8a98652ade838"

URI_aarch64_kf6-prison = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-prison;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison}"
SRC_URI[aarch64_kf6-prison.sha256sum] = "aea21a1c3f8d93707de487d0bae34d90286c73a6db1528b259be14e6aa0ee6e6"

URI_aarch64_kf6-prison-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-prison-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison-devel}"
SRC_URI[aarch64_kf6-prison-devel.sha256sum] = "70159f6a916af18d9a0c3ee3c8b0e52f6d02350d0f385c4167a95449cb36d457"

URI_aarch64_kf6-prison-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-prison-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison-doc}"
SRC_URI[aarch64_kf6-prison-doc.sha256sum] = "e6afc18bfc8888affa5b0b81679cb8ddd8e8aec5a36028b99fc94eba7374680d"

URI_aarch64_kf6-prison-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-prison-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison-html}"
SRC_URI[aarch64_kf6-prison-html.sha256sum] = "c02c8ca5980cd94522a9c92f952dc0576bfe314f28d37ae8d5fa2ab10ee92b4a"

RDEPENDS:kf6-prison = " \
 glibc \
 kf6-filesystem \
 libdmtx \
 libgcc \
 libstdc++ \
 qrencode-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 zxing-cpp \
 "
RDEPENDS:kf6-prison-devel = " \
 cmake-filesystem \
 kf6-prison \
 "
RDEPENDS:kf6-prison-doc = " \
 "
RDEPENDS:kf6-prison-html = " \
 "
