# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kirigami"
PV = "6.12.0"
PR = "2.el10_0"
PACKAGES = " \
 kf6-kirigami \
 kf6-kirigami-devel \
 kf6-kirigami-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kirigami-6.12.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b365c57e402dbd206d7acb697b695ac7f0839226088473b78a5064d040137cf"

URI_x86_64_v2_kf6-kirigami = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-6.12.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami}"
SRC_URI[x86_64_v2_kf6-kirigami.sha256sum] = "82254bf3460822773111420381a02d5573ecbb20d0fc62454b8767bf4e9653a0"

URI_x86_64_v2_kf6-kirigami-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-devel-6.12.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-devel}"
SRC_URI[x86_64_v2_kf6-kirigami-devel.sha256sum] = "213af845de2c7ebcf94f3704517c00dcc10c14d40f16446daa10cca738425dff"

URI_x86_64_v2_kf6-kirigami-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-doc-6.12.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kirigami-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-doc}"
SRC_URI[x86_64_v2_kf6-kirigami-doc.sha256sum] = "98c3649debcaf8aaac07a27c8654c62bab661fb85090a8e4f7def81c3f389f82"

URI_aarch64_kf6-kirigami = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-6.12.0-2.el10_0.aarch64.rpm;name=aarch64_kf6-kirigami;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami}"
SRC_URI[aarch64_kf6-kirigami.sha256sum] = "8271b2e00d6c0e67bc502147563c3d84175b8e402af09ba5a369e9707658cb3c"

URI_aarch64_kf6-kirigami-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-devel-6.12.0-2.el10_0.aarch64.rpm;name=aarch64_kf6-kirigami-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-devel}"
SRC_URI[aarch64_kf6-kirigami-devel.sha256sum] = "4cad58bb254322b4ba38d8e50357aa29e25c398daba967f3c622cb13dee7659c"

URI_aarch64_kf6-kirigami-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-doc-6.12.0-2.el10_0.noarch.rpm;name=aarch64_kf6-kirigami-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-doc}"
SRC_URI[aarch64_kf6-kirigami-doc.sha256sum] = "4302f27eda3f2b9ffbc6cde71f975b72ad6fde54ea05a18806a0ac7e5c6e0403"

RDEPENDS:kf6-kirigami = " \
 glibc \
 libgomp \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kirigami-devel = " \
 cmake-filesystem \
 kf6-kirigami \
 "
RDEPENDS:kf6-kirigami-doc = " \
 "
