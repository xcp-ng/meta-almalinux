# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-isal"
PV = "1.8.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-isal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-isal-1.8.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "998c358c01b38d062842e41a5a1a4c9bcce37ab36a9d5f7be390c41c7da1d9a3"

URI_x86_64_v2_python3-isal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-isal-1.8.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-isal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-isal}"
SRC_URI[x86_64_v2_python3-isal.sha256sum] = "44b68b0a1f2cd0c1f26bfb58b870a6afc888b1f6d79c7854bc134c3fb04e4084"

URI_aarch64_python3-isal = "${EPEL_MIRROR}/aarch64/Packages/p/python3-isal-1.8.0-1.el10_1.aarch64.rpm;name=aarch64_python3-isal;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-isal}"
SRC_URI[aarch64_python3-isal.sha256sum] = "bceda7713b13ce440a82b9ebba301e4915130eb817a5ee73b3b9d26534bce4de"

RDEPENDS:python3-isal = " \
 glibc \
 isa-l \
 python3 \
 "
