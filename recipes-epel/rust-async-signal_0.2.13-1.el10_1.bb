# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-signal"
PV = "0.2.13"
PR = "1.el10_1"
PACKAGES = " \
 rust-async-signal+default-devel \
 rust-async-signal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-signal-0.2.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1724ebd572f4896e917597af973735b8d098b5f4584a63379c17eb0c8b6dae9"

URI_x86_64_v2_rust-async-signal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-signal+default-devel-0.2.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-signal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-signal+default-devel}"
SRC_URI[x86_64_v2_rust-async-signal+default-devel.sha256sum] = "200c25f20e17bc6f5afc63c94a8c5931f39633d226688936a4a807b578a68f67"

URI_x86_64_v2_rust-async-signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-signal-devel-0.2.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-signal-devel}"
SRC_URI[x86_64_v2_rust-async-signal-devel.sha256sum] = "5de9e0195b37dccfde87bf0fd1f56276851a8f521d0effc910d73860b5cc8468"

URI_aarch64_rust-async-signal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-signal+default-devel-0.2.13-1.el10_1.noarch.rpm;name=aarch64_rust-async-signal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-signal+default-devel}"
SRC_URI[aarch64_rust-async-signal+default-devel.sha256sum] = "cfdef1dec8924951845abcea3e31c3b2a43c46f8434fcdd6ee10acca5a98292c"

URI_aarch64_rust-async-signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-signal-devel-0.2.13-1.el10_1.noarch.rpm;name=aarch64_rust-async-signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-signal-devel}"
SRC_URI[aarch64_rust-async-signal-devel.sha256sum] = "dba3fb4d08a74644a3060b9f62a905acf93c80f4cb8acfd5a3b7b45012a94dfd"

RDEPENDS:rust-async-signal+default-devel = " \
 cargo \
 rust-async-signal-devel \
 "
RDEPENDS:rust-async-signal-devel = " \
 cargo \
 rust \
 rust-async-io+default-devel \
 rust-cfg-if+default-devel \
 rust-futures-core+default-devel \
 rust-futures-io+default-devel \
 rust-rustix+process-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-signal-hook-registry+default-devel \
 "
