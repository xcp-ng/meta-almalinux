# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "foomuuri"
PV = "0.31"
PR = "1.el10_1"
PACKAGES = " \
 foomuuri \
 foomuuri-firewalld \
 foomuuri_exporter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/foomuuri-0.31-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40033c72f59738613ca5216c7f677779dd393877598c132a78a169fecfe78253"

URI_x86_64_v2_foomuuri = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foomuuri-0.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_foomuuri;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foomuuri}"
SRC_URI[x86_64_v2_foomuuri.sha256sum] = "09fbc55884069aa55807b5a7d95a0014ef16286618ff1a3216cf58ad69f3c23a"

URI_x86_64_v2_foomuuri-firewalld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foomuuri-firewalld-0.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_foomuuri-firewalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foomuuri-firewalld}"
SRC_URI[x86_64_v2_foomuuri-firewalld.sha256sum] = "fc8868fecb52d96c809df43f7a3a695779c97260c29b2142e4f765c899df8005"

URI_x86_64_v2_foomuuri_exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foomuuri_exporter-0.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_foomuuri_exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foomuuri_exporter}"
SRC_URI[x86_64_v2_foomuuri_exporter.sha256sum] = "899cebae7965b3187ac8ae89c1ed87913415b1c89486812042d55702e49ba50e"

URI_aarch64_foomuuri = "${EPEL_MIRROR}/aarch64/Packages/f/foomuuri-0.31-1.el10_1.noarch.rpm;name=aarch64_foomuuri;unpack=0"
SRC_URI:append = " ${URI_aarch64_foomuuri}"
SRC_URI[aarch64_foomuuri.sha256sum] = "a6d96ae5b4fda3e5ca0ffa9052ff88ad0f17370f1ce5bd9023d5af9fb67ae44e"

URI_aarch64_foomuuri-firewalld = "${EPEL_MIRROR}/aarch64/Packages/f/foomuuri-firewalld-0.31-1.el10_1.noarch.rpm;name=aarch64_foomuuri-firewalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_foomuuri-firewalld}"
SRC_URI[aarch64_foomuuri-firewalld.sha256sum] = "54719125236c4722d3a336157c598716601b2c35e4200a377abc49132d14084f"

URI_aarch64_foomuuri_exporter = "${EPEL_MIRROR}/aarch64/Packages/f/foomuuri_exporter-0.31-1.el10_1.noarch.rpm;name=aarch64_foomuuri_exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_foomuuri_exporter}"
SRC_URI[aarch64_foomuuri_exporter.sha256sum] = "53a4a1373cca4defc17535efbfd509c97f87934fe2a283e8acce77cf4b6c645f"

RDEPENDS:foomuuri = " \
 bash \
 nftables \
 python3 \
 python3-dbus \
 python3-gobject \
 python3-systemd \
 systemd \
 "
RDEPENDS:foomuuri-firewalld = " \
 foomuuri \
 "
RDEPENDS:foomuuri_exporter = " \
 bash \
 python3 \
 python3-prometheus_client \
 "
