# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluefish"
PV = "2.4.2"
PR = "1.el10_3"
PACKAGES = " \
 bluefish \
 bluefish-shared-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bluefish-2.4.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97d661522a3974567066dfbe439ed936feecbb7ea98252243c07c7758a89aa70"

URI_x86_64_v2_bluefish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluefish-2.4.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluefish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluefish}"
SRC_URI[x86_64_v2_bluefish.sha256sum] = "18b84c542cd8d6107af7f77e9c5a4c389bc55c9847c2ed44b6d49b671d7ebffd"

URI_x86_64_v2_bluefish-shared-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluefish-shared-data-2.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_bluefish-shared-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluefish-shared-data}"
SRC_URI[x86_64_v2_bluefish-shared-data.sha256sum] = "526f2be5b10058a3d198e5a1338e56ad3cfa02e756e0871d62021fb8242499a4"

URI_aarch64_bluefish = "${EPEL_MIRROR}/aarch64/Packages/b/bluefish-2.4.2-1.el10_3.aarch64.rpm;name=aarch64_bluefish;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluefish}"
SRC_URI[aarch64_bluefish.sha256sum] = "863235bd0a5764a5f4dfb785301adcdec8fa33537a9d529939ef7984b8258eeb"

URI_aarch64_bluefish-shared-data = "${EPEL_MIRROR}/aarch64/Packages/b/bluefish-shared-data-2.4.2-1.el10_3.noarch.rpm;name=aarch64_bluefish-shared-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluefish-shared-data}"
SRC_URI[aarch64_bluefish-shared-data.sha256sum] = "3f7b31e8d124a834967b61133aefe0d8bac70a64230c9caf4da743682dfe97a8"

RDEPENDS:bluefish = " \
 atk \
 bluefish-shared-data \
 cairo \
 cairo-gobject \
 enchant2 \
 findutils \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 grep \
 gtk3 \
 gucharmap-libs \
 harfbuzz \
 libxml2 \
 pango \
 pcre2 \
 python3-libs \
 xml-common \
 "
RDEPENDS:bluefish-shared-data = " \
 bash \
 bluefish \
 python3 \
 "
