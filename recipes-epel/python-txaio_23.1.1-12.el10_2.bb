# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-txaio"
PV = "23.1.1"
PR = "12.el10_2"
PACKAGES = " \
 python-txaio-doc \
 python3-txaio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-txaio-23.1.1-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce2e7fec232cbc135787bb7db5f505c40b352dd1ecc4f7a22c72b9109988dc91"

URI_x86_64_v2_python-txaio-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-txaio-doc-23.1.1-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-txaio-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-txaio-doc}"
SRC_URI[x86_64_v2_python-txaio-doc.sha256sum] = "1a0da3fb04e0f630eda63962d4e82bc98ec12b60bd8a2889cf342d9b73284f1a"

URI_x86_64_v2_python3-txaio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-txaio-23.1.1-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-txaio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-txaio}"
SRC_URI[x86_64_v2_python3-txaio.sha256sum] = "80695850ef706d5c408d721fee0420d28c6ae5c30639dff24456e4cabde4ac48"

URI_aarch64_python-txaio-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-txaio-doc-23.1.1-12.el10_2.noarch.rpm;name=aarch64_python-txaio-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-txaio-doc}"
SRC_URI[aarch64_python-txaio-doc.sha256sum] = "35ab8c9231942dd8168d6a9fc6d7886ef6d53ab3c9017d1842a73d82efb47630"

URI_aarch64_python3-txaio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-txaio-23.1.1-12.el10_2.noarch.rpm;name=aarch64_python3-txaio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-txaio}"
SRC_URI[aarch64_python3-txaio.sha256sum] = "6c550f21bb2f2aa61146d967b7e6e48010ccff0dd491bc0cab33fc4cc3aea207"

RDEPENDS:python-txaio-doc = " \
 js-jquery \
 "
RDEPENDS:python3-txaio = " \
 python3 \
 python3-six \
 "
