# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Perl-Critic"
PV = "1.156"
PR = "1.el10_0"
PACKAGES = " \
 perl-Perl-Critic \
 perl-Test-Perl-Critic-Policy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Perl-Critic-1.156-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d45dd3592dc24015963bd1be66aa450b643a0d238fb270a1065bbb770fcce08"

URI_x86_64_v2_perl-Perl-Critic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Perl-Critic-1.156-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Perl-Critic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Perl-Critic}"
SRC_URI[x86_64_v2_perl-Perl-Critic.sha256sum] = "c9b248ff3cbf6a08b3ef0d9cba3deba0d21db19330a7c6423c44f0cc82fbe3fd"

URI_x86_64_v2_perl-Test-Perl-Critic-Policy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Perl-Critic-Policy-1.156-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Perl-Critic-Policy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Perl-Critic-Policy}"
SRC_URI[x86_64_v2_perl-Test-Perl-Critic-Policy.sha256sum] = "d49a0b9fda08869247f7d920d888f26dba9263addd35fe709c582418327e7976"

URI_aarch64_perl-Perl-Critic = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Perl-Critic-1.156-1.el10_0.noarch.rpm;name=aarch64_perl-Perl-Critic;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Perl-Critic}"
SRC_URI[aarch64_perl-Perl-Critic.sha256sum] = "4b7a0dcd24d1c2cfde39770b10cabe0154e733b1012728c2f14485a1fa9ac85a"

URI_aarch64_perl-Test-Perl-Critic-Policy = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Perl-Critic-Policy-1.156-1.el10_0.noarch.rpm;name=aarch64_perl-Test-Perl-Critic-Policy;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Perl-Critic-Policy}"
SRC_URI[aarch64_perl-Test-Perl-Critic-Policy.sha256sum] = "f1db8e6b112dafed89d4e60d8fc6212800825c0ff48c4bb12ed02fe70092b73b"

RDEPENDS:perl-Perl-Critic = " \
 hunspell \
 perl-B-Keywords \
 perl-Carp \
 perl-Config-Tiny \
 perl-English \
 perl-Exception-Class \
 perl-Exporter \
 perl-ExtUtils-Manifest \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-File-Which \
 perl-Getopt-Long \
 perl-IO \
 perl-List-SomeUtils \
 perl-Module-Pluggable \
 perl-PPI \
 perl-PPIx-QuoteLike \
 perl-PPIx-Regexp \
 perl-PPIx-Utils \
 perl-PathTools \
 perl-Perl-Critic \
 perl-Pod-Parser \
 perl-Pod-Spell \
 perl-Pod-Usage \
 perl-Readonly \
 perl-Scalar-List-Utils \
 perl-String-Format \
 perl-Term-ANSIColor \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-parent \
 perl-version \
 perltidy \
 "
RDEPENDS:perl-Test-Perl-Critic-Policy = " \
 perl-Carp \
 perl-English \
 perl-Exporter \
 perl-List-SomeUtils \
 perl-Perl-Critic \
 perl-Readonly \
 perl-Test-Simple \
 perl-libs \
 "
