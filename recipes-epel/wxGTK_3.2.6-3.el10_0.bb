# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wxGTK"
PV = "3.2.6"
PR = "3.el10_0"
PACKAGES = " \
 wxBase \
 wxBase-devel \
 wxGTK \
 wxGTK-devel \
 wxGTK-docs \
 wxGTK-gl \
 wxGTK-i18n \
 wxGTK-media \
 wxGTK-webview \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wxGTK-3.2.6-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ca59a2af3ea45f1fc2055e3c5c96a60a9ab81c19fb89305516372785cd6bcca"

URI_x86_64_v2_wxBase = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxBase-3.2.6-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxBase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wxBase}"
SRC_URI[x86_64_v2_wxBase.sha256sum] = "4119827cac89f3bf3062ac94ad0912fc6afe6601608380d9db45e0c8c0b129bc"

URI_x86_64_v2_wxBase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxBase-devel-3.2.6-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxBase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wxBase-devel}"
SRC_URI[x86_64_v2_wxBase-devel.sha256sum] = "76454ebc40bbf9ed526fbea46e37b332171ed8f09a9c12a51d374fbe22e0d3d4"

URI_x86_64_v2_wxGTK = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-3.2.6-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxGTK;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wxGTK}"
SRC_URI[x86_64_v2_wxGTK.sha256sum] = "9a6fab93334878376cd1a9f18d79bc4c61224dd2f4a6d9b97916c8220540cebd"

URI_x86_64_v2_wxGTK-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-devel-3.2.6-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxGTK-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wxGTK-devel}"
SRC_URI[x86_64_v2_wxGTK-devel.sha256sum] = "6eeafe5a8f3ef81994591a3559d0b5731759c2e85d2cb7fa38e68a776ace0994"

URI_x86_64_v2_wxGTK-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-docs-3.2.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_wxGTK-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wxGTK-docs}"
SRC_URI[x86_64_v2_wxGTK-docs.sha256sum] = "9b7174dbf60d3c46ca1c17598e3eb5b5105f2c663f3d950cb39bd2d167090891"

URI_x86_64_v2_wxGTK-gl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-gl-3.2.6-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxGTK-gl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wxGTK-gl}"
SRC_URI[x86_64_v2_wxGTK-gl.sha256sum] = "a1b0362a133aeb89afacf7acd72c98528d7cb9b698cb5cb276f2da75a8253937"

URI_x86_64_v2_wxGTK-i18n = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-i18n-3.2.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_wxGTK-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wxGTK-i18n}"
SRC_URI[x86_64_v2_wxGTK-i18n.sha256sum] = "091a71923de6214bd6616031fb6aa33d7e517362e4c8086238ab85e5b82a65d5"

URI_x86_64_v2_wxGTK-media = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-media-3.2.6-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxGTK-media;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wxGTK-media}"
SRC_URI[x86_64_v2_wxGTK-media.sha256sum] = "a1d7869f574016da02744a2b3a60194e3c588a28025f77d30c0b67e2f78f0225"

URI_x86_64_v2_wxGTK-webview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-webview-3.2.6-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxGTK-webview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wxGTK-webview}"
SRC_URI[x86_64_v2_wxGTK-webview.sha256sum] = "84d1d19342d0b028711784049fc79059e9e972fbfa904f17af8bf8d2398b4820"

URI_aarch64_wxBase = "${EPEL_MIRROR}/aarch64/Packages/w/wxBase-3.2.6-3.el10_0.aarch64.rpm;name=aarch64_wxBase;unpack=0"
SRC_URI:append = " ${URI_aarch64_wxBase}"
SRC_URI[aarch64_wxBase.sha256sum] = "49289dccb10148a1411c5b5e5ec98da059111cb99b38d21313b942e1f1ab718c"

URI_aarch64_wxBase-devel = "${EPEL_MIRROR}/aarch64/Packages/w/wxBase-devel-3.2.6-3.el10_0.aarch64.rpm;name=aarch64_wxBase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wxBase-devel}"
SRC_URI[aarch64_wxBase-devel.sha256sum] = "ce7a6df1118c3457249edcded5e65ede0ca728f7b58e0deb8641b6df90a59d10"

URI_aarch64_wxGTK = "${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-3.2.6-3.el10_0.aarch64.rpm;name=aarch64_wxGTK;unpack=0"
SRC_URI:append = " ${URI_aarch64_wxGTK}"
SRC_URI[aarch64_wxGTK.sha256sum] = "dedb55af8dd49d0503bd84f8c42b52e85382497c98197d1aa8ab561ef65d92f7"

URI_aarch64_wxGTK-devel = "${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-devel-3.2.6-3.el10_0.aarch64.rpm;name=aarch64_wxGTK-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wxGTK-devel}"
SRC_URI[aarch64_wxGTK-devel.sha256sum] = "9f4404bd42a0f3dcc4473e4148a832eb1f35a991c3540f93bd7632c5bdb876b0"

URI_aarch64_wxGTK-docs = "${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-docs-3.2.6-3.el10_0.noarch.rpm;name=aarch64_wxGTK-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_wxGTK-docs}"
SRC_URI[aarch64_wxGTK-docs.sha256sum] = "d81a5d231541f6fa83724e06f84a9abae5b3b2e745b3e5d4e0e0658e5b96a14a"

URI_aarch64_wxGTK-gl = "${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-gl-3.2.6-3.el10_0.aarch64.rpm;name=aarch64_wxGTK-gl;unpack=0"
SRC_URI:append = " ${URI_aarch64_wxGTK-gl}"
SRC_URI[aarch64_wxGTK-gl.sha256sum] = "a807c781db509399aad06a825602eb7119945ffdcd8ecc8fc50a3aff4ec623e7"

URI_aarch64_wxGTK-i18n = "${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-i18n-3.2.6-3.el10_0.noarch.rpm;name=aarch64_wxGTK-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_wxGTK-i18n}"
SRC_URI[aarch64_wxGTK-i18n.sha256sum] = "2ce8266d8d99984c4696a1b68372323990e87dcd29f9a690fa1d46ec52c18b29"

URI_aarch64_wxGTK-media = "${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-media-3.2.6-3.el10_0.aarch64.rpm;name=aarch64_wxGTK-media;unpack=0"
SRC_URI:append = " ${URI_aarch64_wxGTK-media}"
SRC_URI[aarch64_wxGTK-media.sha256sum] = "95fef4ba3239c203343f5f97618a904ebd8817e1321ec8e9f0562d65e4fd19ce"

URI_aarch64_wxGTK-webview = "${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-webview-3.2.6-3.el10_0.aarch64.rpm;name=aarch64_wxGTK-webview;unpack=0"
SRC_URI:append = " ${URI_aarch64_wxGTK-webview}"
SRC_URI[aarch64_wxGTK-webview.sha256sum] = "3fa218399007555370cd48ad4b5c9cbdfb3cdaa3d665784f6cf24cd43b780c00"

RDEPENDS:wxBase = " \
 expat \
 glib2 \
 glibc \
 libgcc \
 libsecret \
 libstdc++ \
 pcre2-utf32 \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:wxBase-devel = " \
 alternatives \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 wxBase \
 "
RDEPENDS:wxGTK = " \
 cairo \
 cairo-gobject \
 fontconfig \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libSM \
 libX11 \
 libXtst \
 libgcc \
 libjpeg-turbo \
 libmspack \
 libpng \
 libstdc++ \
 libtiff \
 libxkbcommon \
 pango \
 virtual/libSDL2-2.0.so.0___64bit_ \
 wxBase \
 wxGTK-i18n \
 "
RDEPENDS:wxGTK-devel = " \
 bash \
 gtk3-devel \
 mesa-libGLU-devel \
 wxBase \
 wxBase-devel \
 wxGTK \
 wxGTK-gl \
 wxGTK-media \
 wxGTK-webview \
 "
RDEPENDS:wxGTK-docs = " \
 wxGTK \
 "
RDEPENDS:wxGTK-gl = " \
 glib2 \
 glibc \
 gtk3 \
 libX11 \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 wxBase \
 wxGTK \
 "
RDEPENDS:wxGTK-i18n = " \
 "
RDEPENDS:wxGTK-media = " \
 cairo \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gtk3 \
 libgcc \
 libstdc++ \
 wxBase \
 wxGTK \
 "
RDEPENDS:wxGTK-webview = " \
 glib2 \
 glibc \
 gtk3 \
 javascriptcoregtk4.1 \
 libgcc \
 libstdc++ \
 webkit2gtk4.1 \
 wxBase \
 wxGTK \
 "
