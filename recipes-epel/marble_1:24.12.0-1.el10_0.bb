# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "marble"
PE = "1"
PV = "24.12.0"
PR = "1.el10_0"
PACKAGES = " \
 marble \
 marble-astro \
 marble-astro-devel \
 marble-common \
 marble-plasma \
 marble-qt \
 marble-widget-data \
 marble-widget-qt6 \
 marble-widget-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/marble-24.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d99ff9758605cf891ffe3e6779aaafdca5a1a8f521b3b0b47b033619e580ec1e"

URI_x86_64_v2_marble = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-24.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble}"
SRC_URI[x86_64_v2_marble.sha256sum] = "549905550023b8fe2f3823d60b0e70aa91d80f86d021a92d83c5f8b3ddb85c60"

URI_x86_64_v2_marble-astro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-astro-24.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-astro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-astro}"
SRC_URI[x86_64_v2_marble-astro.sha256sum] = "a417fca46e5b09a0f3110f1441b8400ea6e46c61354d343aef781f3e78a1dd37"

URI_x86_64_v2_marble-astro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-astro-devel-24.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-astro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-astro-devel}"
SRC_URI[x86_64_v2_marble-astro-devel.sha256sum] = "2cdd59f7529a599b730662e73ef083e87158dd4f4a778033ff0a015c9025c7b6"

URI_x86_64_v2_marble-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-common-24.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_marble-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-common}"
SRC_URI[x86_64_v2_marble-common.sha256sum] = "4ce04ef637872dff4780066ceda57d8bf9597119ba17ea289d0cfec811e04af1"

URI_x86_64_v2_marble-plasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-plasma-24.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-plasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-plasma}"
SRC_URI[x86_64_v2_marble-plasma.sha256sum] = "435c1cf41767101e864ed6d19d55d8b801367461a7b86bdd0895440d4437a5b4"

URI_x86_64_v2_marble-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-qt-24.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-qt}"
SRC_URI[x86_64_v2_marble-qt.sha256sum] = "64466f194121c05653d491b7e243bb6ad734bd6a6ba93780e42a402965f160bc"

URI_x86_64_v2_marble-widget-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-data-24.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_marble-widget-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-widget-data}"
SRC_URI[x86_64_v2_marble-widget-data.sha256sum] = "403b6dffba1909e14520f8e33de3a3672f1b7ad1135eeb16a86b7e13a44330ae"

URI_x86_64_v2_marble-widget-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-qt6-24.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-widget-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-widget-qt6}"
SRC_URI[x86_64_v2_marble-widget-qt6.sha256sum] = "834867dc9532e43c39c6bba2ea15d1ff931cc672b1a6663109c65b6ff28c6d00"

URI_x86_64_v2_marble-widget-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-qt6-devel-24.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-widget-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-widget-qt6-devel}"
SRC_URI[x86_64_v2_marble-widget-qt6-devel.sha256sum] = "2eeaa4596e782adae186bb6305296253049cd2c2e4a09275b667470194c2a3bd"

URI_aarch64_marble = "${EPEL_MIRROR}/aarch64/Packages/m/marble-24.12.0-1.el10_0.aarch64.rpm;name=aarch64_marble;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble}"
SRC_URI[aarch64_marble.sha256sum] = "96820e31858e44c0c500273507c25a3d15a018513befb6b4d5c4505d1fb329f8"

URI_aarch64_marble-astro = "${EPEL_MIRROR}/aarch64/Packages/m/marble-astro-24.12.0-1.el10_0.aarch64.rpm;name=aarch64_marble-astro;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-astro}"
SRC_URI[aarch64_marble-astro.sha256sum] = "69d02a55fc6dc419fc3fd97421c740c5ee2e559950041edaf273df0b484fa8ae"

URI_aarch64_marble-astro-devel = "${EPEL_MIRROR}/aarch64/Packages/m/marble-astro-devel-24.12.0-1.el10_0.aarch64.rpm;name=aarch64_marble-astro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-astro-devel}"
SRC_URI[aarch64_marble-astro-devel.sha256sum] = "4be00cf94ffc880743b045254e88efb88d877d0c47b84440bbe4c79fe71cb07b"

URI_aarch64_marble-common = "${EPEL_MIRROR}/aarch64/Packages/m/marble-common-24.12.0-1.el10_0.noarch.rpm;name=aarch64_marble-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-common}"
SRC_URI[aarch64_marble-common.sha256sum] = "112d20ed97bc3e19e7c20a857ba89d0deb6539196950d4cf6f0241034092a3d6"

URI_aarch64_marble-plasma = "${EPEL_MIRROR}/aarch64/Packages/m/marble-plasma-24.12.0-1.el10_0.aarch64.rpm;name=aarch64_marble-plasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-plasma}"
SRC_URI[aarch64_marble-plasma.sha256sum] = "3b38ef8e4a01566c22b0880f73785173bbefbd7f2a04043cf3b8861aee0c1611"

URI_aarch64_marble-qt = "${EPEL_MIRROR}/aarch64/Packages/m/marble-qt-24.12.0-1.el10_0.aarch64.rpm;name=aarch64_marble-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-qt}"
SRC_URI[aarch64_marble-qt.sha256sum] = "dfb2a3ca5a5d3d7662debf1ed7e731eda7beebdf01049ead54946e73dadbf855"

URI_aarch64_marble-widget-data = "${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-data-24.12.0-1.el10_0.noarch.rpm;name=aarch64_marble-widget-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-widget-data}"
SRC_URI[aarch64_marble-widget-data.sha256sum] = "6ae5c6d694ec9615d4485377697b90faa3df67f159bc9ac3bfe3c7eef818bec1"

URI_aarch64_marble-widget-qt6 = "${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-qt6-24.12.0-1.el10_0.aarch64.rpm;name=aarch64_marble-widget-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-widget-qt6}"
SRC_URI[aarch64_marble-widget-qt6.sha256sum] = "fc1128e8650d8c25cf576df2b8f93a1de8350fa7c583cc4cb8642c906cafc0ae"

URI_aarch64_marble-widget-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-qt6-devel-24.12.0-1.el10_0.aarch64.rpm;name=aarch64_marble-widget-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-widget-qt6-devel}"
SRC_URI[aarch64_marble-widget-qt6-devel.sha256sum] = "433d9a924b8fecddb064b7c79ea5885ab443200e02c687a50d1f17fb6d2ea272"

RDEPENDS:marble = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
RDEPENDS:marble-astro = " \
 glibc \
 libstdc++ \
 marble-common \
 "
RDEPENDS:marble-astro-devel = " \
 cmake-filesystem \
 marble-astro \
 "
RDEPENDS:marble-common = " \
 "
RDEPENDS:marble-plasma = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-krunner \
 libstdc++ \
 marble-common \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:marble-qt = " \
 glibc \
 libstdc++ \
 marble-common \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:marble-widget-data = " \
 marble-common \
 "
RDEPENDS:marble-widget-qt6 = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 marble-astro \
 marble-widget-data \
 phonon-qt6 \
 protobuf \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 qt6-qtserialport \
 qt6-qtsvg \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 shapelib \
 zlib-ng-compat \
 "
RDEPENDS:marble-widget-qt6-devel = " \
 cmake-filesystem \
 marble-widget-qt6 \
 qt6-qt5compat-devel \
 qt6-qtbase-devel \
 qt6-qtwebengine-devel \
 "
