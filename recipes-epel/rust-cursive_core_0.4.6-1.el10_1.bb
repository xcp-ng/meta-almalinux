# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursive_core"
PV = "0.4.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-cursive_core+builder-devel \
 rust-cursive_core+default-devel \
 rust-cursive_core+doc-cfg-devel \
 rust-cursive_core+toml-devel \
 rust-cursive_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursive_core-0.4.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b95969b88da38624cafb362a72d8f56a65d0e78a878371143186900fd30750af"

URI_x86_64_v2_rust-cursive_core+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core+builder-devel-0.4.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core+builder-devel}"
SRC_URI[x86_64_v2_rust-cursive_core+builder-devel.sha256sum] = "ec618e226a053fda73f74a16e0b82dcdbf5ed02ff6c135aebd6c25c41812bf47"

URI_x86_64_v2_rust-cursive_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core+default-devel-0.4.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core+default-devel}"
SRC_URI[x86_64_v2_rust-cursive_core+default-devel.sha256sum] = "24eb9c78992e510f467ca57f9cd3c5d652caa772af7d863fffc9e021022d2167"

URI_x86_64_v2_rust-cursive_core+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core+doc-cfg-devel-0.4.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-cursive_core+doc-cfg-devel.sha256sum] = "b022e5f46b83172f50feee53843b24ef2468460fa783ef6846a53c5ea6f2741c"

URI_x86_64_v2_rust-cursive_core+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core+toml-devel-0.4.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core+toml-devel}"
SRC_URI[x86_64_v2_rust-cursive_core+toml-devel.sha256sum] = "923b3435f8b2575d13b485b9c7b1d10a77dad8f27ba6493d50cb073a2a921def"

URI_x86_64_v2_rust-cursive_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core-devel-0.4.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core-devel}"
SRC_URI[x86_64_v2_rust-cursive_core-devel.sha256sum] = "191d9f5e657449b40f1f031e8b82f49d13b70f0f11ba5d69e208fb45d35e24fb"

URI_aarch64_rust-cursive_core+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core+builder-devel-0.4.6-1.el10_1.noarch.rpm;name=aarch64_rust-cursive_core+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core+builder-devel}"
SRC_URI[aarch64_rust-cursive_core+builder-devel.sha256sum] = "94ea053689785006226a553562cedf85831836edcddd028a071ff14d62020bf2"

URI_aarch64_rust-cursive_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core+default-devel-0.4.6-1.el10_1.noarch.rpm;name=aarch64_rust-cursive_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core+default-devel}"
SRC_URI[aarch64_rust-cursive_core+default-devel.sha256sum] = "c48e4579ba8f82f4e78e6796ba70e29402128151712085d41c802c53001872a0"

URI_aarch64_rust-cursive_core+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core+doc-cfg-devel-0.4.6-1.el10_1.noarch.rpm;name=aarch64_rust-cursive_core+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core+doc-cfg-devel}"
SRC_URI[aarch64_rust-cursive_core+doc-cfg-devel.sha256sum] = "464e59a61abba08d10fbf09e9f2357f12e2290e54b719efae0f4db90e8eea477"

URI_aarch64_rust-cursive_core+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core+toml-devel-0.4.6-1.el10_1.noarch.rpm;name=aarch64_rust-cursive_core+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core+toml-devel}"
SRC_URI[aarch64_rust-cursive_core+toml-devel.sha256sum] = "8fc5100580e9889ac5eb0bd4ba235e56d27d5d99aea53c80ddd426443c615b92"

URI_aarch64_rust-cursive_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core-devel-0.4.6-1.el10_1.noarch.rpm;name=aarch64_rust-cursive_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core-devel}"
SRC_URI[aarch64_rust-cursive_core-devel.sha256sum] = "f2107bac405ba7d27d05d5e654e6f11739f39ac06a77526efbc38d3e3003ac35"

RDEPENDS:rust-cursive_core+builder-devel = " \
 cargo \
 rust-cursive-macros+builder-devel \
 rust-cursive_core-devel \
 rust-inventory+default-devel \
 "
RDEPENDS:rust-cursive_core+default-devel = " \
 cargo \
 rust-cursive_core-devel \
 "
RDEPENDS:rust-cursive_core+doc-cfg-devel = " \
 cargo \
 rust-cursive_core-devel \
 "
RDEPENDS:rust-cursive_core+toml-devel = " \
 cargo \
 rust-cursive_core-devel \
 rust-toml0.8+default-devel \
 "
RDEPENDS:rust-cursive_core-devel = " \
 cargo \
 rust \
 rust-ahash+default-devel \
 rust-compact_str0.9+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-cursive-macros+default-devel \
 rust-enum-map+default-devel \
 rust-enumset+default-devel \
 rust-lazy_static+default-devel \
 rust-log+default-devel \
 rust-num-devel \
 rust-parking_lot+arc_lock-devel \
 rust-parking_lot+default-devel \
 rust-serde_json+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width0.1+default-devel \
 rust-xi-unicode+default-devel \
 "
