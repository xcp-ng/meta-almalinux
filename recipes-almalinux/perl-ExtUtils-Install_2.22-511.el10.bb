# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-Install"
PV = "2.22"
PR = "511.el10"
PACKAGES = " \
 perl-ExtUtils-Install \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-ExtUtils-Install-2.22-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdfa4388893ce05a878295721f205588a2f61ffc01c48ef32de1d58abb3c2083"

URI_x86_64_v2_perl-ExtUtils-Install = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Install-2.22-511.el10.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Install;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ExtUtils-Install}"
SRC_URI[x86_64_v2_perl-ExtUtils-Install.sha256sum] = "c82c47f529f62334177947d1db392eb4119e8ef1debbdb7de26d6a5f84c702f3"

URI_aarch64_perl-ExtUtils-Install = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ExtUtils-Install-2.22-511.el10.noarch.rpm;name=aarch64_perl-ExtUtils-Install;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ExtUtils-Install}"
SRC_URI[aarch64_perl-ExtUtils-Install.sha256sum] = "c82c47f529f62334177947d1db392eb4119e8ef1debbdb7de26d6a5f84c702f3"

RDEPENDS:perl-ExtUtils-Install = " \
 perl-AutoSplit \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-ExtUtils-Install \
 perl-ExtUtils-MakeMaker \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-PathTools \
 perl-libs \
 "
