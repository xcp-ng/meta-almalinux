# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-imgref"
PV = "1.12.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-imgref+default-devel \
 rust-imgref+deprecated-devel \
 rust-imgref-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-imgref-1.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4848c5392748ff77b5abe749b0d865cfda524c09f25b1d29a2669324697082c9"

URI_x86_64_v2_rust-imgref+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref+default-devel-1.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imgref+default-devel}"
SRC_URI[x86_64_v2_rust-imgref+default-devel.sha256sum] = "0d6ddc4478f7ce1d34f0bc36e91f7b028991ab4a5db921f47580fa111095f2b0"

URI_x86_64_v2_rust-imgref+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref+deprecated-devel-1.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imgref+deprecated-devel}"
SRC_URI[x86_64_v2_rust-imgref+deprecated-devel.sha256sum] = "b900d91c11ab5a973fc6ca10d370d5afd1c050237e62d0b6e5dc8cec41987560"

URI_x86_64_v2_rust-imgref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref-devel-1.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imgref-devel}"
SRC_URI[x86_64_v2_rust-imgref-devel.sha256sum] = "f8f042f27b3626f2d60d5f1a5902c91e876c0c97cd3691b391f819f6c809f431"

URI_aarch64_rust-imgref+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref+default-devel-1.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-imgref+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imgref+default-devel}"
SRC_URI[aarch64_rust-imgref+default-devel.sha256sum] = "0d951171b25dcf3b4c81325a054d1548236b67d7efee12c19d769ce4ff535fe4"

URI_aarch64_rust-imgref+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref+deprecated-devel-1.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-imgref+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imgref+deprecated-devel}"
SRC_URI[aarch64_rust-imgref+deprecated-devel.sha256sum] = "83330744b3d880ae1f898891fb6932f9dbeb55391fc99d2bf3f879279ec97b4b"

URI_aarch64_rust-imgref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref-devel-1.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-imgref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imgref-devel}"
SRC_URI[aarch64_rust-imgref-devel.sha256sum] = "5d6335ca15dcb62610891f26711b547d387eb78a502e45ee7448d1cd4c84749b"

RDEPENDS:rust-imgref+default-devel = " \
 cargo \
 rust-imgref+deprecated-devel \
 rust-imgref-devel \
 "
RDEPENDS:rust-imgref+deprecated-devel = " \
 cargo \
 rust-imgref-devel \
 "
RDEPENDS:rust-imgref-devel = " \
 cargo \
 rust \
 "
