# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-datatest-stable"
PV = "0.3.3"
PR = "7.el10_2"
PACKAGES = " \
 rust-datatest-stable+default-devel \
 rust-datatest-stable+include-dir-devel \
 rust-datatest-stable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-datatest-stable-0.3.3-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52f2fe57dec6beea4a97e6d908cf5cc9e15718c38f736305c2f77e2ee7d589ea"

URI_x86_64_v2_rust-datatest-stable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-datatest-stable+default-devel-0.3.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-datatest-stable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-datatest-stable+default-devel}"
SRC_URI[x86_64_v2_rust-datatest-stable+default-devel.sha256sum] = "f43fef4dfabeebba89bad1b6da33bd20aea05e2088eb633f8186a7dfbc26879d"

URI_x86_64_v2_rust-datatest-stable+include-dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-datatest-stable+include-dir-devel-0.3.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-datatest-stable+include-dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-datatest-stable+include-dir-devel}"
SRC_URI[x86_64_v2_rust-datatest-stable+include-dir-devel.sha256sum] = "f99e1d2e9eff159cd7c2a1b63a04361b0dee19fd185f0f02f96593fd5ebe4c21"

URI_x86_64_v2_rust-datatest-stable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-datatest-stable-devel-0.3.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-datatest-stable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-datatest-stable-devel}"
SRC_URI[x86_64_v2_rust-datatest-stable-devel.sha256sum] = "38b55de5c809ff5f588786da84edde96a9a44a343a00439ae962223c24263c93"

URI_aarch64_rust-datatest-stable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-datatest-stable+default-devel-0.3.3-7.el10_2.noarch.rpm;name=aarch64_rust-datatest-stable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-datatest-stable+default-devel}"
SRC_URI[aarch64_rust-datatest-stable+default-devel.sha256sum] = "d95ded553eaed292847e3885210daed706aa24f8a198d9128f19840ebfe4338f"

URI_aarch64_rust-datatest-stable+include-dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-datatest-stable+include-dir-devel-0.3.3-7.el10_2.noarch.rpm;name=aarch64_rust-datatest-stable+include-dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-datatest-stable+include-dir-devel}"
SRC_URI[aarch64_rust-datatest-stable+include-dir-devel.sha256sum] = "0e7aa348e492250c2557d7461c92db56f5de1df283bc1b9b4cfa022c308f64a9"

URI_aarch64_rust-datatest-stable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-datatest-stable-devel-0.3.3-7.el10_2.noarch.rpm;name=aarch64_rust-datatest-stable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-datatest-stable-devel}"
SRC_URI[aarch64_rust-datatest-stable-devel.sha256sum] = "b199dea4d74aff9c6689f25ef4edb9ac7aa18911d1f5f51635d3abc8d8a44ffa"

RDEPENDS:rust-datatest-stable+default-devel = " \
 cargo \
 rust-datatest-stable-devel \
 "
RDEPENDS:rust-datatest-stable+include-dir-devel = " \
 cargo \
 rust-datatest-stable-devel \
 rust-include_dir+default-devel \
 "
RDEPENDS:rust-datatest-stable-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-fancy-regex+default-devel \
 rust-libtest-mimic+default-devel \
 rust-walkdir+default-devel \
 "
