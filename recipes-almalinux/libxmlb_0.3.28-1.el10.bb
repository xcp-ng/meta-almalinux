# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxmlb"
PV = "0.3.28"
PR = "1.el10"
PACKAGES = " \
 libxmlb \
 libxmlb-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libxmlb-0.3.28-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "76eb8246464801c1c419cacf013c38b2bf2730978cad4df964842b377d182999"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libxmlb-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_libxmlb;unpack=0"
SRC_URI[x86_64_v2_libxmlb.sha256sum] = "a8f4f172f450de473760d2590a8201e57610350ffbd16b278382b8c6add306f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxmlb-devel-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_libxmlb-devel;unpack=0"
SRC_URI[x86_64_v2_libxmlb-devel.sha256sum] = "19753b31a2884dd541f6cf6cc30b456554a9471613a3a4ee618ce5bc3f6b52ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libxmlb-0.3.28-1.el10.aarch64.rpm;name=aarch64_libxmlb;unpack=0"
SRC_URI[aarch64_libxmlb.sha256sum] = "20374ce31517477bf110b3146534da9eb3fcb4bdc264ef786eebfffacfef61f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxmlb-devel-0.3.28-1.el10.aarch64.rpm;name=aarch64_libxmlb-devel;unpack=0"
SRC_URI[aarch64_libxmlb-devel.sha256sum] = "2bf84e4b9a452ed94bd89bd77cfed106d1f7ea66b2f2343f2f04323fe8fbe177"

RDEPENDS:libxmlb = " \
 glib2 \
 glibc \
 libgcc \
 libzstd \
 shared-mime-info \
 xz-libs \
 "
RDEPENDS:libxmlb-devel = " \
 glib2-devel \
 libxmlb \
 libzstd-devel \
 pkgconf-pkg-config \
 xz-devel \
 "
