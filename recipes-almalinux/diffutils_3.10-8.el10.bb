# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "diffutils"
PV = "3.10"
PR = "8.el10"
PACKAGES = " \
 diffutils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/diffutils-3.10-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "501ccdf93023df9dab2dff3afb4f70b7c8cdf232d687acc497685e4e5fce0eb8"

URI_x86_64_v2_diffutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/diffutils-3.10-8.el10.x86_64_v2.rpm;name=x86_64_v2_diffutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_diffutils}"
SRC_URI[x86_64_v2_diffutils.sha256sum] = "d8f825235c3d0d6bf1fef7e4a3644f298d45095d69056b2497df0506ca1d3d61"

URI_aarch64_diffutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/diffutils-3.10-8.el10.aarch64.rpm;name=aarch64_diffutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_diffutils}"
SRC_URI[aarch64_diffutils.sha256sum] = "4dc68148d51cb0e91d62fa55806844299f66b8772d1b7840beeea688e6ad42ee"

RDEPENDS:diffutils = " \
 glibc \
 "
