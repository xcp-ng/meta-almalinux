# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rx"
PV = "4.1.0"
PR = "4.el10_2"
PACKAGES = " \
 python3-rx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rx-4.1.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "446a5c70f87946b135c23eb44db14ee28b435b4347702cace8be8bae7d041553"

URI_x86_64_v2_python3-rx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rx-4.1.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rx}"
SRC_URI[x86_64_v2_python3-rx.sha256sum] = "2f1bcc25f3b5d1133331d0c0e33d4484359d92f771c6497d249496b959dce264"

URI_aarch64_python3-rx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rx-4.1.0-4.el10_2.noarch.rpm;name=aarch64_python3-rx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rx}"
SRC_URI[aarch64_python3-rx.sha256sum] = "242c816cc82fadb0fb0fef9997aa1210ccb1254cd4b62b7f9f2d45710fde1da7"

RDEPENDS:python3-rx = " \
 python3 \
 python3-typing-extensions \
 "
