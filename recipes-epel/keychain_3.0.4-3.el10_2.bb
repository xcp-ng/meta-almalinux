# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keychain"
PV = "3.0.4"
PR = "3.el10_2"
PACKAGES = " \
 keychain \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/keychain-3.0.4-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aca48948c43fcb7aefee14bf608ec374e74fcd5a2f0bc4b1907cc750dccb25e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keychain-3.0.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_keychain;unpack=0"
SRC_URI[x86_64_v2_keychain.sha256sum] = "43539a5b6b5f705786254717061d789b7873f629c042091448a4323f7af6b2ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/keychain-3.0.4-3.el10_2.noarch.rpm;name=aarch64_keychain;unpack=0"
SRC_URI[aarch64_keychain.sha256sum] = "7e742257255635939267043d5df7c182e218fd24356e411cb7d286fd7a3d9888"

RDEPENDS:keychain = " \
 python3 \
 "
