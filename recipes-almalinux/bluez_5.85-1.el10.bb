# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluez"
PV = "5.85"
PR = "1.el10"
PACKAGES = " \
 bluez \
 bluez-cups \
 bluez-libs \
 bluez-libs-devel \
 bluez-obexd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/bluez-5.85-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "780cfd3484378f9dd20ab4eb86c23caa978797f5b781c9c13574bbf95ab7229e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bluez-5.85-1.el10.x86_64_v2.rpm;name=x86_64_v2_bluez;unpack=0"
SRC_URI[x86_64_v2_bluez.sha256sum] = "20ac7200a56886f9ce7c2d692e66848f6d359c1c900d01b119952bb0b58a2be1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bluez-cups-5.85-1.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-cups;unpack=0"
SRC_URI[x86_64_v2_bluez-cups.sha256sum] = "d0cf204f2e741a89a86ae58c431419bdfce2b6f3ef083f6487bc810c6d51dd4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bluez-libs-5.85-1.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-libs;unpack=0"
SRC_URI[x86_64_v2_bluez-libs.sha256sum] = "addc2bdb9c167b67aeb665ca3baad30efaee26e02ca00dbc4a0a6642def174fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bluez-libs-devel-5.85-1.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-libs-devel;unpack=0"
SRC_URI[x86_64_v2_bluez-libs-devel.sha256sum] = "cf28ddaf098d736c23caee2bb5cdb25863484a51ef941acb68bb7518ef514bda"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bluez-obexd-5.85-1.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-obexd;unpack=0"
SRC_URI[x86_64_v2_bluez-obexd.sha256sum] = "d1e712e7682d6dc0efb75408304fe7a2e059dc739ca1d7ba6b096112215c61c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bluez-5.85-1.el10.aarch64.rpm;name=aarch64_bluez;unpack=0"
SRC_URI[aarch64_bluez.sha256sum] = "ced112d1c6a73db7a04e8357ed6fc4b8e6c09496592663a214a9eb250fcf6ad0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bluez-cups-5.85-1.el10.aarch64.rpm;name=aarch64_bluez-cups;unpack=0"
SRC_URI[aarch64_bluez-cups.sha256sum] = "54a7279af967070e6951bc85d241e092a48aa940019ca14dcbbfdd4886b6aca8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bluez-libs-5.85-1.el10.aarch64.rpm;name=aarch64_bluez-libs;unpack=0"
SRC_URI[aarch64_bluez-libs.sha256sum] = "bc197ca0c09a9447ec3301deca29a8cacae12f472b777a64da0d7617780b7fce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bluez-libs-devel-5.85-1.el10.aarch64.rpm;name=aarch64_bluez-libs-devel;unpack=0"
SRC_URI[aarch64_bluez-libs-devel.sha256sum] = "4c8b7d2ddfd622ed858ee99dea258ee7be1b229e04921c61bb37f8e88cbc1f19"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bluez-obexd-5.85-1.el10.aarch64.rpm;name=aarch64_bluez-obexd;unpack=0"
SRC_URI[aarch64_bluez-obexd.sha256sum] = "880f03bd504e58200886b73c912b9463e7e9da3c13881d38d0172bb4024b17be"

RDEPENDS:bluez = " \
 bash \
 dbus \
 dbus-libs \
 glib2 \
 glibc \
 readline \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluez-cups = " \
 bluez \
 cups \
 dbus-libs \
 glib2 \
 glibc \
 "
RDEPENDS:bluez-libs = " \
 glibc \
 "
RDEPENDS:bluez-libs-devel = " \
 bluez-libs \
 glibc \
 pkgconf-pkg-config \
 "
RDEPENDS:bluez-obexd = " \
 bash \
 bluez \
 bluez-libs \
 dbus-libs \
 glib2 \
 glibc \
 libical \
 systemd-libs \
 "
