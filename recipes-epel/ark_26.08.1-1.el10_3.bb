# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ark"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ark \
 ark-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/ark-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0f7310590a363c59521dfbd4d580454304d7df806cb062762f6ebc7f973908e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ark-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ark;unpack=0"
SRC_URI[x86_64_v2_ark.sha256sum] = "f079a2f1f9abb73d24d962573dd4fdec37030e360d6188d8942027deb1d481f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ark-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ark-libs;unpack=0"
SRC_URI[x86_64_v2_ark-libs.sha256sum] = "251cfc5bb38c316ca7ef9b05a46e4656a925d77d6a3bbaba54903ae1ecfeb5e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/ark-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ark;unpack=0"
SRC_URI[aarch64_ark.sha256sum] = "23ade749e6b07f7bce1755a2775b9ba2c367f710da544d0c51e6223aa872dfbd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/ark-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ark-libs;unpack=0"
SRC_URI[aarch64_ark-libs.sha256sum] = "d77125f0c59eb1dc56cdbac33d1555ce334886472fc64ccb62bf935be52b0f59"

RDEPENDS:ark = " \
 ark-libs \
 bzip2 \
 glibc \
 gzip \
 kf6-breeze-icons \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 unzip \
 "
RDEPENDS:ark-libs = " \
 ark \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kpty \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libarchive \
 libgcc \
 libstdc++ \
 libzip \
 qt6-qtbase \
 qt6-qtbase-gui \
 zlib-ng-compat \
 "
