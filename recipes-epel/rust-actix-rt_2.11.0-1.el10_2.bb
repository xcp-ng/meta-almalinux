# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-actix-rt"
PV = "2.11.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-actix-rt+actix-macros-devel \
 rust-actix-rt+default-devel \
 rust-actix-rt+macros-devel \
 rust-actix-rt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-actix-rt-2.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd901a3a54a48e6ea6e11f12158b8de52dac27f2b9db40bb42966aaa5cba66da"

URI_x86_64_v2_rust-actix-rt+actix-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt+actix-macros-devel-2.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt+actix-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-actix-rt+actix-macros-devel}"
SRC_URI[x86_64_v2_rust-actix-rt+actix-macros-devel.sha256sum] = "53f01ce25584937ae5831792fb865f66cab066212bc718dc531ae3f25c1bf0fe"

URI_x86_64_v2_rust-actix-rt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt+default-devel-2.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-actix-rt+default-devel}"
SRC_URI[x86_64_v2_rust-actix-rt+default-devel.sha256sum] = "0c403cc8d598dbfc0024302994e694e512d4dd7cd462a59a2e21d881723e8a6c"

URI_x86_64_v2_rust-actix-rt+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt+macros-devel-2.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-actix-rt+macros-devel}"
SRC_URI[x86_64_v2_rust-actix-rt+macros-devel.sha256sum] = "0ffe9c605268cfdea4b7a054195c31ef986a7d46ca0a386beabe77a7b158835e"

URI_x86_64_v2_rust-actix-rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt-devel-2.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-actix-rt-devel}"
SRC_URI[x86_64_v2_rust-actix-rt-devel.sha256sum] = "ea19b2e76402fa64c8ecfe3ae002d6c9c74ad5c433ecf3f74e9785e4c823bd8e"

URI_aarch64_rust-actix-rt+actix-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt+actix-macros-devel-2.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-actix-rt+actix-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-actix-rt+actix-macros-devel}"
SRC_URI[aarch64_rust-actix-rt+actix-macros-devel.sha256sum] = "dd03ce781179efc59cdf3c93fc9b5eedb1b505730ac2273bf10960109db339d9"

URI_aarch64_rust-actix-rt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt+default-devel-2.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-actix-rt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-actix-rt+default-devel}"
SRC_URI[aarch64_rust-actix-rt+default-devel.sha256sum] = "b714e8681304e66d5437a8b032dfcb64df1f3655fdd8810caec76b2a7f9d63b6"

URI_aarch64_rust-actix-rt+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt+macros-devel-2.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-actix-rt+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-actix-rt+macros-devel}"
SRC_URI[aarch64_rust-actix-rt+macros-devel.sha256sum] = "73edd03e360ef1f383dfc19d4b191252bddaab2a4826b3fd81a74754fca82700"

URI_aarch64_rust-actix-rt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt-devel-2.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-actix-rt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-actix-rt-devel}"
SRC_URI[aarch64_rust-actix-rt-devel.sha256sum] = "8ca1b09679797e61322ab96d5730545ab90688d07fc5f1f6a6e3cda1a4819870"

RDEPENDS:rust-actix-rt+actix-macros-devel = " \
 cargo \
 rust-actix-macros+default-devel \
 rust-actix-rt-devel \
 "
RDEPENDS:rust-actix-rt+default-devel = " \
 cargo \
 rust-actix-rt+macros-devel \
 rust-actix-rt-devel \
 "
RDEPENDS:rust-actix-rt+macros-devel = " \
 cargo \
 rust-actix-rt+actix-macros-devel \
 rust-actix-rt-devel \
 "
RDEPENDS:rust-actix-rt-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+parking_lot-devel \
 rust-tokio+rt-devel \
 rust-tokio+signal-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 "
