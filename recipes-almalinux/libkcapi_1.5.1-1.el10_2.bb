# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkcapi"
PV = "1.5.1"
PR = "1.el10_2"
PACKAGES = " \
 libkcapi \
 libkcapi-hasher \
 libkcapi-hmaccalc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libkcapi-1.5.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1aaf7af63fcf4b111771a86f28c3b721b7d75b8a3f5d3a111e2a3ebebea84783"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libkcapi-1.5.1-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libkcapi;unpack=0"
SRC_URI[x86_64_v2_libkcapi.sha256sum] = "1df4f619f7d9953ecccbbe5b4e1fe237b21d0b240c14a2c6099ff2feb5995b11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libkcapi-hasher-1.5.1-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libkcapi-hasher;unpack=0"
SRC_URI[x86_64_v2_libkcapi-hasher.sha256sum] = "8cf81857cad76e16ad794acf0b035fd2250af05e94c5b719f56bc65efad41193"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libkcapi-hmaccalc-1.5.1-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libkcapi-hmaccalc;unpack=0"
SRC_URI[x86_64_v2_libkcapi-hmaccalc.sha256sum] = "0e623b4ace172c46aabc35e3bc18da2b17b768da8709d69184bcb2db729fe6dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libkcapi-1.5.1-1.el10_2.aarch64.rpm;name=aarch64_libkcapi;unpack=0"
SRC_URI[aarch64_libkcapi.sha256sum] = "90d8f20af74d24f3f778e2ce5ff53cfaa920308e43f23689192e7a2fb5a4ecab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libkcapi-hasher-1.5.1-1.el10_2.aarch64.rpm;name=aarch64_libkcapi-hasher;unpack=0"
SRC_URI[aarch64_libkcapi-hasher.sha256sum] = "6abf6ce00a582794fe27c7ad990601f2c1a95071b71cc7fd6faa0dbb1c3161cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libkcapi-hmaccalc-1.5.1-1.el10_2.aarch64.rpm;name=aarch64_libkcapi-hmaccalc;unpack=0"
SRC_URI[aarch64_libkcapi-hmaccalc.sha256sum] = "173ac17d6a6b3923841f510eec87bf73dcb7d22eddee6b9354a7460f7e59e73c"

RDEPENDS:libkcapi = " \
 glibc \
 systemd \
 "
RDEPENDS:libkcapi-hasher = " \
 glibc \
 libkcapi \
 "
RDEPENDS:libkcapi-hmaccalc = " \
 libkcapi-hasher \
 "
