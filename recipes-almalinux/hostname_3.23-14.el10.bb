# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hostname"
PV = "3.23"
PR = "14.el10"
PACKAGES = " \
 hostname \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/hostname-3.23-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05337cbd976a43af1a8140bce7041900833039ec99f77ff609b2c7aced9f8a8b"

URI_x86_64_v2_hostname = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/hostname-3.23-14.el10.x86_64_v2.rpm;name=x86_64_v2_hostname;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hostname}"
SRC_URI[x86_64_v2_hostname.sha256sum] = "3eea00f3e321d7a230c92d5f36a724f854c853c0b7f6f4d350956d4edeb6ef8e"

URI_aarch64_hostname = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/hostname-3.23-14.el10.aarch64.rpm;name=aarch64_hostname;unpack=0"
SRC_URI:append = " ${URI_aarch64_hostname}"
SRC_URI[aarch64_hostname.sha256sum] = "20f8d679d9efeaf2864429b71eb64e2e9012563d0edfc105854523bcbf771286"

RDEPENDS:hostname = " \
 bash \
 glibc \
 "
