# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enum-as-inner"
PV = "0.6.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-enum-as-inner+default-devel \
 rust-enum-as-inner-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enum-as-inner-0.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e71b3f8ffa41385abc528246da656f35e4ab15e308d5887122dd989d583afa54"

URI_x86_64_v2_rust-enum-as-inner+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-as-inner+default-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-as-inner+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-as-inner+default-devel}"
SRC_URI[x86_64_v2_rust-enum-as-inner+default-devel.sha256sum] = "85f0f664adb404199de7793f5593c8a3a26c74879e8749e484c9cff627a80aee"

URI_x86_64_v2_rust-enum-as-inner-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-as-inner-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-as-inner-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-as-inner-devel}"
SRC_URI[x86_64_v2_rust-enum-as-inner-devel.sha256sum] = "cb4ebaeb21c97cc0b401d2b2175ee4a4a984b982928997952be1dfddac5468d0"

URI_aarch64_rust-enum-as-inner+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-as-inner+default-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-enum-as-inner+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-as-inner+default-devel}"
SRC_URI[aarch64_rust-enum-as-inner+default-devel.sha256sum] = "f2cbda8bb6e12bc47f70a0dad8d1f149e3fe21a1c45a0b31e5be2686e00f9875"

URI_aarch64_rust-enum-as-inner-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-as-inner-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-enum-as-inner-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-as-inner-devel}"
SRC_URI[aarch64_rust-enum-as-inner-devel.sha256sum] = "1fa0b839d6d3ae2495804da79139beb35e0bdde80f4807d700c825d9c9d5d032"

RDEPENDS:rust-enum-as-inner+default-devel = " \
 cargo \
 rust-enum-as-inner-devel \
 "
RDEPENDS:rust-enum-as-inner-devel = " \
 cargo \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
