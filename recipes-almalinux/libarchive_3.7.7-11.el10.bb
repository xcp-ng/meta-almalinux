# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libarchive"
PV = "3.7.7"
PR = "11.el10"
PACKAGES = " \
 bsdtar \
 libarchive \
 libarchive-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libarchive-3.7.7-11.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2107efd16b16b3940329cb72dfa6e7eaad3b9ab9a11fb1c3ca1803e25f57bd64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bsdtar-3.7.7-11.el10.x86_64_v2.rpm;name=x86_64_v2_bsdtar;unpack=0"
SRC_URI[x86_64_v2_bsdtar.sha256sum] = "32dffacd18eb185cc4700739dd97a1e78a99c3a16a60a3d6ad5c1dc9b7d48486"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libarchive-3.7.7-11.el10.x86_64_v2.rpm;name=x86_64_v2_libarchive;unpack=0"
SRC_URI[x86_64_v2_libarchive.sha256sum] = "6152083eee61821f28cc133206e8f3348d0c6f24654c9a83e21e2400bbfa38f7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libarchive-devel-3.7.7-11.el10.x86_64_v2.rpm;name=x86_64_v2_libarchive-devel;unpack=0"
SRC_URI[x86_64_v2_libarchive-devel.sha256sum] = "811d4ed3ffd27de64898842d117a45ba7aad996b466ccbd582b0af8961d5ba6d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bsdtar-3.7.7-11.el10.aarch64.rpm;name=aarch64_bsdtar;unpack=0"
SRC_URI[aarch64_bsdtar.sha256sum] = "8b6878135d0eb17c2cc979910ab8c77842d490a126ef06d50a46b1646d1c6a29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libarchive-3.7.7-11.el10.aarch64.rpm;name=aarch64_libarchive;unpack=0"
SRC_URI[aarch64_libarchive.sha256sum] = "ed6c704d6b97dfc571bc5e5510dd69b4dc8ae9cb0ccc681e50164a7df74bfeb3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libarchive-devel-3.7.7-11.el10.aarch64.rpm;name=aarch64_libarchive-devel;unpack=0"
SRC_URI[aarch64_libarchive-devel.sha256sum] = "1425bdde742ddf3f88b26d3aa36683595cd4c31f603ede7a506a9029027ffb09"

RDEPENDS:bsdtar = " \
 glibc \
 libarchive \
 "
RDEPENDS:libarchive = " \
 bzip2-libs \
 glibc \
 libacl \
 libxml2 \
 libzstd \
 lz4-libs \
 openssl-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libarchive-devel = " \
 libarchive \
 openssl-devel \
 pkgconf-pkg-config \
 "
