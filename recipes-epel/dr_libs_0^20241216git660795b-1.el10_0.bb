# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dr_libs"
PV = "0^20241216git660795b"
PR = "1.el10_0"
PACKAGES = " \
 dr_flac-devel \
 dr_libs-devel \
 dr_libs-doc \
 dr_mp3-devel \
 dr_wav-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dr_libs-0^20241216git660795b-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a92d0bbc258d43fce6c26879cca9eeecb47181a19f51bfa63d23605e1282566"

URI_x86_64_v2_dr_flac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_flac-devel-0.12.43^20241216git660795b-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dr_flac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_flac-devel}"
SRC_URI[x86_64_v2_dr_flac-devel.sha256sum] = "bf6129bbbbab06a0ec02f4d2048a5d8683fa0d17cd1b98ff9fd2d3e9ff3ee0a3"

URI_x86_64_v2_dr_libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_libs-devel-0^20241216git660795b-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dr_libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_libs-devel}"
SRC_URI[x86_64_v2_dr_libs-devel.sha256sum] = "425d030f3d65afb64485fd36a0b7ff486c21d1b85078e2c4aadbeba0b1eb39d2"

URI_x86_64_v2_dr_libs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_libs-doc-0^20241216git660795b-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dr_libs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_libs-doc}"
SRC_URI[x86_64_v2_dr_libs-doc.sha256sum] = "55b08119e4c1e599ad79b11cbfb58cb3efb465295744dd1f775ad4717b57ca05"

URI_x86_64_v2_dr_mp3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_mp3-devel-0.6.40^20241216git660795b-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dr_mp3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_mp3-devel}"
SRC_URI[x86_64_v2_dr_mp3-devel.sha256sum] = "426e2ac8397d1fb926e0f11ff6c25bc9197634ab12af21a01937e601f4180476"

URI_x86_64_v2_dr_wav-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_wav-devel-0.13.17^20241216git660795b-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dr_wav-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_wav-devel}"
SRC_URI[x86_64_v2_dr_wav-devel.sha256sum] = "92597242d114075d9a38e4449968eeb3fe03b980d88a28c45813988a0fe9beae"

URI_aarch64_dr_flac-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_flac-devel-0.12.43^20241216git660795b-1.el10_0.noarch.rpm;name=aarch64_dr_flac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_flac-devel}"
SRC_URI[aarch64_dr_flac-devel.sha256sum] = "c6e3c93ae2c2adf083163a77ad055ed4d390defc8b92b3d8644ee2cbc769be9d"

URI_aarch64_dr_libs-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_libs-devel-0^20241216git660795b-1.el10_0.noarch.rpm;name=aarch64_dr_libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_libs-devel}"
SRC_URI[aarch64_dr_libs-devel.sha256sum] = "1300d5a65cbbc7881ab8e42cba119dce5ea7bc3c02e24b8de348fefc9c0c43af"

URI_aarch64_dr_libs-doc = "${EPEL_MIRROR}/aarch64/Packages/d/dr_libs-doc-0^20241216git660795b-1.el10_0.noarch.rpm;name=aarch64_dr_libs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_libs-doc}"
SRC_URI[aarch64_dr_libs-doc.sha256sum] = "a0580fab25bfb932c71294103bbacb536c6fe0248a66ddf207bcf35b7191c064"

URI_aarch64_dr_mp3-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_mp3-devel-0.6.40^20241216git660795b-1.el10_0.noarch.rpm;name=aarch64_dr_mp3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_mp3-devel}"
SRC_URI[aarch64_dr_mp3-devel.sha256sum] = "bb67ca018dab91fe147ca2471187ab890e66e827fbafc31c8c69f33afcaf3213"

URI_aarch64_dr_wav-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_wav-devel-0.13.17^20241216git660795b-1.el10_0.noarch.rpm;name=aarch64_dr_wav-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_wav-devel}"
SRC_URI[aarch64_dr_wav-devel.sha256sum] = "408b48dd52cb72b900dc673858ce5880ee2060e84db823092e96bf112dcaa59d"

RDEPENDS:dr_flac-devel = " \
 "
RDEPENDS:dr_libs-devel = " \
 dr_flac-devel \
 dr_mp3-devel \
 dr_wav-devel \
 "
RDEPENDS:dr_libs-doc = " \
 "
RDEPENDS:dr_mp3-devel = " \
 "
RDEPENDS:dr_wav-devel = " \
 "
