# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enum-map"
PV = "2.7.3"
PR = "2.el10_1"
PACKAGES = " \
 rust-enum-map+arbitrary-devel \
 rust-enum-map+default-devel \
 rust-enum-map+serde-devel \
 rust-enum-map-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enum-map-2.7.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b9ac35c7a84940be061293cb1f37f7286c4ff941b6fe7324c8dcc6c377fcd53"

URI_x86_64_v2_rust-enum-map+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-map+arbitrary-devel-2.7.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-map+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-map+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-enum-map+arbitrary-devel.sha256sum] = "185f49613e2d92f392b2ef1c8fa89e8a13074dce01df47c88d56a1cef39b6f8a"

URI_x86_64_v2_rust-enum-map+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-map+default-devel-2.7.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-map+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-map+default-devel}"
SRC_URI[x86_64_v2_rust-enum-map+default-devel.sha256sum] = "3218d1a5254505e337ca66dbf6ad2ee0ebb1e1ab4ef4a21a6bdd67779285ac68"

URI_x86_64_v2_rust-enum-map+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-map+serde-devel-2.7.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-map+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-map+serde-devel}"
SRC_URI[x86_64_v2_rust-enum-map+serde-devel.sha256sum] = "aae5ee70027df7b5807a7a86372b23e1055f7fa927b1705f54a43a98b570a788"

URI_x86_64_v2_rust-enum-map-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-map-devel-2.7.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-map-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-map-devel}"
SRC_URI[x86_64_v2_rust-enum-map-devel.sha256sum] = "d73eed74a91645d903d5245ed4f9e61ff84ee5f5c00a20f687c2e7378e1d1cad"

URI_aarch64_rust-enum-map+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-map+arbitrary-devel-2.7.3-2.el10_1.noarch.rpm;name=aarch64_rust-enum-map+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-map+arbitrary-devel}"
SRC_URI[aarch64_rust-enum-map+arbitrary-devel.sha256sum] = "d3784b99233049276cb68c63430ead40690b5f26eeafcc2bf9a6b3edeaa5f4b6"

URI_aarch64_rust-enum-map+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-map+default-devel-2.7.3-2.el10_1.noarch.rpm;name=aarch64_rust-enum-map+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-map+default-devel}"
SRC_URI[aarch64_rust-enum-map+default-devel.sha256sum] = "b7a95052f7958908883f2caa463d4c47ab2d11e3a1cbf17669fdccb5950ce50a"

URI_aarch64_rust-enum-map+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-map+serde-devel-2.7.3-2.el10_1.noarch.rpm;name=aarch64_rust-enum-map+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-map+serde-devel}"
SRC_URI[aarch64_rust-enum-map+serde-devel.sha256sum] = "1206ac1a7e9b9d64b93060cdbec81bba2ad7098e60fdfb9e23de3a53abc12a51"

URI_aarch64_rust-enum-map-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-map-devel-2.7.3-2.el10_1.noarch.rpm;name=aarch64_rust-enum-map-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-map-devel}"
SRC_URI[aarch64_rust-enum-map-devel.sha256sum] = "97362bfa91bad3ccbce271fb797056bdb04b544b98909a8c7bca3fb46e15d65d"

RDEPENDS:rust-enum-map+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-enum-map-devel \
 "
RDEPENDS:rust-enum-map+default-devel = " \
 cargo \
 rust-enum-map-devel \
 "
RDEPENDS:rust-enum-map+serde-devel = " \
 cargo \
 rust-enum-map-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-enum-map-devel = " \
 cargo \
 rust \
 rust-enum-map-derive+default-devel \
 "
