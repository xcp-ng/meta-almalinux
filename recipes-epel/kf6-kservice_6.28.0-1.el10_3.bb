# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kservice"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kservice \
 kf6-kservice-devel \
 kf6-kservice-doc \
 kf6-kservice-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kservice-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce4e1129e36c49aaca12ae203d30be52cdbb5375bfbab81277681de08f058c45"

URI_x86_64_v2_kf6-kservice = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kservice;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice}"
SRC_URI[x86_64_v2_kf6-kservice.sha256sum] = "f02cdb03f7a79444ca6fd4d7b309048f9d15a3a7076b5c283017b2c3252e2190"

URI_x86_64_v2_kf6-kservice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kservice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice-devel}"
SRC_URI[x86_64_v2_kf6-kservice-devel.sha256sum] = "896bdaff6fd2e850f7545824f03ffb2a520d008c070f4c56e9e7b20089bd7fb5"

URI_x86_64_v2_kf6-kservice-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kservice-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice-doc}"
SRC_URI[x86_64_v2_kf6-kservice-doc.sha256sum] = "4e78c433f71920fa3b7a8bfcff8d85a7c418404bff9c13d57edadbeb88b39cc1"

URI_x86_64_v2_kf6-kservice-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kservice-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice-html}"
SRC_URI[x86_64_v2_kf6-kservice-html.sha256sum] = "743e67eb2df6fb92db34bbb2d4354bef64f469217ac692c250005e2572b9d1e5"

URI_aarch64_kf6-kservice = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kservice;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice}"
SRC_URI[aarch64_kf6-kservice.sha256sum] = "6d196fdcfe09f379d029749f8f6ba995ff734903853f27ff7a4145f2417e97bf"

URI_aarch64_kf6-kservice-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kservice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice-devel}"
SRC_URI[aarch64_kf6-kservice-devel.sha256sum] = "509abb019e259a573083468e074ed0e72fc1173fc2d448f7a90828d13553f91b"

URI_aarch64_kf6-kservice-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kservice-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice-doc}"
SRC_URI[aarch64_kf6-kservice-doc.sha256sum] = "e8c5d148de65558855f6d49bff885a9e355d1effe3d95cf7c763126cb51350ed"

URI_aarch64_kf6-kservice-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kservice-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice-html}"
SRC_URI[aarch64_kf6-kservice-html.sha256sum] = "76aec0b0597bf854df59d7be81934ddd88a990d6c9b0a2927c675e2fd88353bb"

RDEPENDS:kf6-kservice = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kservice-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kcoreaddons-devel \
 kf6-kservice \
 "
RDEPENDS:kf6-kservice-doc = " \
 "
RDEPENDS:kf6-kservice-html = " \
 "
