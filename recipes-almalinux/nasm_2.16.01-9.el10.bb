# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nasm"
PV = "2.16.01"
PR = "9.el10"
PACKAGES = " \
 nasm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/nasm-2.16.01-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d323044bd78c1a0ffd72a03cd3787d581ab5c7cda29cccf689fd8d1754e0372d"

URI_x86_64_v2_nasm = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nasm-2.16.01-9.el10.x86_64_v2.rpm;name=x86_64_v2_nasm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nasm}"
SRC_URI[x86_64_v2_nasm.sha256sum] = "c0210a8a92f8294a6133136575d5077a2be542879e7ac34cc9778f94ed5e2710"

URI_aarch64_nasm = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nasm-2.16.01-9.el10.aarch64.rpm;name=aarch64_nasm;unpack=0"
SRC_URI:append = " ${URI_aarch64_nasm}"
SRC_URI[aarch64_nasm.sha256sum] = "105afe0c162292aa520989b8564d5d3f22c5ea4c2b95d6ff58676b6481a16e09"

RDEPENDS:nasm = " \
 glibc \
 "
