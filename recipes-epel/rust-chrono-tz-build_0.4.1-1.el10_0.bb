# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chrono-tz-build"
PV = "0.4.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-chrono-tz-build+case-insensitive-devel \
 rust-chrono-tz-build+default-devel \
 rust-chrono-tz-build+filter-by-regex-devel \
 rust-chrono-tz-build+phf_shared-devel \
 rust-chrono-tz-build+regex-devel \
 rust-chrono-tz-build+uncased-devel \
 rust-chrono-tz-build-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chrono-tz-build-0.4.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c2320136cf714d80a3456f383c1a3e6c80b246d97c34f8babaccceca9663607"

URI_x86_64_v2_rust-chrono-tz-build+case-insensitive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build+case-insensitive-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build+case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build+case-insensitive-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build+case-insensitive-devel.sha256sum] = "532bbe9f5cdacb502d6ab35a3b6d901d18f0686e627a041478622e362cf01498"

URI_x86_64_v2_rust-chrono-tz-build+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build+default-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build+default-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build+default-devel.sha256sum] = "58a9b8af68ea9afdae83ce6921d0eccb4989889140e51ea4d9d2aa2046c9f7cb"

URI_x86_64_v2_rust-chrono-tz-build+filter-by-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build+filter-by-regex-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build+filter-by-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build+filter-by-regex-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build+filter-by-regex-devel.sha256sum] = "b71f17a9b73caf26d5be344542a2d62a814848c37ccdfd5ca39a96677c13ab77"

URI_x86_64_v2_rust-chrono-tz-build+phf_shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build+phf_shared-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build+phf_shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build+phf_shared-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build+phf_shared-devel.sha256sum] = "0b3c04d62d27cbe7ea55444d1a09aec632f1a3da33e5261a63c1fdcfd0b2e926"

URI_x86_64_v2_rust-chrono-tz-build+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build+regex-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build+regex-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build+regex-devel.sha256sum] = "6de074e6b8a429dec0a6f299dabcda49a3f52718e7a8bed7002227f60247c9b8"

URI_x86_64_v2_rust-chrono-tz-build+uncased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build+uncased-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build+uncased-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build+uncased-devel.sha256sum] = "f61563d3532fdb3063a94b6541a74015143f6d0439e66eb552b596bb84910cc1"

URI_x86_64_v2_rust-chrono-tz-build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build-devel.sha256sum] = "ccd52c6d7e49410772276e8c98d4afc9d2941199ec5be707580ea17bfdc378d5"

URI_aarch64_rust-chrono-tz-build+case-insensitive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build+case-insensitive-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz-build+case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build+case-insensitive-devel}"
SRC_URI[aarch64_rust-chrono-tz-build+case-insensitive-devel.sha256sum] = "ffeed460d16dc332c7240c3cbe5e9a25b0236331064588b0b33159cbe0d6b7e1"

URI_aarch64_rust-chrono-tz-build+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build+default-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build+default-devel}"
SRC_URI[aarch64_rust-chrono-tz-build+default-devel.sha256sum] = "8c27fdfcf0fae1b728cd2f533edcc4ac7ed41aeb541a321efa31794723d75b16"

URI_aarch64_rust-chrono-tz-build+filter-by-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build+filter-by-regex-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz-build+filter-by-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build+filter-by-regex-devel}"
SRC_URI[aarch64_rust-chrono-tz-build+filter-by-regex-devel.sha256sum] = "341e6d39c8967e9d9ae034120d9be095d2e104995db3c4d5a39d7a60cb77d09e"

URI_aarch64_rust-chrono-tz-build+phf_shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build+phf_shared-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz-build+phf_shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build+phf_shared-devel}"
SRC_URI[aarch64_rust-chrono-tz-build+phf_shared-devel.sha256sum] = "f64111cf37e11dcf6f6eddb8b20a5cd5b1657a1ec019a7394d450d3a975a08ba"

URI_aarch64_rust-chrono-tz-build+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build+regex-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz-build+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build+regex-devel}"
SRC_URI[aarch64_rust-chrono-tz-build+regex-devel.sha256sum] = "4fa1995c12917fe3352d5a0b8d14d70059cf26651caae09852e6d75861152d6d"

URI_aarch64_rust-chrono-tz-build+uncased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build+uncased-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz-build+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build+uncased-devel}"
SRC_URI[aarch64_rust-chrono-tz-build+uncased-devel.sha256sum] = "823dd3065bfdc35f93384782f07d13e99d2e76c9ff4cce9fe6d738e6656cf4a6"

URI_aarch64_rust-chrono-tz-build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz-build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build-devel}"
SRC_URI[aarch64_rust-chrono-tz-build-devel.sha256sum] = "7f4a830a8312ef66cf2e898a9c4c79670bd6a33cfeef984a2ab384dc5871bfe7"

RDEPENDS:rust-chrono-tz-build+case-insensitive-devel = " \
 cargo \
 rust-chrono-tz-build+uncased-devel \
 rust-chrono-tz-build-devel \
 rust-phf_shared+uncased-devel \
 rust-phf_shared-devel \
 "
RDEPENDS:rust-chrono-tz-build+default-devel = " \
 cargo \
 rust-chrono-tz-build-devel \
 "
RDEPENDS:rust-chrono-tz-build+filter-by-regex-devel = " \
 cargo \
 rust-chrono-tz-build+regex-devel \
 rust-chrono-tz-build-devel \
 "
RDEPENDS:rust-chrono-tz-build+phf_shared-devel = " \
 cargo \
 rust-chrono-tz-build-devel \
 rust-phf_shared-devel \
 "
RDEPENDS:rust-chrono-tz-build+regex-devel = " \
 cargo \
 rust-chrono-tz-build-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-chrono-tz-build+uncased-devel = " \
 cargo \
 rust-chrono-tz-build-devel \
 rust-uncased-devel \
 "
RDEPENDS:rust-chrono-tz-build-devel = " \
 cargo \
 rust \
 rust-parse-zoneinfo+default-devel \
 rust-phf_codegen-devel \
 "
