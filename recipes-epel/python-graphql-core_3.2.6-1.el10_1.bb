# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-graphql-core"
PV = "3.2.6"
PR = "1.el10_1"
PACKAGES = " \
 python-graphql-core-doc \
 python3-graphql-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-graphql-core-3.2.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "488af89e94d2a36a200adc3086cabfec9624176d8ab9a1db6370f4f3a0231082"

URI_x86_64_v2_python-graphql-core-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-graphql-core-doc-3.2.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-graphql-core-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-graphql-core-doc}"
SRC_URI[x86_64_v2_python-graphql-core-doc.sha256sum] = "66700e2379e9f8fee27826fbe8a75f8a61f71ab7ae1500d0931e673642a8252e"

URI_x86_64_v2_python3-graphql-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-graphql-core-3.2.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-graphql-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-graphql-core}"
SRC_URI[x86_64_v2_python3-graphql-core.sha256sum] = "56767043b1fa87d3c658302c41b77a3566a19272b69a3a1f773f3029669067b0"

URI_aarch64_python-graphql-core-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-graphql-core-doc-3.2.6-1.el10_1.noarch.rpm;name=aarch64_python-graphql-core-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-graphql-core-doc}"
SRC_URI[aarch64_python-graphql-core-doc.sha256sum] = "cf3245c65fc9d793a749191b31900058523817f1b046b8a96ee9ba14520ec5c7"

URI_aarch64_python3-graphql-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-graphql-core-3.2.6-1.el10_1.noarch.rpm;name=aarch64_python3-graphql-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-graphql-core}"
SRC_URI[aarch64_python3-graphql-core.sha256sum] = "c7d06791d5aadde34c338ecd9985fbf773a74181192b92a6c81a8f9e25f8f85d"

RDEPENDS:python-graphql-core-doc = " \
 "
RDEPENDS:python3-graphql-core = " \
 python3 \
 "
