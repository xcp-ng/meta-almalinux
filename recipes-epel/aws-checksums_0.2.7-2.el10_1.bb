# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-checksums"
PV = "0.2.7"
PR = "2.el10_1"
PACKAGES = " \
 aws-checksums \
 aws-checksums-devel \
 aws-checksums-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-checksums-0.2.7-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdabc604c39c7239ca650a6c46539938ebf7db8bd026d03eff14f864d7ce8c9c"

URI_x86_64_v2_aws-checksums = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-checksums-0.2.7-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-checksums;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-checksums}"
SRC_URI[x86_64_v2_aws-checksums.sha256sum] = "cfb54f48aa343e7a67c9dd3408e82dd21634f88d94d1b1134d0e3aea25e9df53"

URI_x86_64_v2_aws-checksums-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-checksums-devel-0.2.7-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-checksums-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-checksums-devel}"
SRC_URI[x86_64_v2_aws-checksums-devel.sha256sum] = "ad197e61a448555af28f097accd352c1e5c111a0416f68eaaf180dd3af066ec7"

URI_x86_64_v2_aws-checksums-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-checksums-libs-0.2.7-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-checksums-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-checksums-libs}"
SRC_URI[x86_64_v2_aws-checksums-libs.sha256sum] = "c743391e9d6eb6a461b7f67167a4ed05190401cb2372e2fb8ecce5bb3bd5c658"

URI_aarch64_aws-checksums = "${EPEL_MIRROR}/aarch64/Packages/a/aws-checksums-0.2.7-2.el10_1.aarch64.rpm;name=aarch64_aws-checksums;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-checksums}"
SRC_URI[aarch64_aws-checksums.sha256sum] = "21bca7d1c6e80a1a8632e77e6178a056cdf473b39bb1e56ef9d85a42d44832b3"

URI_aarch64_aws-checksums-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-checksums-devel-0.2.7-2.el10_1.aarch64.rpm;name=aarch64_aws-checksums-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-checksums-devel}"
SRC_URI[aarch64_aws-checksums-devel.sha256sum] = "aef4a0a1a29186545eb404e30538154604203b2a248bca1d8d396d0f6e01a27c"

URI_aarch64_aws-checksums-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-checksums-libs-0.2.7-2.el10_1.aarch64.rpm;name=aarch64_aws-checksums-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-checksums-libs}"
SRC_URI[aarch64_aws-checksums-libs.sha256sum] = "4b4e813f3c032c6ff38ee909257424c5cfe9eaddd2ed2682610c3ed87699828b"

RDEPENDS:aws-checksums = " \
 aws-c-common-libs \
 aws-checksums-libs \
 glibc \
 "
RDEPENDS:aws-checksums-devel = " \
 aws-c-common-devel \
 aws-checksums \
 aws-checksums-libs \
 cmake-filesystem \
 "
RDEPENDS:aws-checksums-libs = " \
 aws-c-common-libs \
 aws-checksums \
 glibc \
 "
