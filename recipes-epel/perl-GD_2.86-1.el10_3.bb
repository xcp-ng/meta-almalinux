# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GD"
PV = "2.86"
PR = "1.el10_3"
PACKAGES = " \
 perl-GD \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-GD-2.86-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbca3bd546fe8bae58e1d5e16d7c01f9d5aa2a3f3be3a090ee97a9b11c199a44"

URI_x86_64_v2_perl-GD = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GD-2.86-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-GD;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GD}"
SRC_URI[x86_64_v2_perl-GD.sha256sum] = "7d2a097ad4dbe218db44884e287d56fbf5accedf612e55019f2df0499a8822ce"

URI_aarch64_perl-GD = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GD-2.86-1.el10_3.aarch64.rpm;name=aarch64_perl-GD;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GD}"
SRC_URI[aarch64_perl-GD.sha256sum] = "f9552bcd4f8cb172caa5a31137d94208e5a93c3e9e2af02d42fae4190c6a4885"

RDEPENDS:perl-GD = " \
 gd \
 glibc \
 perl-AutoLoader \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-FileHandle \
 perl-GD \
 perl-Math-Complex \
 perl-Symbol \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
