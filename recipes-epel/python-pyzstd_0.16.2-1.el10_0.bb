# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyzstd"
PV = "0.16.2"
PR = "1.el10_0"
PACKAGES = " \
 python3-pyzstd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyzstd-0.16.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78dffa778cc339ef3288b91271906356c48ff3c193b9954c4163566b71dfc31b"

URI_x86_64_v2_python3-pyzstd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyzstd-0.16.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyzstd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyzstd}"
SRC_URI[x86_64_v2_python3-pyzstd.sha256sum] = "4d95aabfe239e131e24b0473edfe0d3d6b8627d595078280ece1b08c99baacaa"

URI_aarch64_python3-pyzstd = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyzstd-0.16.2-1.el10_0.aarch64.rpm;name=aarch64_python3-pyzstd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyzstd}"
SRC_URI[aarch64_python3-pyzstd.sha256sum] = "3189931b874210590d0788c0923c9eade58f13f8e12ff80b6208726e4ffbf7af"

RDEPENDS:python3-pyzstd = " \
 glibc \
 libzstd \
 python3 \
 "
