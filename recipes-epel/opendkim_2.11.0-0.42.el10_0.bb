# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opendkim"
PV = "2.11.0"
PR = "0.42.el10_0"
PACKAGES = " \
 libopendkim \
 libopendkim-devel \
 opendkim \
 opendkim-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opendkim-2.11.0-0.42.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3a8a1d34f920e703449341a4257dc08ef080100e832cb337e5ab04d6cad89c4"

URI_x86_64_v2_libopendkim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopendkim-2.11.0-0.42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopendkim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopendkim}"
SRC_URI[x86_64_v2_libopendkim.sha256sum] = "08401b657e04968c4d084ddd031167df2f6c43496cd4c6ab316150122dd846bf"

URI_x86_64_v2_libopendkim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopendkim-devel-2.11.0-0.42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopendkim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopendkim-devel}"
SRC_URI[x86_64_v2_libopendkim-devel.sha256sum] = "f0cc701952d93fba80fdeffd8f52a4f936304d1ee0ead3ed551c4b457b30663a"

URI_x86_64_v2_opendkim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendkim-2.11.0-0.42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendkim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendkim}"
SRC_URI[x86_64_v2_opendkim.sha256sum] = "8a2208fbc572689d894fe4f8019127b1e37a464a2a6b84e825dc1a0405ef1a43"

URI_x86_64_v2_opendkim-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendkim-tools-2.11.0-0.42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendkim-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendkim-tools}"
SRC_URI[x86_64_v2_opendkim-tools.sha256sum] = "af56b3e7be006e58b265cdda3995cf6b29c061d78c1b5588ad718ff1e60ff977"

URI_aarch64_libopendkim = "${EPEL_MIRROR}/aarch64/Packages/l/libopendkim-2.11.0-0.42.el10_0.aarch64.rpm;name=aarch64_libopendkim;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopendkim}"
SRC_URI[aarch64_libopendkim.sha256sum] = "2f218d3afc657b127897ee230330d54276d38484aef171da737ff67b9dc9788c"

URI_aarch64_libopendkim-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopendkim-devel-2.11.0-0.42.el10_0.aarch64.rpm;name=aarch64_libopendkim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopendkim-devel}"
SRC_URI[aarch64_libopendkim-devel.sha256sum] = "32f1bfdb0b34d3cfe71b0f41efc7211ce57b920678e6b577bbc92208a4dd262a"

URI_aarch64_opendkim = "${EPEL_MIRROR}/aarch64/Packages/o/opendkim-2.11.0-0.42.el10_0.aarch64.rpm;name=aarch64_opendkim;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendkim}"
SRC_URI[aarch64_opendkim.sha256sum] = "601af7a147f01eaa4a86bb5c6fe3322285d9f17d35e1aaa0b7547d635263db61"

URI_aarch64_opendkim-tools = "${EPEL_MIRROR}/aarch64/Packages/o/opendkim-tools-2.11.0-0.42.el10_0.aarch64.rpm;name=aarch64_opendkim-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendkim-tools}"
SRC_URI[aarch64_opendkim-tools.sha256sum] = "766e492e5b8571074856f604994a97b90f21095611865a2a5be75309ae797be6"

RDEPENDS:libopendkim = " \
 glibc \
 libdb \
 openssl-libs \
 "
RDEPENDS:libopendkim-devel = " \
 libopendkim \
 pkgconf-pkg-config \
 "
RDEPENDS:opendkim = " \
 bash \
 glibc \
 libdb \
 libmemcached-awesome \
 libopendkim \
 lua-libs \
 opendbx \
 openldap \
 openssl-libs \
 sendmail-milter \
 systemd \
 "
RDEPENDS:opendkim-tools = " \
 glibc \
 libdb \
 libmemcached-awesome \
 libopendkim \
 lua-libs \
 opendbx \
 openldap \
 openssl-libs \
 perl-interpreter \
 "
