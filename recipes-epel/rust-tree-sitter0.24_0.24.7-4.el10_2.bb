# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter0.24"
PV = "0.24.7"
PR = "4.el10_2"
PACKAGES = " \
 rust-tree-sitter0.24+default-devel \
 rust-tree-sitter0.24+std-devel \
 rust-tree-sitter0.24-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter0.24-0.24.7-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a085093fb819e2e7028cad357de301331b9052c52fe75e5c512344ebc3e5851"

URI_x86_64_v2_rust-tree-sitter0.24+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter0.24+default-devel-0.24.7-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter0.24+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter0.24+default-devel.sha256sum] = "673686959090eaeced605886fc7589b67c91f8f9bf074a21e887d5dfc876d317"

URI_x86_64_v2_rust-tree-sitter0.24+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter0.24+std-devel-0.24.7-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter0.24+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter0.24+std-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter0.24+std-devel.sha256sum] = "d78d2c04898af407b4a3d36a400e22204dbea9e0cba6bcbb93ae24b0edcb9afd"

URI_x86_64_v2_rust-tree-sitter0.24-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter0.24-devel-0.24.7-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter0.24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter0.24-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter0.24-devel.sha256sum] = "fbc92835d3abe9963bc5a03e4dcdd8c7b5054abb0f663228d51973476e8955d3"

URI_aarch64_rust-tree-sitter0.24+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter0.24+default-devel-0.24.7-4.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter0.24+default-devel}"
SRC_URI[aarch64_rust-tree-sitter0.24+default-devel.sha256sum] = "311dbde54568db2bafba2395e0e9ab34ecc4b5e371fb524ef36578b5bc254949"

URI_aarch64_rust-tree-sitter0.24+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter0.24+std-devel-0.24.7-4.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter0.24+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter0.24+std-devel}"
SRC_URI[aarch64_rust-tree-sitter0.24+std-devel.sha256sum] = "16fbf2cdea843f6e0b238a907a11e96e03926b5bafb52d4c7097ca618531eb4f"

URI_aarch64_rust-tree-sitter0.24-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter0.24-devel-0.24.7-4.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter0.24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter0.24-devel}"
SRC_URI[aarch64_rust-tree-sitter0.24-devel.sha256sum] = "654646bcf48b4df88f132d24e8ecf2105685f24a6e46318418b6c897c59147d2"

RDEPENDS:rust-tree-sitter0.24+default-devel = " \
 cargo \
 rust-tree-sitter0.24+std-devel \
 rust-tree-sitter0.24-devel \
 "
RDEPENDS:rust-tree-sitter0.24+std-devel = " \
 cargo \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-syntax+unicode-devel \
 rust-tree-sitter0.24-devel \
 "
RDEPENDS:rust-tree-sitter0.24-devel = " \
 cargo \
 rust \
 rust-bindgen+default-devel \
 rust-cc+default-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax-devel \
 rust-streaming-iterator+default-devel \
 rust-tree-sitter-language+default-devel \
 "
