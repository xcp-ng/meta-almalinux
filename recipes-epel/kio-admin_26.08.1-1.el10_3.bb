# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-admin"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kio-admin \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kio-admin-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c6454dda1e6ff554667c7e5dd142b13123ec10402c90dfc67b7e186a2177afa1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-admin-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-admin;unpack=0"
SRC_URI[x86_64_v2_kio-admin.sha256sum] = "611b4fa5b4a60168390bc01960ba4088d30f6e04a6bb93d4b35a0e8848825b0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kio-admin-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kio-admin;unpack=0"
SRC_URI[aarch64_kio-admin.sha256sum] = "a90b4aa35a2f055533281915360e57a0bbc5bc19fa387292caa36ef12bcdbed5"

RDEPENDS:kio-admin = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 libatomic \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
