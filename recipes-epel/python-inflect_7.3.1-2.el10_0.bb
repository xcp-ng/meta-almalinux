# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-inflect"
PV = "7.3.1"
PR = "2.el10_0"
PACKAGES = " \
 python3-inflect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-inflect-7.3.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "673b25edc114672323c6c72f8a713a2341083503660863d5918ed5088948aec7"

URI_x86_64_v2_python3-inflect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-inflect-7.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-inflect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-inflect}"
SRC_URI[x86_64_v2_python3-inflect.sha256sum] = "bbeec879b636c615e4af23a9a7358e914ac505413a0a4761acd87f1d5d3f087a"

URI_aarch64_python3-inflect = "${EPEL_MIRROR}/aarch64/Packages/p/python3-inflect-7.3.1-2.el10_0.noarch.rpm;name=aarch64_python3-inflect;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-inflect}"
SRC_URI[aarch64_python3-inflect.sha256sum] = "f0f2cb749a2f4909ba56289b24aff2f6af7266eb5bfca641e2eec71f44ccfe9f"

RDEPENDS:python3-inflect = " \
 python3 \
 python3-more-itertools \
 python3-typeguard \
 "
