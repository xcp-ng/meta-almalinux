# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kirigami-gallery"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kirigami-gallery \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kirigami-gallery-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b61257b5e397463c10f58c994f026d7944024d951edbdc8d404a404b0f9ca0f5"

URI_x86_64_v2_kirigami-gallery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kirigami-gallery-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kirigami-gallery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kirigami-gallery}"
SRC_URI[x86_64_v2_kirigami-gallery.sha256sum] = "f5e3d4dff66593861b2ea8f71cc9ac41cab2a7fe06091bd3e6b1e06229a3313a"

URI_aarch64_kirigami-gallery = "${EPEL_MIRROR}/aarch64/Packages/k/kirigami-gallery-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kirigami-gallery;unpack=0"
SRC_URI:append = " ${URI_aarch64_kirigami-gallery}"
SRC_URI[aarch64_kirigami-gallery.sha256sum] = "c2ccec37e4a11156e6eb5aa5b6448e5f52b0a881f27ea643dc7a2bda754c2764"

RDEPENDS:kirigami-gallery = " \
 breeze-icon-theme \
 glibc \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
