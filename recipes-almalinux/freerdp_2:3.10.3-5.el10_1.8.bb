# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freerdp"
PE = "2"
PV = "3.10.3"
PR = "5.el10_1.8"
PACKAGES = " \
 freerdp \
 freerdp-devel \
 freerdp-libs \
 freerdp-server \
 libwinpr \
 libwinpr-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freerdp-3.10.3-5.el10_1.8.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9234baac66ae83beb50e610795379ac13cf514dd6497945bf8b7f02ab8fe65f"

URI_x86_64_v2_freerdp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freerdp-3.10.3-5.el10_1.8.x86_64_v2.rpm;name=x86_64_v2_freerdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp}"
SRC_URI[x86_64_v2_freerdp.sha256sum] = "17327f6b7ee3fe580b109b09fbb951ac7262d6aaf8856c93d366682291edc26b"

URI_x86_64_v2_freerdp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freerdp-devel-3.10.3-5.el10_1.8.x86_64_v2.rpm;name=x86_64_v2_freerdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp-devel}"
SRC_URI[x86_64_v2_freerdp-devel.sha256sum] = "b16b3f1ee92323f18cf2f42251e0178330f52e4de7d2a97067ee12e285fd69b8"

URI_x86_64_v2_freerdp-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freerdp-libs-3.10.3-5.el10_1.8.x86_64_v2.rpm;name=x86_64_v2_freerdp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp-libs}"
SRC_URI[x86_64_v2_freerdp-libs.sha256sum] = "04df8c75068e6c4688f92764824973444412d16d152ca739bf41320c4af986ea"

URI_x86_64_v2_freerdp-server = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freerdp-server-3.10.3-5.el10_1.8.x86_64_v2.rpm;name=x86_64_v2_freerdp-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp-server}"
SRC_URI[x86_64_v2_freerdp-server.sha256sum] = "711cac3b0025e513e6381dda4f410feead57f29cf518c8f53a6936a66b8b3225"

URI_x86_64_v2_libwinpr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwinpr-3.10.3-5.el10_1.8.x86_64_v2.rpm;name=x86_64_v2_libwinpr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwinpr}"
SRC_URI[x86_64_v2_libwinpr.sha256sum] = "95252e7afd65e2ce40a44dd74385938221766f104ed54f3b2aeeff44dcd99ca3"

URI_x86_64_v2_libwinpr-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwinpr-devel-3.10.3-5.el10_1.8.x86_64_v2.rpm;name=x86_64_v2_libwinpr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwinpr-devel}"
SRC_URI[x86_64_v2_libwinpr-devel.sha256sum] = "a31014f3eb3ccb065ea8e4a05f2fb7094f081569d92a89bcab5d1525587d0f04"

URI_aarch64_freerdp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freerdp-3.10.3-5.el10_1.8.aarch64.rpm;name=aarch64_freerdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp}"
SRC_URI[aarch64_freerdp.sha256sum] = "95038b600e522adfec8525fdc352e0d34a393ec8a47fd16eb41521b4b1c2fc69"

URI_aarch64_freerdp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freerdp-devel-3.10.3-5.el10_1.8.aarch64.rpm;name=aarch64_freerdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp-devel}"
SRC_URI[aarch64_freerdp-devel.sha256sum] = "ac66cb955865ed760197dc01cac55d5a0442eebfe409ac4bb27cd04fd6f790e9"

URI_aarch64_freerdp-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freerdp-libs-3.10.3-5.el10_1.8.aarch64.rpm;name=aarch64_freerdp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp-libs}"
SRC_URI[aarch64_freerdp-libs.sha256sum] = "ea926fd9acf35159b002b88aad5849bca7144bf0fbe55394ade106d201db2bf9"

URI_aarch64_freerdp-server = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freerdp-server-3.10.3-5.el10_1.8.aarch64.rpm;name=aarch64_freerdp-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp-server}"
SRC_URI[aarch64_freerdp-server.sha256sum] = "4bd347a642ba76d85ff18f29e2b39dc3ff9b870902b96e3738483e96cd2612a2"

URI_aarch64_libwinpr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwinpr-3.10.3-5.el10_1.8.aarch64.rpm;name=aarch64_libwinpr;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwinpr}"
SRC_URI[aarch64_libwinpr.sha256sum] = "7ee5e72efd033e947ba8b166f1eebcb1672e5427b4c6b21dc4245914e3217fdc"

URI_aarch64_libwinpr-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwinpr-devel-3.10.3-5.el10_1.8.aarch64.rpm;name=aarch64_libwinpr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwinpr-devel}"
SRC_URI[aarch64_libwinpr-devel.sha256sum] = "4a3277e25bcf4b662e1d23d0898edd904163ec2aaedecf59fd8cceb1e879d221"

RDEPENDS:freerdp = " \
 freerdp-libs \
 glibc \
 libX11 \
 libXcursor \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libXrender \
 libwayland-client \
 libwayland-cursor \
 libwinpr \
 libxkbcommon \
 "
RDEPENDS:freerdp-devel = " \
 cmake \
 cmake-filesystem \
 freerdp-devel \
 freerdp-libs \
 libwinpr-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:freerdp-libs = " \
 alsa-lib \
 cairo \
 cups-libs \
 fdk-aac-free \
 fuse3-libs \
 glibc \
 gsm \
 lame-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXinerama \
 libXtst \
 libgcc \
 libstdc++ \
 libusb1 \
 libwinpr \
 libxkbfile \
 openssl-libs \
 opus \
 pam-libs \
 pulseaudio-libs \
 zlib-ng-compat \
 "
RDEPENDS:freerdp-server = " \
 freerdp-libs \
 glibc \
 libwinpr \
 "
RDEPENDS:libwinpr = " \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libicu \
 libjpeg-turbo \
 libpng \
 libwebp \
 openssl-libs \
 "
RDEPENDS:libwinpr-devel = " \
 cmake \
 cmake-filesystem \
 libwinpr \
 libwinpr-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
