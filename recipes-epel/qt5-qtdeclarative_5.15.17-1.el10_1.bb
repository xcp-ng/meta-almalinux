# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtdeclarative"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtdeclarative \
 qt5-qtdeclarative-devel \
 qt5-qtdeclarative-examples \
 qt5-qtdeclarative-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtdeclarative-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc13102a67fb337e88e801d406409c2769716e2e1ebe33a6d972f7e5b1271cbf"

URI_x86_64_v2_qt5-qtdeclarative = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdeclarative;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative}"
SRC_URI[x86_64_v2_qt5-qtdeclarative.sha256sum] = "cc695f31988840dc0d4ac69bf0069c3efd59fef342e52eddfe3cdea85708b60b"

URI_x86_64_v2_qt5-qtdeclarative-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative-devel}"
SRC_URI[x86_64_v2_qt5-qtdeclarative-devel.sha256sum] = "49f6e53e11168120d3934d18a80dc7a9ab9a390209f8cd3db42e577ebc94d485"

URI_x86_64_v2_qt5-qtdeclarative-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdeclarative-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative-examples}"
SRC_URI[x86_64_v2_qt5-qtdeclarative-examples.sha256sum] = "34dcd5c4a1a9ce88a05260bf705d87a01e96f8c61f48e1d75690777a06a5e245"

URI_x86_64_v2_qt5-qtdeclarative-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-static-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdeclarative-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative-static}"
SRC_URI[x86_64_v2_qt5-qtdeclarative-static.sha256sum] = "9d93ea64d554015e1d495d27121d3b6ac4b4c958c1728d0ccb88957d89308105"

URI_aarch64_qt5-qtdeclarative = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtdeclarative;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative}"
SRC_URI[aarch64_qt5-qtdeclarative.sha256sum] = "1f59d742cef2e2fd60ef8db403a1c33cbf101a73f5b38abd34396934c79a0afd"

URI_aarch64_qt5-qtdeclarative-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative-devel}"
SRC_URI[aarch64_qt5-qtdeclarative-devel.sha256sum] = "8e0914487bc39a129c3065fbef4f6ddc50069796e608c85a05fbff6f7c1c853f"

URI_aarch64_qt5-qtdeclarative-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtdeclarative-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative-examples}"
SRC_URI[aarch64_qt5-qtdeclarative-examples.sha256sum] = "fa8e315c8dc352e2b07e6e3e18ed18a0bc025cc600e8d7ab8adb5a36d91a7fa2"

URI_aarch64_qt5-qtdeclarative-static = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-static-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtdeclarative-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative-static}"
SRC_URI[aarch64_qt5-qtdeclarative-static.sha256sum] = "3087ef65bdc08a6f050a1da722496f0fbdc09c8f59e66a654a7c7a83275ae779"

RDEPENDS:qt5-qtdeclarative:x86_64_v2 = " \
 glibc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
"
RDEPENDS:qt5-qtdeclarative:aarch64 = " \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
"
RDEPENDS:qt5-qtdeclarative-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtdeclarative-devel \
 "
RDEPENDS:qt5-qtdeclarative-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtdeclarative-static = " \
 qt5-qtdeclarative-devel \
 "
