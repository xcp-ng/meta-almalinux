# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "myrepos"
PV = "1.20180726"
PR = "20.el10_0"
PACKAGES = " \
 myrepos \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/myrepos-1.20180726-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8228b81f563f7751e6915ded33c6f5996b47d64213a85ca23ec7e218caa5ab95"

URI_x86_64_v2_myrepos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myrepos-1.20180726-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_myrepos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myrepos}"
SRC_URI[x86_64_v2_myrepos.sha256sum] = "68731959768fb15ecc5ae98d0ebd5b187d01a701dea95b4ad152ee711d735799"

URI_aarch64_myrepos = "${EPEL_MIRROR}/aarch64/Packages/m/myrepos-1.20180726-20.el10_0.noarch.rpm;name=aarch64_myrepos;unpack=0"
SRC_URI:append = " ${URI_aarch64_myrepos}"
SRC_URI[aarch64_myrepos.sha256sum] = "eba6fda9a1af007824ef4b292307b69dcced108946d207ebc522aac8430906d8"

RDEPENDS:myrepos = " \
 git \
 perl-File-Copy \
 perl-FindBin \
 perl-Getopt-Long \
 perl-PathTools \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
