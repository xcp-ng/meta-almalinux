# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dlm"
PV = "4.3.0"
PR = "1.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dlm-4.3.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41cb3effe672a7573bf42bab0a56bc956d943fb893d35d69c591dfdee18f7e13"

