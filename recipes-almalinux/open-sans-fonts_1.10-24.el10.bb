# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "open-sans-fonts"
PV = "1.10"
PR = "24.el10"
PACKAGES = " \
 open-sans-fonts \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/open-sans-fonts-1.10-24.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b4dff4eab5af8d1a66a50756bf46fa7f9f1d1da887e6b5c1f4f94a8faae6f393"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-sans-fonts-1.10-24.el10.noarch.rpm;name=x86_64_v2_open-sans-fonts;unpack=0"
SRC_URI[x86_64_v2_open-sans-fonts.sha256sum] = "4211226285b5fe071f9d5d1609be60ff3cef2074ca232afdabfb367d2ee9c51d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/open-sans-fonts-1.10-24.el10.noarch.rpm;name=aarch64_open-sans-fonts;unpack=0"
SRC_URI[aarch64_open-sans-fonts.sha256sum] = "4211226285b5fe071f9d5d1609be60ff3cef2074ca232afdabfb367d2ee9c51d"

RDEPENDS:open-sans-fonts = " \
 fonts-filesystem \
 "
