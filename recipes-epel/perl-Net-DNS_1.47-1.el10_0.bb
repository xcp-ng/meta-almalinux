# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-DNS"
PV = "1.47"
PR = "1.el10_0"
PACKAGES = " \
 perl-Net-DNS \
 perl-Net-DNS-Nameserver \
 perl-Net-DNS-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-DNS-1.47-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c20b92e4791dc73be733d3e2b03f81190233f96abaa7e6eeb0b58c0c2995d369"

URI_x86_64_v2_perl-Net-DNS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-DNS-1.47-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-DNS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-DNS}"
SRC_URI[x86_64_v2_perl-Net-DNS.sha256sum] = "5c58226b2369a62d1ef38aa24dc6832c97bc40f43b0cf83811e7494a1420b9fa"

URI_x86_64_v2_perl-Net-DNS-Nameserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-DNS-Nameserver-1.47-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-DNS-Nameserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-DNS-Nameserver}"
SRC_URI[x86_64_v2_perl-Net-DNS-Nameserver.sha256sum] = "2bdbcd90353f5746cf55cfd21d5a35ddc84d35120df1ffe22a5135074b3ea03a"

URI_x86_64_v2_perl-Net-DNS-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-DNS-tests-1.47-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-DNS-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-DNS-tests}"
SRC_URI[x86_64_v2_perl-Net-DNS-tests.sha256sum] = "6584bc0bcf6bb7c7ed6ea06438bf89be92816821a826b666985b04f4f86dd0b8"

URI_aarch64_perl-Net-DNS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-DNS-1.47-1.el10_0.noarch.rpm;name=aarch64_perl-Net-DNS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-DNS}"
SRC_URI[aarch64_perl-Net-DNS.sha256sum] = "ce5433779600cc66693b9fa4e66752af81d8c0c89721e98bd9029d265f269692"

URI_aarch64_perl-Net-DNS-Nameserver = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-DNS-Nameserver-1.47-1.el10_0.noarch.rpm;name=aarch64_perl-Net-DNS-Nameserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-DNS-Nameserver}"
SRC_URI[aarch64_perl-Net-DNS-Nameserver.sha256sum] = "6d95ebbf9291f8838b536b198a883db085455f9945d3818fdcec073ebdb2fb31"

URI_aarch64_perl-Net-DNS-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-DNS-tests-1.47-1.el10_0.noarch.rpm;name=aarch64_perl-Net-DNS-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-DNS-tests}"
SRC_URI[aarch64_perl-Net-DNS-tests.sha256sum] = "9616b44754eb030115c03c52fbf058f1bc3acc67d83297982799cdd1101049a4"

RDEPENDS:perl-Net-DNS = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Digest-HMAC \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Encode \
 perl-Exporter \
 perl-IO \
 perl-MIME-Base64 \
 perl-Net-DNS \
 perl-Socket \
 perl-Time-Local \
 perl-base \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Net-DNS-Nameserver = " \
 perl-Carp \
 perl-IO \
 perl-IO-Socket-IP \
 perl-Net-DNS \
 perl-Socket \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Net-DNS-tests = " \
 bash \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-Net-DNS \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
