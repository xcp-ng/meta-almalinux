# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_spanned"
PV = "1.0.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-serde_spanned+alloc-devel \
 rust-serde_spanned+default-devel \
 rust-serde_spanned+serde-devel \
 rust-serde_spanned+std-devel \
 rust-serde_spanned-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_spanned-1.0.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cae18d98647fe7de28e5f81cf211551a7850b58883130a35f9150f4ccf43fd1c"

URI_x86_64_v2_rust-serde_spanned+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+alloc-devel-1.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+alloc-devel.sha256sum] = "3e1c025eab52adeb9de697d465fdf59032d24fd15d00d7c41e4093fbc1d86871"

URI_x86_64_v2_rust-serde_spanned+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+default-devel-1.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+default-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+default-devel.sha256sum] = "62ff72ae98cecc889e60c21c20eb157de440adc1c60ad1aef17516d41b682856"

URI_x86_64_v2_rust-serde_spanned+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+serde-devel-1.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+serde-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+serde-devel.sha256sum] = "7ec618fea575972694e52134bf9ed0eeeee2661c7d2805134700c3fd75ab2b8b"

URI_x86_64_v2_rust-serde_spanned+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+std-devel-1.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+std-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+std-devel.sha256sum] = "c94e2b40305cbc9b42b83f8f43d7141a9f98e4ef35711946511748329beeeb80"

URI_x86_64_v2_rust-serde_spanned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned-devel-1.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned-devel.sha256sum] = "1b2a7b8f194ca3d300d11706189fe71bedafd10e71a090d54a6c93225c8c3e81"

URI_aarch64_rust-serde_spanned+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+alloc-devel-1.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-serde_spanned+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+alloc-devel}"
SRC_URI[aarch64_rust-serde_spanned+alloc-devel.sha256sum] = "1c3f045ccc28c80bcead2b58e7a4f0952625eb6a76b27cf892f183a3f6e948d8"

URI_aarch64_rust-serde_spanned+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+default-devel-1.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-serde_spanned+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+default-devel}"
SRC_URI[aarch64_rust-serde_spanned+default-devel.sha256sum] = "6835e24725ae7443ebc01f40cecc8961e6ae0b25f8850782c04f1a1866e3e5b6"

URI_aarch64_rust-serde_spanned+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+serde-devel-1.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-serde_spanned+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+serde-devel}"
SRC_URI[aarch64_rust-serde_spanned+serde-devel.sha256sum] = "4b2baaf3e3436b59e8109841680c0b289f57c4f31eb42b227066ad4bfd440ad7"

URI_aarch64_rust-serde_spanned+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+std-devel-1.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-serde_spanned+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+std-devel}"
SRC_URI[aarch64_rust-serde_spanned+std-devel.sha256sum] = "3dd4c3050081a52fb8c5b2fd2767a9fa67a4e6f278c1e5ca6fb3906967c128aa"

URI_aarch64_rust-serde_spanned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned-devel-1.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-serde_spanned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned-devel}"
SRC_URI[aarch64_rust-serde_spanned-devel.sha256sum] = "39ac6859dccbe2ce92e595ff402741d436c5e75043d061ab8dadac3a2e2e884a"

RDEPENDS:rust-serde_spanned+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned+default-devel = " \
 cargo \
 rust-serde_spanned+serde-devel \
 rust-serde_spanned+std-devel \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned+std-devel = " \
 cargo \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-serde_spanned+alloc-devel \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned-devel = " \
 cargo \
 rust \
 "
