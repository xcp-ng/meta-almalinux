# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fastfetch"
PV = "2.48.1"
PR = "1.el10_0"
PACKAGES = " \
 fastfetch \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fastfetch-2.48.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "55f8055bdaf0b4bd539352449cd8f10dbe31510e5fb8047943e09c1bf8291da4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fastfetch-2.48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fastfetch;unpack=0"
SRC_URI[x86_64_v2_fastfetch.sha256sum] = "1bf5ded4e7741d3fc0e45d96dbb519f719ab0b6e01f04e2abc44b60b6c2d050a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fastfetch-2.48.1-1.el10_0.aarch64.rpm;name=aarch64_fastfetch;unpack=0"
SRC_URI[aarch64_fastfetch.sha256sum] = "5275e3ea3b1e0a232be0a5c74dd820cbfe12951f9257df4afc23241bd5217e8c"

RDEPENDS:fastfetch = " \
 glibc \
 libgcc \
 yyjson \
 "
