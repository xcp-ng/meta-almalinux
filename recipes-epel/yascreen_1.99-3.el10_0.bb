# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yascreen"
PV = "1.99"
PR = "3.el10_0"
PACKAGES = " \
 yascreen \
 yascreen-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/y/yascreen-1.99-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "992d38a926f3ba34f30a429ed9ad1aa68851d75ed7139371e678208ab7e28548"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yascreen-1.99-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yascreen;unpack=0"
SRC_URI[x86_64_v2_yascreen.sha256sum] = "7d8ce5742f46a890e79aea74e3fae9b8e84f280e88393e7331506bc16298fd3d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yascreen-devel-1.99-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yascreen-devel;unpack=0"
SRC_URI[x86_64_v2_yascreen-devel.sha256sum] = "66a94ad403261368da2f045da7b427b8fb2149304f59055f70799501e286b201"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/y/yascreen-1.99-3.el10_0.aarch64.rpm;name=aarch64_yascreen;unpack=0"
SRC_URI[aarch64_yascreen.sha256sum] = "c2066220ace7d3571679b83a78c1447697ff4c9f68ff6410f13e8489c12ea355"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/y/yascreen-devel-1.99-3.el10_0.aarch64.rpm;name=aarch64_yascreen-devel;unpack=0"
SRC_URI[aarch64_yascreen-devel.sha256sum] = "d45e4c5540befa79e2794addc9ec71fd8b5d6f1a03f51c8609970856d42e7db6"

RDEPENDS:yascreen = " \
 glibc \
 "
RDEPENDS:yascreen-devel = " \
 pkgconf-pkg-config \
 yascreen \
 "
