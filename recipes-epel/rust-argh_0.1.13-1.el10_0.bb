# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-argh"
PV = "0.1.13"
PR = "1.el10_0"
PACKAGES = " \
 rust-argh+default-devel \
 rust-argh+help-devel \
 rust-argh+serde-devel \
 rust-argh-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-argh-0.1.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "409dc738f162db01148f868cc61257469cef8691108a1d199086692c1567135b"

URI_x86_64_v2_rust-argh+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argh+default-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argh+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argh+default-devel}"
SRC_URI[x86_64_v2_rust-argh+default-devel.sha256sum] = "f617d813b645ccd274f470fbbabd82f6a158965660bdc9420ae3d567c07ec884"

URI_x86_64_v2_rust-argh+help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argh+help-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argh+help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argh+help-devel}"
SRC_URI[x86_64_v2_rust-argh+help-devel.sha256sum] = "a1bffe075fdd08e7934a3154acaa1346bc05d94e3de54ee8704fc52ac0469275"

URI_x86_64_v2_rust-argh+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argh+serde-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argh+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argh+serde-devel}"
SRC_URI[x86_64_v2_rust-argh+serde-devel.sha256sum] = "d7bee6449ff25f989cdac3f2463d9da17da37469ebb938cf7a45ef1c32fa18de"

URI_x86_64_v2_rust-argh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argh-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argh-devel}"
SRC_URI[x86_64_v2_rust-argh-devel.sha256sum] = "e6a6d49b4e3133ba76110c45af2eefb390b7bdf005b2c65dbc54f72840279971"

URI_aarch64_rust-argh+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argh+default-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-argh+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argh+default-devel}"
SRC_URI[aarch64_rust-argh+default-devel.sha256sum] = "731829646c8b628c352be2facc9dac47f1203b8c76d816d03f059595d23381ea"

URI_aarch64_rust-argh+help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argh+help-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-argh+help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argh+help-devel}"
SRC_URI[aarch64_rust-argh+help-devel.sha256sum] = "d04e705fe254ce70f7e70822444d047602dd97408a0c3c8bdbf895b34b5e7852"

URI_aarch64_rust-argh+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argh+serde-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-argh+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argh+serde-devel}"
SRC_URI[aarch64_rust-argh+serde-devel.sha256sum] = "0bd9ca20a93d432529bf0296c5246872b4c0bbc6ccd84c485c720f21e918cff0"

URI_aarch64_rust-argh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argh-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-argh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argh-devel}"
SRC_URI[aarch64_rust-argh-devel.sha256sum] = "4703945dbf25691a72b3a3dbdda597282b0eb5716077b5053701973bb57f9bf0"

RDEPENDS:rust-argh+default-devel = " \
 cargo \
 rust-argh+help-devel \
 rust-argh+serde-devel \
 rust-argh-devel \
 "
RDEPENDS:rust-argh+help-devel = " \
 cargo \
 rust-argh-devel \
 rust-argh_derive+help-devel \
 "
RDEPENDS:rust-argh+serde-devel = " \
 cargo \
 rust-argh-devel \
 rust-argh_shared+serde-devel \
 "
RDEPENDS:rust-argh-devel = " \
 cargo \
 rust-argh_derive+default-devel \
 rust-argh_shared+default-devel \
 rust-rust-fuzzy-search+default-devel \
 "
