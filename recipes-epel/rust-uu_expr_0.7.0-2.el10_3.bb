# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_expr"
PV = "0.7.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-uu_expr+default-devel \
 rust-uu_expr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_expr-0.7.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea514f317652cfea49c748e6646417f2dcfdd13acbaf9e207c8b23ff4670357a"

URI_x86_64_v2_rust-uu_expr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_expr+default-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_expr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_expr+default-devel}"
SRC_URI[x86_64_v2_rust-uu_expr+default-devel.sha256sum] = "4c10189c34bf1f75e917160360b548304d0c20d6defe9b251dba5ee4388fdab3"

URI_x86_64_v2_rust-uu_expr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_expr-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_expr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_expr-devel}"
SRC_URI[x86_64_v2_rust-uu_expr-devel.sha256sum] = "61336cb76004af390307f1a655f0616b7c87c1e58a1d61d32b28f9e4c1333b65"

URI_aarch64_rust-uu_expr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_expr+default-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_expr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_expr+default-devel}"
SRC_URI[aarch64_rust-uu_expr+default-devel.sha256sum] = "8a81b3bc8fa34221738a35e6db49d54b2b8566d2937c46aaa590cee2ffac7992"

URI_aarch64_rust-uu_expr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_expr-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_expr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_expr-devel}"
SRC_URI[aarch64_rust-uu_expr-devel.sha256sum] = "70b3342f8a7076e7826b189c3dfed72c7a69096b1e243dcd78cc505d4b770761"

RDEPENDS:rust-uu_expr+default-devel = " \
 cargo \
 rust-uu_expr-devel \
 "
RDEPENDS:rust-uu_expr-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-num-bigint+default-devel \
 rust-num-traits+default-devel \
 rust-onig-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+i18n-collator-devel \
 "
