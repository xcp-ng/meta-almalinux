# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hybrid-array"
PV = "0.4.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-hybrid-array+alloc-devel \
 rust-hybrid-array+arbitrary-devel \
 rust-hybrid-array+bytemuck-devel \
 rust-hybrid-array+default-devel \
 rust-hybrid-array+extra-sizes-devel \
 rust-hybrid-array+serde-devel \
 rust-hybrid-array+subtle-devel \
 rust-hybrid-array+zerocopy-devel \
 rust-hybrid-array+zeroize-devel \
 rust-hybrid-array-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hybrid-array-0.4.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d14a496e57f9d0a99568a564339ef1f859d001cb7d482a6018fce98399e41c76"

URI_x86_64_v2_rust-hybrid-array+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+alloc-devel-0.4.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+alloc-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+alloc-devel.sha256sum] = "befa453ebc07a37755cfe658632f39237c793be5fda7b860a145a7fb5b069125"

URI_x86_64_v2_rust-hybrid-array+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+arbitrary-devel-0.4.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+arbitrary-devel.sha256sum] = "1aa8eff14fd9b0bd5126a645ec32f36edaf2db3a4dcf96ad942fa76346b500ac"

URI_x86_64_v2_rust-hybrid-array+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+bytemuck-devel-0.4.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+bytemuck-devel.sha256sum] = "6b310ceb4ae2a8875287a5437e20706d82a82f92fbb1aeb9af92daae7b761da0"

URI_x86_64_v2_rust-hybrid-array+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+default-devel-0.4.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+default-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+default-devel.sha256sum] = "ccb2316daf7d3d3bff473c987ffa7d4d33b25ce88978db22ad7a7649ba89edb7"

URI_x86_64_v2_rust-hybrid-array+extra-sizes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+extra-sizes-devel-0.4.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+extra-sizes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+extra-sizes-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+extra-sizes-devel.sha256sum] = "198eb8666682b3d8d1db040f248c586cf708684d76c5dd90d3f96e31fe19f430"

URI_x86_64_v2_rust-hybrid-array+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+serde-devel-0.4.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+serde-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+serde-devel.sha256sum] = "ba7213b52c88ef77195dc3fd8a01d3a61625f161a2d3c448fe13b411674ec1e9"

URI_x86_64_v2_rust-hybrid-array+subtle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+subtle-devel-0.4.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+subtle-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+subtle-devel.sha256sum] = "20af74a48331739fc42824c64c75bd62367259aed382edbade799dbad633964e"

URI_x86_64_v2_rust-hybrid-array+zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+zerocopy-devel-0.4.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+zerocopy-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+zerocopy-devel.sha256sum] = "6209436ba15ca6c7a11cf479b7f531ed23238ec8dbe79e931f08209306855ec8"

URI_x86_64_v2_rust-hybrid-array+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+zeroize-devel-0.4.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array+zeroize-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array+zeroize-devel.sha256sum] = "614ffa9819c4840007067de3dcdc98871dbb2992b183c0f458e6dbc5ff80c5ab"

URI_x86_64_v2_rust-hybrid-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array-devel-0.4.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hybrid-array-devel}"
SRC_URI[x86_64_v2_rust-hybrid-array-devel.sha256sum] = "cc6fc38d8e36025f07f85dabba52d1b1fe35ca6951260a30ca29c37150a3cfac"

URI_aarch64_rust-hybrid-array+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+alloc-devel-0.4.7-1.el10_2.noarch.rpm;name=aarch64_rust-hybrid-array+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+alloc-devel}"
SRC_URI[aarch64_rust-hybrid-array+alloc-devel.sha256sum] = "95e7f6fcf655f32344d022adb06ae44e40df803a19883d7609d75dd259577ec2"

URI_aarch64_rust-hybrid-array+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+arbitrary-devel-0.4.7-1.el10_2.noarch.rpm;name=aarch64_rust-hybrid-array+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+arbitrary-devel}"
SRC_URI[aarch64_rust-hybrid-array+arbitrary-devel.sha256sum] = "edbff665e66ddd9d1be90c397c4e04e1e289866874f53638445e0718a8951c50"

URI_aarch64_rust-hybrid-array+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+bytemuck-devel-0.4.7-1.el10_2.noarch.rpm;name=aarch64_rust-hybrid-array+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+bytemuck-devel}"
SRC_URI[aarch64_rust-hybrid-array+bytemuck-devel.sha256sum] = "4c71b70a492ae96c24977af14655352d5286471aa91c1aa058dafdc9958e355a"

URI_aarch64_rust-hybrid-array+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+default-devel-0.4.7-1.el10_2.noarch.rpm;name=aarch64_rust-hybrid-array+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+default-devel}"
SRC_URI[aarch64_rust-hybrid-array+default-devel.sha256sum] = "b92b60bfa8bc03683cde9e0ceed9ddd540844c9c6c1830da8cdced7110779679"

URI_aarch64_rust-hybrid-array+extra-sizes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+extra-sizes-devel-0.4.7-1.el10_2.noarch.rpm;name=aarch64_rust-hybrid-array+extra-sizes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+extra-sizes-devel}"
SRC_URI[aarch64_rust-hybrid-array+extra-sizes-devel.sha256sum] = "e0b92f3348665d0d6e86d406442d1aee6fcb5b210de860cc8739486e4613e829"

URI_aarch64_rust-hybrid-array+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+serde-devel-0.4.7-1.el10_2.noarch.rpm;name=aarch64_rust-hybrid-array+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+serde-devel}"
SRC_URI[aarch64_rust-hybrid-array+serde-devel.sha256sum] = "d1f9cbc20ea7a5d7ad091ba8f517c1c9412941a6d97956da06357a97aa563556"

URI_aarch64_rust-hybrid-array+subtle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+subtle-devel-0.4.7-1.el10_2.noarch.rpm;name=aarch64_rust-hybrid-array+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+subtle-devel}"
SRC_URI[aarch64_rust-hybrid-array+subtle-devel.sha256sum] = "46ef7a4cd322bde0238f2d10d5a056ba2ec5037202d30fd9bab636688e917994"

URI_aarch64_rust-hybrid-array+zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+zerocopy-devel-0.4.7-1.el10_2.noarch.rpm;name=aarch64_rust-hybrid-array+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+zerocopy-devel}"
SRC_URI[aarch64_rust-hybrid-array+zerocopy-devel.sha256sum] = "f601875bcc54f6938efef2a8261358bb7455dd160c7cb9eafdc9b60e7ecde3eb"

URI_aarch64_rust-hybrid-array+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+zeroize-devel-0.4.7-1.el10_2.noarch.rpm;name=aarch64_rust-hybrid-array+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array+zeroize-devel}"
SRC_URI[aarch64_rust-hybrid-array+zeroize-devel.sha256sum] = "fa6567085fa6dac0e3d54e4348c48d3440e63d5f552c4ea7284eff0c8aa12341"

URI_aarch64_rust-hybrid-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array-devel-0.4.7-1.el10_2.noarch.rpm;name=aarch64_rust-hybrid-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hybrid-array-devel}"
SRC_URI[aarch64_rust-hybrid-array-devel.sha256sum] = "9ef4c132a185c338e3a904af30c2a56b3fed61cf54e055a4f269cdd4c625add5"

RDEPENDS:rust-hybrid-array+alloc-devel = " \
 cargo \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+bytemuck-devel = " \
 cargo \
 rust-bytemuck-devel \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+default-devel = " \
 cargo \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+extra-sizes-devel = " \
 cargo \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+serde-devel = " \
 cargo \
 rust-hybrid-array-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hybrid-array+subtle-devel = " \
 cargo \
 rust-hybrid-array-devel \
 rust-subtle+const-generics-devel \
 rust-subtle-devel \
 "
RDEPENDS:rust-hybrid-array+zerocopy-devel = " \
 cargo \
 rust-hybrid-array-devel \
 rust-zerocopy+default-devel \
 rust-zerocopy+derive-devel \
 "
RDEPENDS:rust-hybrid-array+zeroize-devel = " \
 cargo \
 rust-hybrid-array-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-hybrid-array-devel = " \
 cargo \
 rust \
 rust-typenum+const-generics-devel \
 rust-typenum+default-devel \
 "
