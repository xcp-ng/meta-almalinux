# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "emacs-yaml-mode"
PV = "0.0.16"
PR = "3.el10_0"
PACKAGES = " \
 emacs-yaml-mode \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/emacs-yaml-mode-0.0.16-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a26035ed5d9076e1659b7296d02b01233a1c62053b562d62a8ee12fef728d8e2"

URI_x86_64_v2_emacs-yaml-mode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/emacs-yaml-mode-0.0.16-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_emacs-yaml-mode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs-yaml-mode}"
SRC_URI[x86_64_v2_emacs-yaml-mode.sha256sum] = "e7d0d5bd952b12a78b9a4b218bc479f00458b5b32a86c4da2e5695aba2f8fc5f"

URI_aarch64_emacs-yaml-mode = "${EPEL_MIRROR}/aarch64/Packages/e/emacs-yaml-mode-0.0.16-3.el10_0.noarch.rpm;name=aarch64_emacs-yaml-mode;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs-yaml-mode}"
SRC_URI[aarch64_emacs-yaml-mode.sha256sum] = "394e763e7aff3b9ddb342f8ba269dd146071f0b191115bf6bee0666035223fe4"

RDEPENDS:emacs-yaml-mode = " \
 virtual/emacs_bin__ge_29.4 \
 "
