# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-goblin"
PV = "0.9.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-goblin+alloc-devel \
 rust-goblin+archive-devel \
 rust-goblin+default-devel \
 rust-goblin+elf32-devel \
 rust-goblin+elf64-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin+log-devel \
 rust-goblin+mach32-devel \
 rust-goblin+mach64-devel \
 rust-goblin+pe32-devel \
 rust-goblin+pe64-devel \
 rust-goblin+std-devel \
 rust-goblin+te-devel \
 rust-goblin-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-goblin-0.9.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b339dd75e77d1dc401cdbe8d92c272e6e96961f0f59dee5f135e9d178f58708b"

URI_x86_64_v2_rust-goblin+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+alloc-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+alloc-devel}"
SRC_URI[x86_64_v2_rust-goblin+alloc-devel.sha256sum] = "0c817f14fff4cd3305c4e241322715aa090609effdc57bb76b06667027ff39c3"

URI_x86_64_v2_rust-goblin+archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+archive-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+archive-devel}"
SRC_URI[x86_64_v2_rust-goblin+archive-devel.sha256sum] = "0aa729e93e4f5efa585cddef0c6d0c1199c8ef72e7d813c940d7a032b2c2b342"

URI_x86_64_v2_rust-goblin+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+default-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+default-devel}"
SRC_URI[x86_64_v2_rust-goblin+default-devel.sha256sum] = "d78eb217a893e574975ec1d020cb2d1a2989996c59ada93c13eab2b7b6885fcd"

URI_x86_64_v2_rust-goblin+elf32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+elf32-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+elf32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+elf32-devel}"
SRC_URI[x86_64_v2_rust-goblin+elf32-devel.sha256sum] = "015f594943468cc624db56d24c3617facfb77368ae13c08d00fcfdecb7e00c0c"

URI_x86_64_v2_rust-goblin+elf64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+elf64-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+elf64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+elf64-devel}"
SRC_URI[x86_64_v2_rust-goblin+elf64-devel.sha256sum] = "f3ab0e9daf4a08d7a65c206fe6e67b5df0cb0a395712cf87832fef9203852deb"

URI_x86_64_v2_rust-goblin+endian_fd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+endian_fd-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+endian_fd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+endian_fd-devel}"
SRC_URI[x86_64_v2_rust-goblin+endian_fd-devel.sha256sum] = "99ebd136c148296b2bc93283f34e1839cd36fafabc630f759209402055ac2799"

URI_x86_64_v2_rust-goblin+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+log-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+log-devel}"
SRC_URI[x86_64_v2_rust-goblin+log-devel.sha256sum] = "b583d30d4eca7cbe88e2ec3773dc641c076832092e9ef8583c165378b8328f03"

URI_x86_64_v2_rust-goblin+mach32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+mach32-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+mach32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+mach32-devel}"
SRC_URI[x86_64_v2_rust-goblin+mach32-devel.sha256sum] = "bf5555981104258fa014f61cc6b5add2d6f72545151599a0bce986e7b8098092"

URI_x86_64_v2_rust-goblin+mach64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+mach64-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+mach64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+mach64-devel}"
SRC_URI[x86_64_v2_rust-goblin+mach64-devel.sha256sum] = "f06900da12323a751d7d01c6369180bb97020e51dfea6fea1cb92080900d7d43"

URI_x86_64_v2_rust-goblin+pe32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+pe32-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+pe32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+pe32-devel}"
SRC_URI[x86_64_v2_rust-goblin+pe32-devel.sha256sum] = "7e092c34d39d74b9d2c8d5b03535175702dc9f5208166866b1809f2aa4a5a8e9"

URI_x86_64_v2_rust-goblin+pe64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+pe64-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+pe64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+pe64-devel}"
SRC_URI[x86_64_v2_rust-goblin+pe64-devel.sha256sum] = "094379444a4d8d349f9e8b2577df708eb19227be8d57269e6eaecec63ee07a56"

URI_x86_64_v2_rust-goblin+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+std-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+std-devel}"
SRC_URI[x86_64_v2_rust-goblin+std-devel.sha256sum] = "32c004978221023fb913942592a019545e26f250c275ef3b74cc405c32d0dead"

URI_x86_64_v2_rust-goblin+te-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+te-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+te-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+te-devel}"
SRC_URI[x86_64_v2_rust-goblin+te-devel.sha256sum] = "eb27d109da1cf987b74714ce7e54957f7dbea2874a0dc41da3d7391089f74379"

URI_x86_64_v2_rust-goblin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin-devel}"
SRC_URI[x86_64_v2_rust-goblin-devel.sha256sum] = "eb7dbddbce5b4ddccd0f409210891acdb9673ddc7a9e134490b1402d208dc175"

URI_aarch64_rust-goblin+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+alloc-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+alloc-devel}"
SRC_URI[aarch64_rust-goblin+alloc-devel.sha256sum] = "87d76eb89f659a3db347af57923f52225ee289766d5e9ede70e602a9da02170f"

URI_aarch64_rust-goblin+archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+archive-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin+archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+archive-devel}"
SRC_URI[aarch64_rust-goblin+archive-devel.sha256sum] = "ae96cd198b989e6c611c7f00d974d0f703f986d389a57aab95c6008e8bf9c1af"

URI_aarch64_rust-goblin+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+default-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+default-devel}"
SRC_URI[aarch64_rust-goblin+default-devel.sha256sum] = "994bee69c5eb4aad89e2cc8785065b424cc4c4c45bd25d9e1adc218a89e16739"

URI_aarch64_rust-goblin+elf32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+elf32-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin+elf32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+elf32-devel}"
SRC_URI[aarch64_rust-goblin+elf32-devel.sha256sum] = "c15992c3258b7466a8867bbb041166c53828bc6c766b0521ea8f341f7d648ab4"

URI_aarch64_rust-goblin+elf64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+elf64-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin+elf64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+elf64-devel}"
SRC_URI[aarch64_rust-goblin+elf64-devel.sha256sum] = "204f711bd2ba7a7a03fcb8eb526c601cd2480ad6c9b01d4586c58da93995ba57"

URI_aarch64_rust-goblin+endian_fd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+endian_fd-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin+endian_fd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+endian_fd-devel}"
SRC_URI[aarch64_rust-goblin+endian_fd-devel.sha256sum] = "7b2fce0b6b45e197e7ea8cfd86f83c40b0771ce6f520e868873c101d66385f7d"

URI_aarch64_rust-goblin+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+log-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+log-devel}"
SRC_URI[aarch64_rust-goblin+log-devel.sha256sum] = "abbf7881f0773589d12c178adc97fc243ec3b898af2c869cff6bbd0da5cb8b8f"

URI_aarch64_rust-goblin+mach32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+mach32-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin+mach32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+mach32-devel}"
SRC_URI[aarch64_rust-goblin+mach32-devel.sha256sum] = "6173bb4513d9eafa3ed66b0fb184a3ee2fb4dc44486bbe57774bc5f471e30a3d"

URI_aarch64_rust-goblin+mach64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+mach64-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin+mach64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+mach64-devel}"
SRC_URI[aarch64_rust-goblin+mach64-devel.sha256sum] = "21ed66d7c94e0c51db3acafa4a220cf7871f69878357ac6343a33710c67c3ff8"

URI_aarch64_rust-goblin+pe32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+pe32-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin+pe32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+pe32-devel}"
SRC_URI[aarch64_rust-goblin+pe32-devel.sha256sum] = "c9207ed1a5d39db3e227275fbb8eb27ef1adb07a9b307e9bf2dfcd936e9a92d6"

URI_aarch64_rust-goblin+pe64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+pe64-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin+pe64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+pe64-devel}"
SRC_URI[aarch64_rust-goblin+pe64-devel.sha256sum] = "d7df7f0586afabffddc2ba672665e82f8cac3fe7275fd58550b4a435c8bb55a2"

URI_aarch64_rust-goblin+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+std-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+std-devel}"
SRC_URI[aarch64_rust-goblin+std-devel.sha256sum] = "09586a8a9581eab126bf4ccec8a497eeb60c6b9a133b67a2f6c373dff8850e17"

URI_aarch64_rust-goblin+te-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+te-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin+te-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+te-devel}"
SRC_URI[aarch64_rust-goblin+te-devel.sha256sum] = "693247809d9d0b2911915dfb8f9a7900b1d3d8892f4d81dcdf7fe2aed049a21e"

URI_aarch64_rust-goblin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-goblin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin-devel}"
SRC_URI[aarch64_rust-goblin-devel.sha256sum] = "3f93d04686171ed8cb15489ac741e89f5a1fcca4f4173fa308130857152cb517"

RDEPENDS:rust-goblin+alloc-devel = " \
 cargo \
 rust-goblin+log-devel \
 rust-goblin-devel \
 rust-scroll+derive-devel \
 "
RDEPENDS:rust-goblin+archive-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+default-devel = " \
 cargo \
 rust-goblin+archive-devel \
 rust-goblin+elf32-devel \
 rust-goblin+elf64-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin+mach32-devel \
 rust-goblin+mach64-devel \
 rust-goblin+pe32-devel \
 rust-goblin+pe64-devel \
 rust-goblin+std-devel \
 rust-goblin+te-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+elf32-devel = " \
 cargo \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+elf64-devel = " \
 cargo \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+endian_fd-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+log-devel = " \
 cargo \
 rust-goblin-devel \
 rust-log-devel \
 "
RDEPENDS:rust-goblin+mach32-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+archive-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+mach64-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+archive-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+pe32-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+pe64-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+std-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin-devel \
 rust-scroll+std-devel \
 "
RDEPENDS:rust-goblin+te-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin-devel = " \
 cargo \
 rust \
 rust-plain+default-devel \
 rust-scroll-devel \
 "
