# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-hspec-expectations"
PV = "0.8.4"
PR = "1.el10_0"
PACKAGES = " \
 ghc-hspec-expectations \
 ghc-hspec-expectations-devel \
 ghc-hspec-expectations-doc \
 ghc-hspec-expectations-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-hspec-expectations-0.8.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1f68a398a5ada93997242071f75afd365dc55e22b9c17bb2f56711107c8743e"

URI_x86_64_v2_ghc-hspec-expectations = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-expectations-0.8.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hspec-expectations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-expectations}"
SRC_URI[x86_64_v2_ghc-hspec-expectations.sha256sum] = "796f1101142ce26ef541b622d5f5450984f86a616206d5641f0f00adb30fb450"

URI_x86_64_v2_ghc-hspec-expectations-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-expectations-devel-0.8.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hspec-expectations-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-expectations-devel}"
SRC_URI[x86_64_v2_ghc-hspec-expectations-devel.sha256sum] = "ce4f6a99d2fa10d2aa9e2057de8fff1efb89be3b4fb9e7639fcd497175fae03d"

URI_x86_64_v2_ghc-hspec-expectations-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-expectations-doc-0.8.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hspec-expectations-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-expectations-doc}"
SRC_URI[x86_64_v2_ghc-hspec-expectations-doc.sha256sum] = "c229b138733d26a9da5cee15a03280bedc06f337a1473d6317d681a6afdb3ce8"

URI_x86_64_v2_ghc-hspec-expectations-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-expectations-prof-0.8.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hspec-expectations-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-expectations-prof}"
SRC_URI[x86_64_v2_ghc-hspec-expectations-prof.sha256sum] = "e4295219f799a4c2205986bc1a8d5f01d2bc0748a4452c2e832fe209f1621d66"

URI_aarch64_ghc-hspec-expectations = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-expectations-0.8.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-hspec-expectations;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-expectations}"
SRC_URI[aarch64_ghc-hspec-expectations.sha256sum] = "9c16797d4fc84c5867eee3cc1ff5f9eeceed07a175c0f8f1126e8b2ff85c19d5"

URI_aarch64_ghc-hspec-expectations-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-expectations-devel-0.8.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-hspec-expectations-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-expectations-devel}"
SRC_URI[aarch64_ghc-hspec-expectations-devel.sha256sum] = "0f33cf73ed4af9ca1351980acbfb71047d955ce6391b0ad5fa9fa6df5a647c98"

URI_aarch64_ghc-hspec-expectations-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-expectations-doc-0.8.4-1.el10_0.noarch.rpm;name=aarch64_ghc-hspec-expectations-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-expectations-doc}"
SRC_URI[aarch64_ghc-hspec-expectations-doc.sha256sum] = "2e9f068f591308b6ebc3082ebdbfe3b272316fd811429e7e6d14e36932012248"

URI_aarch64_ghc-hspec-expectations-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-expectations-prof-0.8.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-hspec-expectations-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-expectations-prof}"
SRC_URI[aarch64_ghc-hspec-expectations-prof.sha256sum] = "14316933822a39af0373292241163d4882837e3f40b9299229bd5ebcf66b6c43"

RDEPENDS:ghc-hspec-expectations = " \
 ghc-HUnit \
 ghc-array \
 ghc-base \
 ghc-call-stack \
 ghc-deepseq \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hspec-expectations-devel = " \
 ghc-HUnit-devel \
 ghc-base-devel \
 ghc-call-stack-devel \
 ghc-compiler \
 ghc-hspec-expectations \
 "
RDEPENDS:ghc-hspec-expectations-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hspec-expectations-prof = " \
 ghc-HUnit-prof \
 ghc-base-prof \
 ghc-call-stack-prof \
 ghc-hspec-expectations-devel \
 "
