# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xournalpp"
PV = "1.2.7"
PR = "1.el10_0"
PACKAGES = " \
 xournalpp \
 xournalpp-plugins \
 xournalpp-ui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xournalpp-1.2.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6fca47e18c04a76f32abfbfcf346d2592cf1b92daaf8ae8922befe65ba89b44"

URI_x86_64_v2_xournalpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xournalpp-1.2.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xournalpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xournalpp}"
SRC_URI[x86_64_v2_xournalpp.sha256sum] = "ecc30866828a776d9593ab28d1e937ff4e619501750c6dfa27523353cadcf108"

URI_x86_64_v2_xournalpp-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xournalpp-plugins-1.2.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_xournalpp-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xournalpp-plugins}"
SRC_URI[x86_64_v2_xournalpp-plugins.sha256sum] = "6f433d511c097353069b3424173730867b9f87e0eb877398d6b61442faacd362"

URI_x86_64_v2_xournalpp-ui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xournalpp-ui-1.2.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_xournalpp-ui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xournalpp-ui}"
SRC_URI[x86_64_v2_xournalpp-ui.sha256sum] = "7926abded45a580ea686fa6e91cefffc56940640ec4104c85b1beed8ddff9a47"

URI_aarch64_xournalpp = "${EPEL_MIRROR}/aarch64/Packages/x/xournalpp-1.2.7-1.el10_0.aarch64.rpm;name=aarch64_xournalpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_xournalpp}"
SRC_URI[aarch64_xournalpp.sha256sum] = "ff6a5b0ec82ad5ca6666c3a651bc23f2dba2a724b1528cc318c7fe6858699813"

URI_aarch64_xournalpp-plugins = "${EPEL_MIRROR}/aarch64/Packages/x/xournalpp-plugins-1.2.7-1.el10_0.noarch.rpm;name=aarch64_xournalpp-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_xournalpp-plugins}"
SRC_URI[aarch64_xournalpp-plugins.sha256sum] = "f56022b98cbc33155fbc85b4cab39c1e3438712d974cbadf7164cf7c491a492a"

URI_aarch64_xournalpp-ui = "${EPEL_MIRROR}/aarch64/Packages/x/xournalpp-ui-1.2.7-1.el10_0.noarch.rpm;name=aarch64_xournalpp-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_xournalpp-ui}"
SRC_URI[aarch64_xournalpp-ui.sha256sum] = "ca7932cc4a32d7759b8fe9a8e2f217fd9ce27accb14fa2af14355346264921e3"

RDEPENDS:xournalpp = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gperftools-libs \
 gtk3 \
 gtksourceview4 \
 hicolor-icon-theme \
 libX11 \
 libXi \
 libgcc \
 librsvg2 \
 libsndfile \
 libstdc++ \
 libxml2 \
 libzip \
 lua-libs \
 pango \
 poppler-glib \
 portaudio \
 xournalpp-plugins \
 xournalpp-ui \
 zlib-ng-compat \
 "
RDEPENDS:xournalpp-plugins = " \
 "
RDEPENDS:xournalpp-ui = " \
 "
