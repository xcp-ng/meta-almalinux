# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-filesystem \
 kf6-rpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c6bd9dbe32c10b15d7b521096cf680bb80584933ec4d6ffe886c0299d74a55b"

URI_x86_64_v2_kf6-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-filesystem-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-filesystem}"
SRC_URI[x86_64_v2_kf6-filesystem.sha256sum] = "d4e0dd211bb16666975cd451ced604ba4e074b5e123ff466a6dff28064e4edab"

URI_x86_64_v2_kf6-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-rpm-macros-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-rpm-macros}"
SRC_URI[x86_64_v2_kf6-rpm-macros.sha256sum] = "19256c674bad346dc8c3cffaad2e87a401b4e01d522884bd89909eb92abf071c"

URI_aarch64_kf6-filesystem = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-filesystem-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-filesystem}"
SRC_URI[aarch64_kf6-filesystem.sha256sum] = "19fff24cd95fbf408055adaf3e91fce93c12a8c684695ed04cf6a25af72c2819"

URI_aarch64_kf6-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-rpm-macros-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-rpm-macros}"
SRC_URI[aarch64_kf6-rpm-macros.sha256sum] = "3048ef061ba38083f974ae8e342eddd6defddc39bd52a2f713878eb60034791e"

RDEPENDS:kf6-filesystem = " \
 kde-filesystem \
 "
RDEPENDS:kf6-rpm-macros = " \
 cmake \
 doxygen \
 gcc-c++ \
 kde-qdoc-common \
 qt6-doc-devel \
 qt6-qttools-devel \
 qt6-rpm-macros \
 "
