# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cliff"
PV = "4.13.3"
PR = "1.el10_2"
PACKAGES = " \
 python3-cliff \
 python3-cliff-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cliff-4.13.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0ef90f5a2be9f1b6571291d0933d5a99186008b2f769bfeab8364f21505fbf7"

URI_x86_64_v2_python3-cliff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cliff-4.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cliff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cliff}"
SRC_URI[x86_64_v2_python3-cliff.sha256sum] = "8649cdc4475e61e8c1b87b4d25e0fc8b7956094349c0ccc33398d31501d4bde2"

URI_x86_64_v2_python3-cliff-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cliff-tests-4.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cliff-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cliff-tests}"
SRC_URI[x86_64_v2_python3-cliff-tests.sha256sum] = "2c3f1b4c7d2cc682e90b7e0ac3b05257ae680e8452e4b5fad8e943b9fcf7d831"

URI_aarch64_python3-cliff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cliff-4.13.3-1.el10_2.noarch.rpm;name=aarch64_python3-cliff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cliff}"
SRC_URI[aarch64_python3-cliff.sha256sum] = "82446216f126b1f678a1ce5e38ca3cc0da767239df57c4dde522705f81951bc8"

URI_aarch64_python3-cliff-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cliff-tests-4.13.3-1.el10_2.noarch.rpm;name=aarch64_python3-cliff-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cliff-tests}"
SRC_URI[aarch64_python3-cliff-tests.sha256sum] = "68625bd545c4e83577b3140559e79cc84b4eb446aabd8ea14361581638b9c0d8"

RDEPENDS:python3-cliff = " \
 python3 \
 python3-autopage \
 python3-cmd2 \
 python3-prettytable \
 python3-pyyaml \
 python3-stevedore \
 "
RDEPENDS:python3-cliff-tests = " \
 bash \
 python3 \
 python3-cliff \
 python3-fixtures \
 python3-pyyaml \
 python3-subunit \
 python3-testscenarios \
 python3-testtools \
 which \
 "
