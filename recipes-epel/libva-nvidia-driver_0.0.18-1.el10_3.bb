# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libva-nvidia-driver"
PV = "0.0.18"
PR = "1.el10_3"
PACKAGES = " \
 libva-nvidia-driver \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libva-nvidia-driver-0.0.18-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3ca46f4e015058fd855835197e6c5bb504df30f09c84e970be72af285f6896cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libva-nvidia-driver-0.0.18-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libva-nvidia-driver;unpack=0"
SRC_URI[x86_64_v2_libva-nvidia-driver.sha256sum] = "8706175be201638e8a91376deca6c0255a3e874a3256fa4082c6e44632a7733a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libva-nvidia-driver-0.0.18-1.el10_3.aarch64.rpm;name=aarch64_libva-nvidia-driver;unpack=0"
SRC_URI[aarch64_libva-nvidia-driver.sha256sum] = "ccc4612274e46d62d03cb7cdbe6d4a6bf6dba6a5b2aba8eff69cf36e3bd0ef9a"

RDEPENDS:libva-nvidia-driver = " \
 glibc \
 gstreamer1-plugins-bad-free-libs \
 libglvnd-egl \
 "
