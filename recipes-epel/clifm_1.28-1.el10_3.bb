# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clifm"
PV = "1.28"
PR = "1.el10_3"
PACKAGES = " \
 clifm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clifm-1.28-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3c92b21725696e36dadd6bf66dda35eb0a5caca6b3d633993bed405de2316a0"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - clifm: libcap.so.2()(64bit)

URI_x86_64_v2_clifm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clifm-1.28-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clifm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clifm}"
SRC_URI[x86_64_v2_clifm.sha256sum] = "fbe1c477db7712cc692ddce5151c9e51c49ce0e8b9581d827d1539b9a50d465b"

URI_aarch64_clifm = "${EPEL_MIRROR}/aarch64/Packages/c/clifm-1.28-1.el10_3.aarch64.rpm;name=aarch64_clifm;unpack=0"
SRC_URI:append = " ${URI_aarch64_clifm}"
SRC_URI[aarch64_clifm.sha256sum] = "641ce9c8dac0e536545cefcaad7be5f98e9bc95c8ccf56a011e0f10dcfbb8273"

RDEPENDS:clifm:x86_64_v2 = " \
 bash \
 file-libs \
 glibc \
 hicolor-icon-theme \
 libacl \
 libcap \
 python3 \
 readline \
"
RDEPENDS:clifm:aarch64 = " \
 bash \
 file-libs \
 glibc \
 hicolor-icon-theme \
 libacl \
 python3 \
 readline \
"
