# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "game-music-emu"
PV = "0.6.3"
PR = "16.el10_0"
PACKAGES = " \
 game-music-emu \
 game-music-emu-devel \
 game-music-emu-player \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/game-music-emu-0.6.3-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf9e74a025e0069e160b2fc191c253a82adce61df7d2c942e46c3affe770aea4"

URI_x86_64_v2_game-music-emu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/game-music-emu-0.6.3-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_game-music-emu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_game-music-emu}"
SRC_URI[x86_64_v2_game-music-emu.sha256sum] = "3bd50bf1e77a9611318ecd52279182dfa88bb5a7d2859b5a44c85fd29672b4e5"

URI_x86_64_v2_game-music-emu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/game-music-emu-devel-0.6.3-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_game-music-emu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_game-music-emu-devel}"
SRC_URI[x86_64_v2_game-music-emu-devel.sha256sum] = "063d610b04779ce6958f69c4c460547d181ec6f84a96099d756da19d76a6685f"

URI_x86_64_v2_game-music-emu-player = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/game-music-emu-player-0.6.3-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_game-music-emu-player;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_game-music-emu-player}"
SRC_URI[x86_64_v2_game-music-emu-player.sha256sum] = "6f661ef993a4e701f736c78dd34a54d32c84214f832c6ee1f6cde37d1c49dad6"

URI_aarch64_game-music-emu = "${EPEL_MIRROR}/aarch64/Packages/g/game-music-emu-0.6.3-16.el10_0.aarch64.rpm;name=aarch64_game-music-emu;unpack=0"
SRC_URI:append = " ${URI_aarch64_game-music-emu}"
SRC_URI[aarch64_game-music-emu.sha256sum] = "6fa09e54f2034e31b7cea3df40535758a301f74b46c45d58630715ac432a2bc0"

URI_aarch64_game-music-emu-devel = "${EPEL_MIRROR}/aarch64/Packages/g/game-music-emu-devel-0.6.3-16.el10_0.aarch64.rpm;name=aarch64_game-music-emu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_game-music-emu-devel}"
SRC_URI[aarch64_game-music-emu-devel.sha256sum] = "361bf7dd6ef90179e080e9f82ca6b6479261f4bae3811efb389bf461aa183249"

URI_aarch64_game-music-emu-player = "${EPEL_MIRROR}/aarch64/Packages/g/game-music-emu-player-0.6.3-16.el10_0.aarch64.rpm;name=aarch64_game-music-emu-player;unpack=0"
SRC_URI:append = " ${URI_aarch64_game-music-emu-player}"
SRC_URI[aarch64_game-music-emu-player.sha256sum] = "47ac294525dffb838c0625d530b8bb0d31bdebcb46e592eb23cfec7c979ffc38"

RDEPENDS:game-music-emu = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:game-music-emu-devel = " \
 game-music-emu \
 pkgconf-pkg-config \
 "
RDEPENDS:game-music-emu-player = " \
 game-music-emu \
 glibc \
 libgcc \
 libstdc++ \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
