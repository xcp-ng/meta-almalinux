# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnscap"
PV = "2.5.2"
PR = "1.el10_3"
PACKAGES = " \
 dnscap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnscap-2.5.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b4098eb116acf2040341fdfaaa72d06f8b9e8e4d60396b2ea630a889e0dad72"

URI_x86_64_v2_dnscap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnscap-2.5.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnscap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnscap}"
SRC_URI[x86_64_v2_dnscap.sha256sum] = "59759d0c1fc96e1cc1d8d4f8227a30242946fe3a1aa77a510c63d397dff86822"

URI_aarch64_dnscap = "${EPEL_MIRROR}/aarch64/Packages/d/dnscap-2.5.2-1.el10_3.aarch64.rpm;name=aarch64_dnscap;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnscap}"
SRC_URI[aarch64_dnscap.sha256sum] = "5465eab9aef41abf908167e6c26065d88f2dbaafbfd77cb06261a754da69c9a6"

RDEPENDS:dnscap = " \
 bzip2-libs \
 cryptopant \
 glibc \
 ldns \
 libpcap \
 libzstd \
 lz4-libs \
 openssl-libs \
 perl-interpreter \
 xz-libs \
 zlib-ng-compat \
 "
