# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager"
PE = "1"
PV = "1.54.0"
PR = "3.el10_1"
PACKAGES = " \
 NetworkManager \
 NetworkManager-adsl \
 NetworkManager-bluetooth \
 NetworkManager-cloud-setup \
 NetworkManager-config-connectivity-redhat \
 NetworkManager-config-server \
 NetworkManager-libnm \
 NetworkManager-libnm-devel \
 NetworkManager-ovs \
 NetworkManager-ppp \
 NetworkManager-tui \
 NetworkManager-wifi \
 NetworkManager-wwan \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/NetworkManager-1.54.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f59615b2b82a04ce9f61cc91a3ad4e7cf0bfb68711a12c85f7dab37035d4b384"

URI_x86_64_v2_NetworkManager = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-1.54.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_NetworkManager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager}"
SRC_URI[x86_64_v2_NetworkManager.sha256sum] = "46c591d1b450a26027b5df5ac4bc3576284441d562c0ed0ce0f7b986985a0339"

URI_x86_64_v2_NetworkManager-adsl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-adsl-1.54.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-adsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-adsl}"
SRC_URI[x86_64_v2_NetworkManager-adsl.sha256sum] = "ff3011242bcc76fad8a10eadcba108d7f31eaaeb8037181f2b03fd660e0e8cba"

URI_x86_64_v2_NetworkManager-bluetooth = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-bluetooth-1.54.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-bluetooth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-bluetooth}"
SRC_URI[x86_64_v2_NetworkManager-bluetooth.sha256sum] = "3d099f725bb3452ca9a96227486b4deb324af72b59f0478153fcef57fd22b02b"

URI_x86_64_v2_NetworkManager-cloud-setup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-cloud-setup-1.54.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-cloud-setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-cloud-setup}"
SRC_URI[x86_64_v2_NetworkManager-cloud-setup.sha256sum] = "8b2231a74c9c47dbd25580085041691de8190ebe51eb82197b158823da7ca5fd"

URI_x86_64_v2_NetworkManager-config-connectivity-redhat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-config-connectivity-redhat-1.54.0-3.el10_1.noarch.rpm;name=x86_64_v2_NetworkManager-config-connectivity-redhat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-config-connectivity-redhat}"
SRC_URI[x86_64_v2_NetworkManager-config-connectivity-redhat.sha256sum] = "9377a2be7c0ff448095aea4acd25684eed10c3d23c94598355fa4a509778355e"

URI_x86_64_v2_NetworkManager-config-server = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-config-server-1.54.0-3.el10_1.noarch.rpm;name=x86_64_v2_NetworkManager-config-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-config-server}"
SRC_URI[x86_64_v2_NetworkManager-config-server.sha256sum] = "2c2be3bca96974272ae01a770c4023d86e75b93ed2a42c87eaa577467cead118"

URI_x86_64_v2_NetworkManager-libnm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-libnm-1.54.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libnm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libnm}"
SRC_URI[x86_64_v2_NetworkManager-libnm.sha256sum] = "a35da73dc6d26fe1faf8fe24f5d5f5c386d1b8452d242549c3e8e066d7373660"

URI_x86_64_v2_NetworkManager-libnm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/NetworkManager-libnm-devel-1.54.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libnm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libnm-devel}"
SRC_URI[x86_64_v2_NetworkManager-libnm-devel.sha256sum] = "91f35b1cf514ab96f974fdf5ad0114307cbead4e4efe7debd0f77bc6c042b2ee"

URI_x86_64_v2_NetworkManager-ovs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-ovs-1.54.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-ovs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-ovs}"
SRC_URI[x86_64_v2_NetworkManager-ovs.sha256sum] = "cf79285ef64c4a2d35571b20e4ca17947cccf856a9a1d6a2d493ef94013ac966"

URI_x86_64_v2_NetworkManager-ppp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-ppp-1.54.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-ppp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-ppp}"
SRC_URI[x86_64_v2_NetworkManager-ppp.sha256sum] = "d07010e3c947b92e88fcea9f2b871e523b0d1ab1e0a7bab757edd57fea11538d"

URI_x86_64_v2_NetworkManager-tui = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-tui-1.54.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-tui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-tui}"
SRC_URI[x86_64_v2_NetworkManager-tui.sha256sum] = "b218deb2185e4c32bc8561219623e05368a392ea20d76a1816b269c7351f0bd7"

URI_x86_64_v2_NetworkManager-wifi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-wifi-1.54.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-wifi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-wifi}"
SRC_URI[x86_64_v2_NetworkManager-wifi.sha256sum] = "370ee886a36ef3508fb1527ee8df96e1e20e0c4845e417bf37cea238ca78d9b5"

URI_x86_64_v2_NetworkManager-wwan = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-wwan-1.54.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-wwan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-wwan}"
SRC_URI[x86_64_v2_NetworkManager-wwan.sha256sum] = "76f79e685f239640fdf3914b7a911f05ce0e5955484493520d7d6f991c497a07"

URI_aarch64_NetworkManager = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-1.54.0-3.el10_1.aarch64.rpm;name=aarch64_NetworkManager;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager}"
SRC_URI[aarch64_NetworkManager.sha256sum] = "e59faa7411051d9471abeeb0cfe813c5cef9df2d51968b0c057fcfcd54e4fcd6"

URI_aarch64_NetworkManager-adsl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-adsl-1.54.0-3.el10_1.aarch64.rpm;name=aarch64_NetworkManager-adsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-adsl}"
SRC_URI[aarch64_NetworkManager-adsl.sha256sum] = "dadc35de8ae8e534c1c477e5b1602ead41fa9c3d7ef94cd419ad4e8402ee66ed"

URI_aarch64_NetworkManager-bluetooth = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-bluetooth-1.54.0-3.el10_1.aarch64.rpm;name=aarch64_NetworkManager-bluetooth;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-bluetooth}"
SRC_URI[aarch64_NetworkManager-bluetooth.sha256sum] = "ae979a1bae2e0bf118cd75eb008907e19f8b46ffb4ea9abe1b698bfcc9b72695"

URI_aarch64_NetworkManager-cloud-setup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-cloud-setup-1.54.0-3.el10_1.aarch64.rpm;name=aarch64_NetworkManager-cloud-setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-cloud-setup}"
SRC_URI[aarch64_NetworkManager-cloud-setup.sha256sum] = "f052fa6b8d4b3fec11e2f8b14a9bfd2e0d3b2bf59ae3751abbb74df8cf12f3bd"

URI_aarch64_NetworkManager-config-connectivity-redhat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-config-connectivity-redhat-1.54.0-3.el10_1.noarch.rpm;name=aarch64_NetworkManager-config-connectivity-redhat;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-config-connectivity-redhat}"
SRC_URI[aarch64_NetworkManager-config-connectivity-redhat.sha256sum] = "9377a2be7c0ff448095aea4acd25684eed10c3d23c94598355fa4a509778355e"

URI_aarch64_NetworkManager-config-server = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-config-server-1.54.0-3.el10_1.noarch.rpm;name=aarch64_NetworkManager-config-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-config-server}"
SRC_URI[aarch64_NetworkManager-config-server.sha256sum] = "2c2be3bca96974272ae01a770c4023d86e75b93ed2a42c87eaa577467cead118"

URI_aarch64_NetworkManager-libnm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-libnm-1.54.0-3.el10_1.aarch64.rpm;name=aarch64_NetworkManager-libnm;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libnm}"
SRC_URI[aarch64_NetworkManager-libnm.sha256sum] = "f48640eacf8af3ae9a1b27c2ffd17b1179caf6783c6256cceb94f6c08dd588b2"

URI_aarch64_NetworkManager-libnm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/NetworkManager-libnm-devel-1.54.0-3.el10_1.aarch64.rpm;name=aarch64_NetworkManager-libnm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libnm-devel}"
SRC_URI[aarch64_NetworkManager-libnm-devel.sha256sum] = "4515990683733a6228cf0e483901064d099298801cf264051a3ba2256a314ea0"

URI_aarch64_NetworkManager-ovs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-ovs-1.54.0-3.el10_1.aarch64.rpm;name=aarch64_NetworkManager-ovs;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-ovs}"
SRC_URI[aarch64_NetworkManager-ovs.sha256sum] = "542f72de7ab3170512e704b3f4a7344369cee6ba303e3a46e5f0dd33c43b6898"

URI_aarch64_NetworkManager-ppp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-ppp-1.54.0-3.el10_1.aarch64.rpm;name=aarch64_NetworkManager-ppp;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-ppp}"
SRC_URI[aarch64_NetworkManager-ppp.sha256sum] = "0a3f91b9d7ff875bf7a1feb90b0d0f85b67c8bb46e5e4ba170100d625e2e38c6"

URI_aarch64_NetworkManager-tui = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-tui-1.54.0-3.el10_1.aarch64.rpm;name=aarch64_NetworkManager-tui;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-tui}"
SRC_URI[aarch64_NetworkManager-tui.sha256sum] = "f1d89d89e87c44e0cde8f921816ee1c0fe27e9c8ad04bc199eca9420e9e91d6e"

URI_aarch64_NetworkManager-wifi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-wifi-1.54.0-3.el10_1.aarch64.rpm;name=aarch64_NetworkManager-wifi;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-wifi}"
SRC_URI[aarch64_NetworkManager-wifi.sha256sum] = "e43da3644ad875ab404948a535b3aabaa1756e92fe561029897d87f0ae5d8f9b"

URI_aarch64_NetworkManager-wwan = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-wwan-1.54.0-3.el10_1.aarch64.rpm;name=aarch64_NetworkManager-wwan;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-wwan}"
SRC_URI[aarch64_NetworkManager-wwan.sha256sum] = "19d156a9b53376dee79068433b209ab46977cff4bc24f7fe065ca42acde47c1c"

RDEPENDS:NetworkManager = " \
 NetworkManager-libnm \
 alternatives \
 audit-libs \
 bash \
 dbus \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 libndp \
 libselinux \
 readline \
 systemd \
 systemd-libs \
 systemd-udev \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:NetworkManager-adsl = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:NetworkManager-bluetooth = " \
 NetworkManager \
 NetworkManager-wwan \
 bluez \
 bluez-libs \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:NetworkManager-cloud-setup = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 glib2 \
 glibc \
 jansson \
 libgcc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:NetworkManager-config-connectivity-redhat = " \
 "
RDEPENDS:NetworkManager-config-server = " \
 "
RDEPENDS:NetworkManager-libnm = " \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 systemd-libs \
 "
RDEPENDS:NetworkManager-libnm-devel = " \
 NetworkManager-libnm \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:NetworkManager-ovs = " \
 NetworkManager \
 glib2 \
 glibc \
 jansson \
 libgcc \
 "
RDEPENDS:NetworkManager-ppp = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 ppp \
 "
RDEPENDS:NetworkManager-tui = " \
 NetworkManager \
 NetworkManager-libnm \
 glib2 \
 glibc \
 libgcc \
 newt \
 "
RDEPENDS:NetworkManager-wifi = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 wireless-regdb \
 wpa_supplicant \
 "
RDEPENDS:NetworkManager-wwan = " \
 ModemManager \
 ModemManager-glib \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 systemd-libs \
 "
