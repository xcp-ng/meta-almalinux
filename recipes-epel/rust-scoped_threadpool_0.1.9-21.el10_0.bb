# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scoped_threadpool"
PV = "0.1.9"
PR = "21.el10_0"
PACKAGES = " \
 rust-scoped_threadpool+default-devel \
 rust-scoped_threadpool+nightly-devel \
 rust-scoped_threadpool-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scoped_threadpool-0.1.9-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "faed2133064b98303f14156753212c5041a253ce716468006f6b1800644b389c"

URI_x86_64_v2_rust-scoped_threadpool+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scoped_threadpool+default-devel-0.1.9-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scoped_threadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scoped_threadpool+default-devel}"
SRC_URI[x86_64_v2_rust-scoped_threadpool+default-devel.sha256sum] = "7ab423a38a93a431312cb19523cfd4b6d0607ae23f8736dc378b282600f53078"

URI_x86_64_v2_rust-scoped_threadpool+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scoped_threadpool+nightly-devel-0.1.9-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scoped_threadpool+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scoped_threadpool+nightly-devel}"
SRC_URI[x86_64_v2_rust-scoped_threadpool+nightly-devel.sha256sum] = "4d8bc09c530fa2eaa72d66a490f2fad1f9039495b5884effd81ea043e2427122"

URI_x86_64_v2_rust-scoped_threadpool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scoped_threadpool-devel-0.1.9-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scoped_threadpool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scoped_threadpool-devel}"
SRC_URI[x86_64_v2_rust-scoped_threadpool-devel.sha256sum] = "0500d5725b0651b403e15737f3287c63779042453e8413a9f4f4fe04dd0d9608"

URI_aarch64_rust-scoped_threadpool+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scoped_threadpool+default-devel-0.1.9-21.el10_0.noarch.rpm;name=aarch64_rust-scoped_threadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scoped_threadpool+default-devel}"
SRC_URI[aarch64_rust-scoped_threadpool+default-devel.sha256sum] = "e67aa614699f3dbecbe8160dc5b67abea66fec4f6cfacb5a9fa0a2651fd1e856"

URI_aarch64_rust-scoped_threadpool+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scoped_threadpool+nightly-devel-0.1.9-21.el10_0.noarch.rpm;name=aarch64_rust-scoped_threadpool+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scoped_threadpool+nightly-devel}"
SRC_URI[aarch64_rust-scoped_threadpool+nightly-devel.sha256sum] = "4d551d67dbd7a77f0be400ad18d703c0d4009e4eef14593bbb8dce2d4c9d6104"

URI_aarch64_rust-scoped_threadpool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scoped_threadpool-devel-0.1.9-21.el10_0.noarch.rpm;name=aarch64_rust-scoped_threadpool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scoped_threadpool-devel}"
SRC_URI[aarch64_rust-scoped_threadpool-devel.sha256sum] = "a93739ab62935996be81818064db3dc268a2e21cfa4a1a3d1c97df285ad81247"

RDEPENDS:rust-scoped_threadpool+default-devel = " \
 cargo \
 rust-scoped_threadpool-devel \
 "
RDEPENDS:rust-scoped_threadpool+nightly-devel = " \
 cargo \
 rust-scoped_threadpool-devel \
 "
RDEPENDS:rust-scoped_threadpool-devel = " \
 cargo \
 "
