# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-parse"
PV = "1.0.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-anstyle-parse+core-devel \
 rust-anstyle-parse+default-devel \
 rust-anstyle-parse+utf8-devel \
 rust-anstyle-parse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-parse-1.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55715860782bb33759ba47e10971ba4eae3e3e59d76bc9d1e5eaa0e32595dd22"

URI_x86_64_v2_rust-anstyle-parse+core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-parse+core-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-parse+core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-parse+core-devel}"
SRC_URI[x86_64_v2_rust-anstyle-parse+core-devel.sha256sum] = "28aeac049aba93345a380503576eef994cd70faaedd566dbdec844deb043288f"

URI_x86_64_v2_rust-anstyle-parse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-parse+default-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-parse+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-parse+default-devel.sha256sum] = "8b20659dc23cdca919b1701203eb3bad37a952ad0a6981ea5ab1d2c3d63bd690"

URI_x86_64_v2_rust-anstyle-parse+utf8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-parse+utf8-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-parse+utf8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-parse+utf8-devel}"
SRC_URI[x86_64_v2_rust-anstyle-parse+utf8-devel.sha256sum] = "54aced4f466de5a67ab1512a87024b9bf52e90781c2073c14de24b8280c11b53"

URI_x86_64_v2_rust-anstyle-parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-parse-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-parse-devel}"
SRC_URI[x86_64_v2_rust-anstyle-parse-devel.sha256sum] = "445992f4442bc32b060934a08bd690a19cae99f5f213200f07ab18e80c724992"

URI_aarch64_rust-anstyle-parse+core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-parse+core-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle-parse+core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-parse+core-devel}"
SRC_URI[aarch64_rust-anstyle-parse+core-devel.sha256sum] = "b6966e7d66030d803b370ea964bde5c4518b3db71d19b42be7b6598f7893d3c1"

URI_aarch64_rust-anstyle-parse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-parse+default-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-parse+default-devel}"
SRC_URI[aarch64_rust-anstyle-parse+default-devel.sha256sum] = "008f72b68d197447161b1f85e9cc0aa800397528c6a7b49cd21b93570a0433e8"

URI_aarch64_rust-anstyle-parse+utf8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-parse+utf8-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle-parse+utf8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-parse+utf8-devel}"
SRC_URI[aarch64_rust-anstyle-parse+utf8-devel.sha256sum] = "a8dcc815a6b7ed9e016434bbc3778d911b719c6965a5f6fcd72d3b678fa8e9a6"

URI_aarch64_rust-anstyle-parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-parse-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle-parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-parse-devel}"
SRC_URI[aarch64_rust-anstyle-parse-devel.sha256sum] = "351f5df8a87174bf0b049c4eeb189647736c1a9966e53fc3b77f3551b6c2cfd5"

RDEPENDS:rust-anstyle-parse+core-devel = " \
 cargo \
 rust-anstyle-parse-devel \
 rust-arrayvec-devel \
 "
RDEPENDS:rust-anstyle-parse+default-devel = " \
 cargo \
 rust-anstyle-parse+utf8-devel \
 rust-anstyle-parse-devel \
 "
RDEPENDS:rust-anstyle-parse+utf8-devel = " \
 cargo \
 rust-anstyle-parse-devel \
 rust-utf8parse+default-devel \
 "
RDEPENDS:rust-anstyle-parse-devel = " \
 cargo \
 rust \
 "
