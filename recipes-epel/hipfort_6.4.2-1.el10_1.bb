# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipfort"
PV = "6.4.2"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 hipfort \
 hipfort-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipfort-6.4.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c9fa50c56a8ba169ada4e90215a6a0956a55ba55344c05d838a05a2bb1e03c3"

URI_x86_64_v2_hipfort = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipfort-6.4.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipfort;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipfort}"
SRC_URI[x86_64_v2_hipfort.sha256sum] = "5bd05a51e36857bc26eb99faf4ea2c97083142b6a8afd0fe1b5cc98c79f0e8f2"

URI_x86_64_v2_hipfort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipfort-devel-6.4.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipfort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipfort-devel}"
SRC_URI[x86_64_v2_hipfort-devel.sha256sum] = "20d2ecce4aa5d41a608fb35603e88d7efff640d37e988c63b229b1b377490e19"

RDEPENDS:hipfort = " \
 bash \
 glibc \
 hipblas \
 hipfft \
 hipsolver \
 hipsparse \
 libgcc \
 libgfortran \
 "
RDEPENDS:hipfort-devel = " \
 hipfort \
 "
