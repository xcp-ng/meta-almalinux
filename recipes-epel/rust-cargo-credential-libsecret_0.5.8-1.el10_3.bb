# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-credential-libsecret"
PV = "0.5.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo-credential-libsecret+default-devel \
 rust-cargo-credential-libsecret-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-credential-libsecret-0.5.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "74e9a9cfe01b530ecbc1ece80cadb432dff22983d5735565637380f57bafed3a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential-libsecret+default-devel-0.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential-libsecret+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-credential-libsecret+default-devel.sha256sum] = "0535ae5198945337b3f970ba570311630c844ebbce12e59ebcd5b35471b1e146"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential-libsecret-devel-0.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential-libsecret-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-credential-libsecret-devel.sha256sum] = "7650ea3af626e17b2f8b3ecc7608d326f5bb06c7ce83ca1e70fe80b006607b96"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential-libsecret+default-devel-0.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-credential-libsecret+default-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-credential-libsecret+default-devel.sha256sum] = "0accb987688512e962b70e1bc5993262e2ba94932e87791bd6ed92973a3980e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential-libsecret-devel-0.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-credential-libsecret-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-credential-libsecret-devel.sha256sum] = "92fe3971d1d96001fc5915c4e54492816648278232d07018e1e649d95e747977"

RDEPENDS:rust-cargo-credential-libsecret+default-devel = " \
 cargo \
 rust-cargo-credential-libsecret-devel \
 "
RDEPENDS:rust-cargo-credential-libsecret-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-cargo-credential+default-devel \
 rust-libloading+default-devel \
 "
