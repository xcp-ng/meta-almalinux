# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-backend"
PV = "0.3.12"
PR = "1.el10_1"
PACKAGES = " \
 rust-wayland-backend+client_system-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-backend+dlopen-devel \
 rust-wayland-backend+log-devel \
 rust-wayland-backend+raw-window-handle-devel \
 rust-wayland-backend+rwh_06-devel \
 rust-wayland-backend+server_system-devel \
 rust-wayland-backend-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-backend-0.3.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f39e9cdc5f458a710a0260cc7e765a71427efdde0311980307eb341452df208a"

URI_x86_64_v2_rust-wayland-backend+client_system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+client_system-devel-0.3.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+client_system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+client_system-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+client_system-devel.sha256sum] = "c1750a3d6e3d4d3eead325935f8dd72722a5882605f7c4edbaedfc471f3431ab"

URI_x86_64_v2_rust-wayland-backend+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+default-devel-0.3.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+default-devel.sha256sum] = "5079b7c6002104dc5b77c9b87c35a45c700c07a7adb052fc423d297e1dee7da1"

URI_x86_64_v2_rust-wayland-backend+dlopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+dlopen-devel-0.3.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+dlopen-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+dlopen-devel.sha256sum] = "1dd5363dd3780bbfdf60383db4535b1ed4d208a54d8705d3b823e5945dabe607"

URI_x86_64_v2_rust-wayland-backend+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+log-devel-0.3.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+log-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+log-devel.sha256sum] = "64e6554a301ea8f59a6474b3d38f8490f807e46aa71cc9435adad5f27b201c32"

URI_x86_64_v2_rust-wayland-backend+raw-window-handle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+raw-window-handle-devel-0.3.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+raw-window-handle-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+raw-window-handle-devel.sha256sum] = "23ed4f24fa43a69bc386c0eecc53c2a1d137fb25980ceae719d19c3b48f871f5"

URI_x86_64_v2_rust-wayland-backend+rwh_06-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+rwh_06-devel-0.3.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+rwh_06-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+rwh_06-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+rwh_06-devel.sha256sum] = "b802f602f51bf6c9c7ee3922ed89b54a437e08aa496253903ca594c373bd04d6"

URI_x86_64_v2_rust-wayland-backend+server_system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+server_system-devel-0.3.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+server_system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+server_system-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+server_system-devel.sha256sum] = "dbceb6c34edab5e082d06c09b23a2ea56d934bef912263ac17e474ce3e3db8c3"

URI_x86_64_v2_rust-wayland-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend-devel-0.3.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend-devel.sha256sum] = "bbafeb365cd387ab02b68a0517d02c709e95f28e8cfaceaa5d07a2a311e7a989"

URI_aarch64_rust-wayland-backend+client_system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+client_system-devel-0.3.12-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-backend+client_system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+client_system-devel}"
SRC_URI[aarch64_rust-wayland-backend+client_system-devel.sha256sum] = "ed4604d2886b2383485d155c32225cd39114023120c9d5002a364417af654400"

URI_aarch64_rust-wayland-backend+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+default-devel-0.3.12-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+default-devel}"
SRC_URI[aarch64_rust-wayland-backend+default-devel.sha256sum] = "7874ff548058f5f2807b960b1bb614717ba0e9d239ef4d34e55a1caca1fba3c7"

URI_aarch64_rust-wayland-backend+dlopen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+dlopen-devel-0.3.12-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-backend+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+dlopen-devel}"
SRC_URI[aarch64_rust-wayland-backend+dlopen-devel.sha256sum] = "964c677f6075f6008b9e486db90af805c45332876b3e15a35df9a089b4a03f1b"

URI_aarch64_rust-wayland-backend+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+log-devel-0.3.12-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-backend+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+log-devel}"
SRC_URI[aarch64_rust-wayland-backend+log-devel.sha256sum] = "3b203d5c387289b681ec8324d0952bfedee5ba84145be5d1c6e9376c1c51e595"

URI_aarch64_rust-wayland-backend+raw-window-handle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+raw-window-handle-devel-0.3.12-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-backend+raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+raw-window-handle-devel}"
SRC_URI[aarch64_rust-wayland-backend+raw-window-handle-devel.sha256sum] = "364c00467f73738b8a67a5ca21779c4c060da422f53d6a0e7cc16eccedffd41d"

URI_aarch64_rust-wayland-backend+rwh_06-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+rwh_06-devel-0.3.12-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-backend+rwh_06-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+rwh_06-devel}"
SRC_URI[aarch64_rust-wayland-backend+rwh_06-devel.sha256sum] = "d40bd774165710f96cc9450c4e28a00590de7bb6172c73b5f3c3e8906ce1b8ef"

URI_aarch64_rust-wayland-backend+server_system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+server_system-devel-0.3.12-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-backend+server_system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+server_system-devel}"
SRC_URI[aarch64_rust-wayland-backend+server_system-devel.sha256sum] = "04aa67090f98b2511484b3b333c3eb7e392c1408758605e231eec88e44b5c7c2"

URI_aarch64_rust-wayland-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend-devel-0.3.12-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend-devel}"
SRC_URI[aarch64_rust-wayland-backend-devel.sha256sum] = "b0cc618e627b17795293bca72216b8312c1b2f6741e3b2acd1153c828a6d0fb7"

RDEPENDS:rust-wayland-backend+client_system-devel = " \
 cargo \
 rust-scoped-tls+default-devel \
 rust-wayland-backend-devel \
 rust-wayland-sys+client-devel \
 "
RDEPENDS:rust-wayland-backend+default-devel = " \
 cargo \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+dlopen-devel = " \
 cargo \
 rust-wayland-backend-devel \
 rust-wayland-sys+dlopen-devel \
 "
RDEPENDS:rust-wayland-backend+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+raw-window-handle-devel = " \
 cargo \
 rust-raw-window-handle0.5+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+rwh_06-devel = " \
 cargo \
 rust-raw-window-handle+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+server_system-devel = " \
 cargo \
 rust-scoped-tls+default-devel \
 rust-wayland-backend-devel \
 rust-wayland-sys+server-devel \
 "
RDEPENDS:rust-wayland-backend-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-downcast-rs+default-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+process-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 rust-wayland-sys+default-devel \
 "
