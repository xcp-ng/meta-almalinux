# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "smc-tools"
PV = "1.8.4"
PR = "1.el10"
PACKAGES = " \
 smc-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/smc-tools-1.8.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0a7ea9cdede4c146e25f0bc36705be9a7e8d1b0a56432caf470c211ac2090216"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/smc-tools-1.8.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_smc-tools;unpack=0"
SRC_URI[x86_64_v2_smc-tools.sha256sum] = "e17458eedbf291057833275a1e9eebd9f7c906e2f17c3aefe5f8453aea403e84"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/smc-tools-1.8.4-1.el10.aarch64.rpm;name=aarch64_smc-tools;unpack=0"
SRC_URI[aarch64_smc-tools.sha256sum] = "37906c8c3dfac9c0861d108106e4dbd01eb50b0794b849b24701d1ee51bfd2af"

RDEPENDS:smc-tools = " \
 bash \
 glibc \
 libnl3 \
 "
