# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fftw"
PV = "3.3.10"
PR = "15.el10"
PACKAGES:x86_64_v2 = " \
 fftw \
 fftw-devel \
 fftw-doc \
 fftw-libs \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-quad \
 fftw-libs-single \
 fftw-openmpi-devel \
 fftw-openmpi-libs \
 fftw-openmpi-libs-double \
 fftw-openmpi-libs-long \
 fftw-openmpi-libs-single \
 fftw-openmpi-static \
 fftw-static \
"
PACKAGES:aarch64 = " \
 fftw \
 fftw-devel \
 fftw-doc \
 fftw-libs \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-single \
 fftw-openmpi-devel \
 fftw-openmpi-libs \
 fftw-openmpi-libs-double \
 fftw-openmpi-libs-long \
 fftw-openmpi-libs-single \
 fftw-openmpi-static \
 fftw-static \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fftw-3.3.10-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59775f1311180a77b5bc05d626146267f0340a528d0d77a0347e9c6064db3031"

URI_x86_64_v2_fftw = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw}"
SRC_URI[x86_64_v2_fftw.sha256sum] = "211f5f1dcb503dfc9be730d59d1aa99f3f84892973f883ce110fb435d3a18b30"

URI_x86_64_v2_fftw-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-devel-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-devel}"
SRC_URI[x86_64_v2_fftw-devel.sha256sum] = "bd5eb3e5424184f146fbe213f548965b33cf46d057e281d13d7e09ca4ee2e8a5"

URI_x86_64_v2_fftw-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fftw-doc-3.3.10-15.el10.noarch.rpm;name=x86_64_v2_fftw-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-doc}"
SRC_URI[x86_64_v2_fftw-doc.sha256sum] = "917c89810134e4e21604b21b5c15ea5954b1e56eb885d7569c84556bd44b4893"

URI_x86_64_v2_fftw-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-libs}"
SRC_URI[x86_64_v2_fftw-libs.sha256sum] = "b829a5aa7281a5e0433308f212ce03d8bea70290055044a3955c929b0d8fb669"

URI_x86_64_v2_fftw-libs-double = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-double-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw-libs-double;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-libs-double}"
SRC_URI[x86_64_v2_fftw-libs-double.sha256sum] = "0acdb2a8bc477d8c52a7179222e3c41ebe6d2a138ecacff7f666c28f8db7ff76"

URI_x86_64_v2_fftw-libs-long = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-long-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw-libs-long;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-libs-long}"
SRC_URI[x86_64_v2_fftw-libs-long.sha256sum] = "0b013af978aac025abb5078dcc21894360ae3b004d3aecefd691e71c7cc16e34"

URI_x86_64_v2_fftw-libs-quad = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-quad-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw-libs-quad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-libs-quad}"
SRC_URI[x86_64_v2_fftw-libs-quad.sha256sum] = "114709b92d53816968b71456680081df4e6f13c74bd0d83a85c5f2360c173ec7"

URI_x86_64_v2_fftw-libs-single = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-single-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw-libs-single;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-libs-single}"
SRC_URI[x86_64_v2_fftw-libs-single.sha256sum] = "2b046bb2a614d332d197eb2085b215f37135746dbbd3180a1fbd5a1af3d10fc9"

URI_x86_64_v2_fftw-openmpi-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-devel-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-openmpi-devel}"
SRC_URI[x86_64_v2_fftw-openmpi-devel.sha256sum] = "c3c0571f5ebe8ab08f3495febd5c4ae356ff2ac4f94a90bfc24ddb88278fc0b1"

URI_x86_64_v2_fftw-openmpi-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-openmpi-libs}"
SRC_URI[x86_64_v2_fftw-openmpi-libs.sha256sum] = "7234692c868a1b83854e254724bee0d8fe57d1413d1e5945a2b5e51e92aeb4bd"

URI_x86_64_v2_fftw-openmpi-libs-double = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-double-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-libs-double;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-openmpi-libs-double}"
SRC_URI[x86_64_v2_fftw-openmpi-libs-double.sha256sum] = "0814c58fe5b5294c344e1f820dae1c065b60feeab1514c14e9e3fd945602cdc2"

URI_x86_64_v2_fftw-openmpi-libs-long = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-long-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-libs-long;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-openmpi-libs-long}"
SRC_URI[x86_64_v2_fftw-openmpi-libs-long.sha256sum] = "f55af2dd74c3978126a22e8be884330f2613af42d1989d722e745fe40f0f17e6"

URI_x86_64_v2_fftw-openmpi-libs-single = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-single-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-libs-single;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-openmpi-libs-single}"
SRC_URI[x86_64_v2_fftw-openmpi-libs-single.sha256sum] = "954225258f69174b237a528e1894baad89329ad0b946531c9c3c5b919b18889e"

URI_x86_64_v2_fftw-openmpi-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-static-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-openmpi-static}"
SRC_URI[x86_64_v2_fftw-openmpi-static.sha256sum] = "6f292266036ef4cb0e5e81d1912121ab921b9e1e004e9c95673ed0bb491558e7"

URI_x86_64_v2_fftw-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-static-3.3.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_fftw-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-static}"
SRC_URI[x86_64_v2_fftw-static.sha256sum] = "4aee5476ea85fbb4e1f95a0f4a80f74d23e8aee7e940cc5ee85a1b9aaab3d7b8"

URI_aarch64_fftw = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-3.3.10-15.el10.aarch64.rpm;name=aarch64_fftw;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw}"
SRC_URI[aarch64_fftw.sha256sum] = "5d547416a1d46ecd5cb4b482c88e625a8f7d4ca0d886e93f179eca8d11334883"

URI_aarch64_fftw-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-devel-3.3.10-15.el10.aarch64.rpm;name=aarch64_fftw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-devel}"
SRC_URI[aarch64_fftw-devel.sha256sum] = "675e5bab44d2158df32f0db1b2991b0c30cb582e9884f294b517b304515e21d4"

URI_aarch64_fftw-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fftw-doc-3.3.10-15.el10.noarch.rpm;name=aarch64_fftw-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-doc}"
SRC_URI[aarch64_fftw-doc.sha256sum] = "917c89810134e4e21604b21b5c15ea5954b1e56eb885d7569c84556bd44b4893"

URI_aarch64_fftw-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-libs-3.3.10-15.el10.aarch64.rpm;name=aarch64_fftw-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-libs}"
SRC_URI[aarch64_fftw-libs.sha256sum] = "06418dcc74d716ef0cf1f52571425e6d7c190800b77af7f495ee5bddc1fa200c"

URI_aarch64_fftw-libs-double = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-libs-double-3.3.10-15.el10.aarch64.rpm;name=aarch64_fftw-libs-double;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-libs-double}"
SRC_URI[aarch64_fftw-libs-double.sha256sum] = "b23ea20675d620592cc8e67517d2dc9eb0a120df7aaeed9c0c4583dcd54257f5"

URI_aarch64_fftw-libs-long = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-libs-long-3.3.10-15.el10.aarch64.rpm;name=aarch64_fftw-libs-long;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-libs-long}"
SRC_URI[aarch64_fftw-libs-long.sha256sum] = "5b88ac7c6dc4eb56fd7e5c75fd756a45324f45647cff8685b74b273e4306b4cc"

URI_aarch64_fftw-libs-single = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-libs-single-3.3.10-15.el10.aarch64.rpm;name=aarch64_fftw-libs-single;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-libs-single}"
SRC_URI[aarch64_fftw-libs-single.sha256sum] = "d82666cc89d07cfcf05bd3ab6611cc2de755be4107ef9860d7cd4bb7ebeda586"

URI_aarch64_fftw-openmpi-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-devel-3.3.10-15.el10.aarch64.rpm;name=aarch64_fftw-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-openmpi-devel}"
SRC_URI[aarch64_fftw-openmpi-devel.sha256sum] = "517de2d8700a402b95a7fa19082b316fb16eec03156740b183a1e238ff5e595d"

URI_aarch64_fftw-openmpi-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-libs-3.3.10-15.el10.aarch64.rpm;name=aarch64_fftw-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-openmpi-libs}"
SRC_URI[aarch64_fftw-openmpi-libs.sha256sum] = "1993a1a5ba56ef1926514806bd211e1c06fd0c5eb147067442fe2a480cf1645e"

URI_aarch64_fftw-openmpi-libs-double = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-libs-double-3.3.10-15.el10.aarch64.rpm;name=aarch64_fftw-openmpi-libs-double;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-openmpi-libs-double}"
SRC_URI[aarch64_fftw-openmpi-libs-double.sha256sum] = "c1d7144720099bbee0803a4326fd4552acfbc85a24fc7c929195e84ebd21e9b7"

URI_aarch64_fftw-openmpi-libs-long = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-libs-long-3.3.10-15.el10.aarch64.rpm;name=aarch64_fftw-openmpi-libs-long;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-openmpi-libs-long}"
SRC_URI[aarch64_fftw-openmpi-libs-long.sha256sum] = "84f6919cb8fcd928d600d26740e4c4d05585772c6f5eef71c9159b929f17ff0d"

URI_aarch64_fftw-openmpi-libs-single = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-libs-single-3.3.10-15.el10.aarch64.rpm;name=aarch64_fftw-openmpi-libs-single;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-openmpi-libs-single}"
SRC_URI[aarch64_fftw-openmpi-libs-single.sha256sum] = "b17838509e1a2c54a6f6c6b038ab0790436580f2b6e97888a8252c91face6ff1"

URI_aarch64_fftw-openmpi-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-static-3.3.10-15.el10.aarch64.rpm;name=aarch64_fftw-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-openmpi-static}"
SRC_URI[aarch64_fftw-openmpi-static.sha256sum] = "9878b048a305cf439f2b9a42a1ae561f08d72f8aa0cae0fcbb2ea965c8338516"

URI_aarch64_fftw-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-static-3.3.10-15.el10.aarch64.rpm;name=aarch64_fftw-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-static}"
SRC_URI[aarch64_fftw-static.sha256sum] = "81ac657ba2085d931a1bdddb18bdbc1fbde27f3584e70536ce6ab49a7407cbe9"

RDEPENDS:fftw:x86_64_v2 = " \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-quad \
 fftw-libs-single \
 glibc \
"
RDEPENDS:fftw:aarch64 = " \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-single \
 glibc \
"
RDEPENDS:fftw-devel = " \
 fftw \
 fftw-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:fftw-doc = " \
 "
RDEPENDS:fftw-libs:x86_64_v2 = " \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-quad \
 fftw-libs-single \
"
RDEPENDS:fftw-libs:aarch64 = " \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-single \
"
RDEPENDS:fftw-libs-double = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:fftw-libs-long = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:fftw-libs-quad = " \
 glibc \
 libgcc \
 libgomp \
 libquadmath \
 "
RDEPENDS:fftw-libs-single = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:fftw-openmpi-devel = " \
 fftw-devel \
 fftw-openmpi-libs \
 openmpi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:fftw-openmpi-libs = " \
 fftw-openmpi-libs-double \
 fftw-openmpi-libs-long \
 fftw-openmpi-libs-single \
 "
RDEPENDS:fftw-openmpi-libs-double = " \
 fftw-libs-double \
 glibc \
 openmpi \
 "
RDEPENDS:fftw-openmpi-libs-long = " \
 fftw-libs-long \
 glibc \
 openmpi \
 "
RDEPENDS:fftw-openmpi-libs-single = " \
 fftw-libs-single \
 glibc \
 openmpi \
 "
RDEPENDS:fftw-openmpi-static = " \
 fftw-openmpi-devel \
 fftw-static \
 "
RDEPENDS:fftw-static = " \
 fftw-devel \
 "
