# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-schema"
PV = "0.7.7"
PR = "1.el10_0"
PACKAGES = " \
 python3-schema \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-schema-0.7.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01e21c1867029f31fae8bd0d2b6f91542d094f9c205df7a05cd33cd03c862f6e"

URI_x86_64_v2_python3-schema = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-schema-0.7.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-schema;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-schema}"
SRC_URI[x86_64_v2_python3-schema.sha256sum] = "fdfe73c6b8fb17ded1e64d2eb1692850d29f49773dcf796ccd1e23bdd96f6241"

URI_aarch64_python3-schema = "${EPEL_MIRROR}/aarch64/Packages/p/python3-schema-0.7.7-1.el10_0.noarch.rpm;name=aarch64_python3-schema;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-schema}"
SRC_URI[aarch64_python3-schema.sha256sum] = "1cfb939022bf6459d6e8203d25f88cce094796cc44cdd854d345157b79fc0170"

RDEPENDS:python3-schema = " \
 python3 \
 "
