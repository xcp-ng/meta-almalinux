# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-google"
PV = "2.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqsign-google+default-devel \
 rust-reqsign-google-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-google-2.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f22bd8bec376163d52591a2af0a3863de936a5c29db6cef24634752338c698ac"

URI_x86_64_v2_rust-reqsign-google+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-google+default-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-google+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-google+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-google+default-devel.sha256sum] = "398e92b4778d061400fd9c1e423992b331e32799677ed1ba95fde2f6165d9246"

URI_x86_64_v2_rust-reqsign-google-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-google-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-google-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-google-devel}"
SRC_URI[x86_64_v2_rust-reqsign-google-devel.sha256sum] = "5d95f6fca57692da2206669c77fd33ab04f633a26d6f46e44312065a6f31ce29"

URI_aarch64_rust-reqsign-google+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-google+default-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-google+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-google+default-devel}"
SRC_URI[aarch64_rust-reqsign-google+default-devel.sha256sum] = "3155def6039e4d31bd0febf9897ecd99d7d15708e4d8110d37d039eb208356ea"

URI_aarch64_rust-reqsign-google-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-google-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-google-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-google-devel}"
SRC_URI[aarch64_rust-reqsign-google-devel.sha256sum] = "ff07fdf3196221f37d379ba8f9fd94ed2b89838dcb22ccd7ed22e179a397cd80"

RDEPENDS:rust-reqsign-google+default-devel = " \
 cargo \
 rust-reqsign-google-devel \
 "
RDEPENDS:rust-reqsign-google-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-jsonwebtoken+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-rand0.8+default-devel \
 rust-reqsign-core+default-devel \
 rust-reqwest0.12-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-sha2+default-devel \
 rust-sha2+oid-devel \
 "
