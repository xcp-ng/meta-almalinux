# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-manager"
PV = "5.1.0"
PR = "2.el10"
PACKAGES = " \
 virt-install \
 virt-manager \
 virt-manager-common \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virt-manager-5.1.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6d7f79ed20705d69827d0c9e843605a935f9ea553efa2cb59b43c09e342f8b4"

URI_x86_64_v2_virt-install = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-install-5.1.0-2.el10.noarch.rpm;name=x86_64_v2_virt-install;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-install}"
SRC_URI[x86_64_v2_virt-install.sha256sum] = "57e7a0ff0b5a8a89b125311708f7c7832c5c04daa66bbc04212eb9c0bedb731e"

URI_x86_64_v2_virt-manager = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/virt-manager-5.1.0-2.el10.noarch.rpm;name=x86_64_v2_virt-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-manager}"
SRC_URI[x86_64_v2_virt-manager.sha256sum] = "46d1d09d2475d52eb5fd79baadf8a72f2083fb7d423862d600be2447221cc68f"

URI_x86_64_v2_virt-manager-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-manager-common-5.1.0-2.el10.noarch.rpm;name=x86_64_v2_virt-manager-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-manager-common}"
SRC_URI[x86_64_v2_virt-manager-common.sha256sum] = "89c77683d9cd7ed874e02c981a10a1638d303e4e3f7c19140c69447146621b5c"

URI_aarch64_virt-install = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-install-5.1.0-2.el10.noarch.rpm;name=aarch64_virt-install;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-install}"
SRC_URI[aarch64_virt-install.sha256sum] = "57e7a0ff0b5a8a89b125311708f7c7832c5c04daa66bbc04212eb9c0bedb731e"

URI_aarch64_virt-manager = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/virt-manager-5.1.0-2.el10.noarch.rpm;name=aarch64_virt-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-manager}"
SRC_URI[aarch64_virt-manager.sha256sum] = "46d1d09d2475d52eb5fd79baadf8a72f2083fb7d423862d600be2447221cc68f"

URI_aarch64_virt-manager-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-manager-common-5.1.0-2.el10.noarch.rpm;name=aarch64_virt-manager-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-manager-common}"
SRC_URI[aarch64_virt-manager-common.sha256sum] = "89c77683d9cd7ed874e02c981a10a1638d303e4e3f7c19140c69447146621b5c"

RDEPENDS:virt-install = " \
 libvirt-client \
 python3 \
 virt-manager-common \
 "
RDEPENDS:virt-manager = " \
 dconf \
 gtk-vnc2 \
 gtk3 \
 libvirt-glib \
 python3 \
 python3-gobject \
 virt-manager-common \
 vte291 \
 "
RDEPENDS:virt-manager-common = " \
 libosinfo \
 python3-argcomplete \
 python3-gobject-base \
 python3-libvirt \
 python3-libxml2 \
 python3-requests \
 xorriso \
 "
