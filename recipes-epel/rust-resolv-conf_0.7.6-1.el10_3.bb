# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-resolv-conf"
PV = "0.7.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-resolv-conf+default-devel \
 rust-resolv-conf+system-devel \
 rust-resolv-conf-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-resolv-conf-0.7.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a2e96956bffa18aeb790ee3f018b36bb88578dbdf1ec7cda220ead730236a5e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-resolv-conf+default-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-resolv-conf+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-resolv-conf+default-devel.sha256sum] = "7bd286fca3a9c97e4d47450d0d4284d1dcd02ee37d8fa48694320b305054d8e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-resolv-conf+system-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-resolv-conf+system-devel;unpack=0"
SRC_URI[x86_64_v2_rust-resolv-conf+system-devel.sha256sum] = "ada37c7c7eb85cd6a78a7d8e4f0d017a6a5b6e521cc57fd8a4932954a96d4be0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-resolv-conf-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-resolv-conf-devel;unpack=0"
SRC_URI[x86_64_v2_rust-resolv-conf-devel.sha256sum] = "528ad07dd05fdc0c64df148c51ede4337504618caf8c608bc9c4d170d0d7b046"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-resolv-conf+default-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-resolv-conf+default-devel;unpack=0"
SRC_URI[aarch64_rust-resolv-conf+default-devel.sha256sum] = "034a4bb19e432684679c7fed5f9da2fe9160d588607ff0c0b657f68031898f03"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-resolv-conf+system-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-resolv-conf+system-devel;unpack=0"
SRC_URI[aarch64_rust-resolv-conf+system-devel.sha256sum] = "592d7d4d63baa2a317f292dd13df3237aff3b78247c17c990bd7f8fed2982e99"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-resolv-conf-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-resolv-conf-devel;unpack=0"
SRC_URI[aarch64_rust-resolv-conf-devel.sha256sum] = "a25a93d111bd7b18768817f7f8d1f1c7928de95efb53a0f61d42b5bb86a1da38"

RDEPENDS:rust-resolv-conf+default-devel = " \
 cargo \
 rust-resolv-conf-devel \
 "
RDEPENDS:rust-resolv-conf+system-devel = " \
 cargo \
 rust-resolv-conf-devel \
 "
RDEPENDS:rust-resolv-conf-devel = " \
 cargo \
 rust \
 "
