# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typenum"
PV = "1.19.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-typenum+const-generics-devel \
 rust-typenum+default-devel \
 rust-typenum+force_unix_path_separator-devel \
 rust-typenum+i128-devel \
 rust-typenum+no_std-devel \
 rust-typenum+strict-devel \
 rust-typenum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typenum-1.19.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa0c212fa203140e0613003a1c7848541e7aa2a076832846967880cbed3d6d1a"

URI_x86_64_v2_rust-typenum+const-generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+const-generics-devel-1.19.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+const-generics-devel}"
SRC_URI[x86_64_v2_rust-typenum+const-generics-devel.sha256sum] = "9f2500c2b451774caad3bd5e8b42b2474f21784173260a32d3f4a752f6654aa6"

URI_x86_64_v2_rust-typenum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+default-devel-1.19.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+default-devel}"
SRC_URI[x86_64_v2_rust-typenum+default-devel.sha256sum] = "45852a02b520cadcc97bc1d66fbb1ae8adadaa305caaa6abf26799f2e07011a5"

URI_x86_64_v2_rust-typenum+force_unix_path_separator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+force_unix_path_separator-devel-1.19.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+force_unix_path_separator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+force_unix_path_separator-devel}"
SRC_URI[x86_64_v2_rust-typenum+force_unix_path_separator-devel.sha256sum] = "fdf38dc5f22aded684df43ea0fdec8ce70bea3296369f370fa44c24b672cb14a"

URI_x86_64_v2_rust-typenum+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+i128-devel-1.19.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+i128-devel}"
SRC_URI[x86_64_v2_rust-typenum+i128-devel.sha256sum] = "2cb87c26ccf1a34dd24370c8b653bbef645d741863aa694f7283881dbfde4420"

URI_x86_64_v2_rust-typenum+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+no_std-devel-1.19.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+no_std-devel}"
SRC_URI[x86_64_v2_rust-typenum+no_std-devel.sha256sum] = "a0ef8ce0b577d999c4968710be1171e65a4ff40db74543ffc4e562b0db93a56e"

URI_x86_64_v2_rust-typenum+strict-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+strict-devel-1.19.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+strict-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+strict-devel}"
SRC_URI[x86_64_v2_rust-typenum+strict-devel.sha256sum] = "2c43d9158375af60019c807e4eff2c6616025479bed1c29f551347006f66dab0"

URI_x86_64_v2_rust-typenum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum-devel-1.19.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum-devel}"
SRC_URI[x86_64_v2_rust-typenum-devel.sha256sum] = "39845940e7d05fb5b0685471dd96fb852445be199146e0181473f8a38cf429d7"

URI_aarch64_rust-typenum+const-generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+const-generics-devel-1.19.0-1.el10_2.noarch.rpm;name=aarch64_rust-typenum+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+const-generics-devel}"
SRC_URI[aarch64_rust-typenum+const-generics-devel.sha256sum] = "fdc87793e2d444759fe6f517fa3a4f5aecacccfa73f5f3d40d19a0169ec91e83"

URI_aarch64_rust-typenum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+default-devel-1.19.0-1.el10_2.noarch.rpm;name=aarch64_rust-typenum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+default-devel}"
SRC_URI[aarch64_rust-typenum+default-devel.sha256sum] = "fb632211692d41b39e079732b1e443a63ab572927f936e9a3936c3b263eee933"

URI_aarch64_rust-typenum+force_unix_path_separator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+force_unix_path_separator-devel-1.19.0-1.el10_2.noarch.rpm;name=aarch64_rust-typenum+force_unix_path_separator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+force_unix_path_separator-devel}"
SRC_URI[aarch64_rust-typenum+force_unix_path_separator-devel.sha256sum] = "8dc27441c198ac527563b22684b9a11cb53a04489997428b6dde2dcc33a4533c"

URI_aarch64_rust-typenum+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+i128-devel-1.19.0-1.el10_2.noarch.rpm;name=aarch64_rust-typenum+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+i128-devel}"
SRC_URI[aarch64_rust-typenum+i128-devel.sha256sum] = "a003ef08b6d77386ab24c7995f369a505c28b6cf782479b698cb859bb4b4cc39"

URI_aarch64_rust-typenum+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+no_std-devel-1.19.0-1.el10_2.noarch.rpm;name=aarch64_rust-typenum+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+no_std-devel}"
SRC_URI[aarch64_rust-typenum+no_std-devel.sha256sum] = "899f8c2830b5834460e61df6a61b89d34afc2264e1b02b967de7767e2ddb5a7e"

URI_aarch64_rust-typenum+strict-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+strict-devel-1.19.0-1.el10_2.noarch.rpm;name=aarch64_rust-typenum+strict-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+strict-devel}"
SRC_URI[aarch64_rust-typenum+strict-devel.sha256sum] = "01215fcf7d06e979e744a629586f070bf700e6b86db92de2d9621b89324a015e"

URI_aarch64_rust-typenum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum-devel-1.19.0-1.el10_2.noarch.rpm;name=aarch64_rust-typenum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum-devel}"
SRC_URI[aarch64_rust-typenum-devel.sha256sum] = "526f68242f4ef5705c808d934ba70859e283babd3b1c06485b856502ea28efee"

RDEPENDS:rust-typenum+const-generics-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+default-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+force_unix_path_separator-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+i128-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+no_std-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+strict-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum-devel = " \
 cargo \
 rust \
 "
