# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkcompactdisc"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libkcompactdisc \
 libkcompactdisc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkcompactdisc-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17dd8721b28307a35c6e60b10394909be8c602f1e6db74e5733deb13aceda0d2"

URI_x86_64_v2_libkcompactdisc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcompactdisc-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcompactdisc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcompactdisc}"
SRC_URI[x86_64_v2_libkcompactdisc.sha256sum] = "8fa807e5e71f77a74e7069c6cbf0448fa11b6052460d6ab01b3bbccfe16d3d18"

URI_x86_64_v2_libkcompactdisc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcompactdisc-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcompactdisc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcompactdisc-devel}"
SRC_URI[x86_64_v2_libkcompactdisc-devel.sha256sum] = "98a280fdfe543326c89a8105b3e4f7b239763c7e295aa539b3f2d9fc4fb57cd6"

URI_aarch64_libkcompactdisc = "${EPEL_MIRROR}/aarch64/Packages/l/libkcompactdisc-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkcompactdisc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcompactdisc}"
SRC_URI[aarch64_libkcompactdisc.sha256sum] = "c1bc398b7dcdce6d10026da7e1d1a65f42a152abd623ef1d480408230cd878af"

URI_aarch64_libkcompactdisc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkcompactdisc-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkcompactdisc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcompactdisc-devel}"
SRC_URI[aarch64_libkcompactdisc-devel.sha256sum] = "fb9dc883912493885c62710070853af5395641fe305345f4953b90ef041e0d93"

RDEPENDS:libkcompactdisc = " \
 alsa-lib \
 glibc \
 kf6-ki18n \
 kf6-solid \
 libstdc++ \
 phonon-qt6 \
 qt6-qtbase \
 "
RDEPENDS:libkcompactdisc-devel = " \
 cmake-filesystem \
 libkcompactdisc \
 "
