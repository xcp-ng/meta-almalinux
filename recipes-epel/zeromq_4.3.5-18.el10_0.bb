# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zeromq"
PV = "4.3.5"
PR = "18.el10_0"
PACKAGES = " \
 zeromq \
 zeromq-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zeromq-4.3.5-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a650f53dc65bdad0238019c046d47b908c08e000dfbbb941cea1ec6a18e57b7"

URI_x86_64_v2_zeromq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zeromq-4.3.5-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zeromq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zeromq}"
SRC_URI[x86_64_v2_zeromq.sha256sum] = "32ce1a085256516f7a3c16dd1406de6d397f38857e001453c8286da6b8dddbf8"

URI_x86_64_v2_zeromq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zeromq-devel-4.3.5-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zeromq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zeromq-devel}"
SRC_URI[x86_64_v2_zeromq-devel.sha256sum] = "a38897815df9bc6b9b7f20000c26f014ef51ee73f829ae9653e7e05879675b56"

URI_aarch64_zeromq = "${EPEL_MIRROR}/aarch64/Packages/z/zeromq-4.3.5-18.el10_0.aarch64.rpm;name=aarch64_zeromq;unpack=0"
SRC_URI:append = " ${URI_aarch64_zeromq}"
SRC_URI[aarch64_zeromq.sha256sum] = "8933aaa613abc1dfeafd4ed40a5e12466b3067e153a85d74913740a3d79f9997"

URI_aarch64_zeromq-devel = "${EPEL_MIRROR}/aarch64/Packages/z/zeromq-devel-4.3.5-18.el10_0.aarch64.rpm;name=aarch64_zeromq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zeromq-devel}"
SRC_URI[aarch64_zeromq-devel.sha256sum] = "151ec4d8edcea7b32c02d4dd53f812d6cef66d127d924125bf9149985bdd9f95"

RDEPENDS:zeromq = " \
 glibc \
 krb5-libs \
 libgcc \
 libsodium \
 libstdc++ \
 libunwind \
 openpgm \
 "
RDEPENDS:zeromq-devel = " \
 krb5-devel \
 libsodium-devel \
 libunwind-devel \
 openpgm-devel \
 pkgconf-pkg-config \
 zeromq \
 "
