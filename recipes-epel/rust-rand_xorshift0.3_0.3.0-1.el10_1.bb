# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_xorshift0.3"
PV = "0.3.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-rand_xorshift0.3+default-devel \
 rust-rand_xorshift0.3+serde-devel \
 rust-rand_xorshift0.3+serde1-devel \
 rust-rand_xorshift0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_xorshift0.3-0.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57f7bd3cd27f6529961cda06ddd29ebc4958d886d525443c6847a2166302aad3"

URI_x86_64_v2_rust-rand_xorshift0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift0.3+default-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift0.3+default-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift0.3+default-devel.sha256sum] = "3e8d2905bb9cbd726091c4558a155bef0a8c495671989aad43c4fa6d5e01ea98"

URI_x86_64_v2_rust-rand_xorshift0.3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift0.3+serde-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift0.3+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift0.3+serde-devel.sha256sum] = "75415ec4e6d34590f009c73e1c67aae1349a2e34eb475cc1b53f5b898d99bba4"

URI_x86_64_v2_rust-rand_xorshift0.3+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift0.3+serde1-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift0.3+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift0.3+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift0.3+serde1-devel.sha256sum] = "e97b260102b81ed89b1d609fbc2d9a0ce8fb3fbc52fa93717cdf904e4a27fdef"

URI_x86_64_v2_rust-rand_xorshift0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift0.3-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift0.3-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift0.3-devel.sha256sum] = "3438e7a04cf6489dc1d4b70095d99318d0fb0ec0b937356d683ace83f3b45a3f"

URI_aarch64_rust-rand_xorshift0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift0.3+default-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-rand_xorshift0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift0.3+default-devel}"
SRC_URI[aarch64_rust-rand_xorshift0.3+default-devel.sha256sum] = "11599622037353161587756bfe3ff6cb24706be926cd65126ded480a20cf3dd5"

URI_aarch64_rust-rand_xorshift0.3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift0.3+serde-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-rand_xorshift0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift0.3+serde-devel}"
SRC_URI[aarch64_rust-rand_xorshift0.3+serde-devel.sha256sum] = "ef4782205031f62d7e8ded6889ecf3e3f598874e10c8224e04449d0b082ccdf8"

URI_aarch64_rust-rand_xorshift0.3+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift0.3+serde1-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-rand_xorshift0.3+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift0.3+serde1-devel}"
SRC_URI[aarch64_rust-rand_xorshift0.3+serde1-devel.sha256sum] = "1a651f4d041687ff2461ee215b620f3b8d655bc3d6dea6ecd6c0aecbceaccb8c"

URI_aarch64_rust-rand_xorshift0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift0.3-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-rand_xorshift0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift0.3-devel}"
SRC_URI[aarch64_rust-rand_xorshift0.3-devel.sha256sum] = "229ff0ffbc9395c5b57ef4f6b8d71a98fb5a91c9ada53b9d5b9a422079d57c28"

RDEPENDS:rust-rand_xorshift0.3+default-devel = " \
 cargo \
 rust-rand_xorshift0.3-devel \
 "
RDEPENDS:rust-rand_xorshift0.3+serde-devel = " \
 cargo \
 rust-rand_xorshift0.3-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rand_xorshift0.3+serde1-devel = " \
 cargo \
 rust-rand_xorshift0.3+serde-devel \
 rust-rand_xorshift0.3-devel \
 "
RDEPENDS:rust-rand_xorshift0.3-devel = " \
 cargo \
 rust-rand_core0.6+default-devel \
 "
