# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ostree"
PV = "2025.2"
PR = "1.el10_0"
PACKAGES = " \
 ostree \
 ostree-devel \
 ostree-grub2 \
 ostree-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ostree-2025.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "445884b8821a86836b05fe9fc66c3ef6d09cb8bbe062bcd7b38da6674bab03d7"

URI_x86_64_v2_ostree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ostree-2025.2-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ostree}"
SRC_URI[x86_64_v2_ostree.sha256sum] = "7ab96baf280e8e56a84b552e43a198903efb84b849a40924f2ad30061cbc4611"

URI_x86_64_v2_ostree-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ostree-devel-2025.2-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_ostree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ostree-devel}"
SRC_URI[x86_64_v2_ostree-devel.sha256sum] = "6693a911b7e08b69eb451b3a9e6f6d41a4df2f321b3b923caa18b408da402572"

URI_x86_64_v2_ostree-grub2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ostree-grub2-2025.2-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_ostree-grub2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ostree-grub2}"
SRC_URI[x86_64_v2_ostree-grub2.sha256sum] = "d2eef79726018a1ea88b6c95eade52f94499b1fee30c1240fed55205c8da2473"

URI_x86_64_v2_ostree-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ostree-libs-2025.2-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_ostree-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ostree-libs}"
SRC_URI[x86_64_v2_ostree-libs.sha256sum] = "70e50b742f5e35c4657605b00421fc90b9e64a7ff40c9046267b0611efbd1c92"

URI_aarch64_ostree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ostree-2025.2-1.el10_0.aarch64.rpm;name=aarch64_ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_ostree}"
SRC_URI[aarch64_ostree.sha256sum] = "acbdba65c5af5c520b7a4525b1a2336d72d3d807e144be77a11a8a48ab34f4ea"

URI_aarch64_ostree-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ostree-devel-2025.2-1.el10_0.aarch64.rpm;name=aarch64_ostree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ostree-devel}"
SRC_URI[aarch64_ostree-devel.sha256sum] = "977fa64579a66363a082ca8c55e2062f8888b27e778d657de0ec8ed8857ea6e3"

URI_aarch64_ostree-grub2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ostree-grub2-2025.2-1.el10_0.aarch64.rpm;name=aarch64_ostree-grub2;unpack=0"
SRC_URI:append = " ${URI_aarch64_ostree-grub2}"
SRC_URI[aarch64_ostree-grub2.sha256sum] = "c1c2ecf9cf23972ace0a8c3dcbfacf7107bf405552a176363284a1798beba978"

URI_aarch64_ostree-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ostree-libs-2025.2-1.el10_0.aarch64.rpm;name=aarch64_ostree-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ostree-libs}"
SRC_URI[aarch64_ostree-libs.sha256sum] = "1eaf7c432b4b84505a97e4ab7f67dd210dc0dae05fd20d4b8abb3c2d282253be"

RDEPENDS:ostree = " \
 bash \
 composefs \
 composefs-libs \
 dracut \
 fuse-libs \
 glib2 \
 glibc \
 gnupg2 \
 libarchive \
 libgcc \
 libselinux \
 openssl-libs \
 ostree-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:ostree-devel = " \
 composefs-devel \
 glib2-devel \
 gpgme-devel \
 libarchive-devel \
 libcurl-devel \
 libgpg-error-devel \
 libselinux-devel \
 openssl-devel \
 ostree-libs \
 pkgconf-pkg-config \
 systemd-devel \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:ostree-grub2:x86_64_v2 = " \
 bash \
 grub2-pc \
 ostree \
"
RDEPENDS:ostree-grub2:aarch64 = " \
 bash \
 grub2-efi-aa64 \
 ostree \
"
RDEPENDS:ostree-libs = " \
 composefs-libs \
 glib2 \
 glibc \
 gpgme \
 libarchive \
 libgcc \
 libgpg-error \
 libmount \
 libselinux \
 openssl-libs \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
