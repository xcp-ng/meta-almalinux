# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "miniupnpc"
PV = "2.2.8"
PR = "1.el10_0"
PACKAGES = " \
 miniupnpc \
 miniupnpc-devel \
 python3-miniupnpc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/miniupnpc-2.2.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2f318f05b3d82eaa15029b7db0a5e494f2f7211e86dafaf157ad97929478b28"

URI_x86_64_v2_miniupnpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/miniupnpc-2.2.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_miniupnpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_miniupnpc}"
SRC_URI[x86_64_v2_miniupnpc.sha256sum] = "7c361c26d6161ea8da7093ab2df80e22372c53171585de8a91673383545e5b04"

URI_x86_64_v2_miniupnpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/miniupnpc-devel-2.2.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_miniupnpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_miniupnpc-devel}"
SRC_URI[x86_64_v2_miniupnpc-devel.sha256sum] = "1d83504155d32be78f6f29691dbd96372d647a114171890a5d4945b8af7a3ba8"

URI_x86_64_v2_python3-miniupnpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-miniupnpc-2.2.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-miniupnpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-miniupnpc}"
SRC_URI[x86_64_v2_python3-miniupnpc.sha256sum] = "d5f0e4e03cbecaf45795bcba9134e27c21a8928f6a617cc36269f95d23d086b5"

URI_aarch64_miniupnpc = "${EPEL_MIRROR}/aarch64/Packages/m/miniupnpc-2.2.8-1.el10_0.aarch64.rpm;name=aarch64_miniupnpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_miniupnpc}"
SRC_URI[aarch64_miniupnpc.sha256sum] = "bbd8c0ea51bf2563be91f040a70f55aa066c5f44761f4844bc35096d1e7433d0"

URI_aarch64_miniupnpc-devel = "${EPEL_MIRROR}/aarch64/Packages/m/miniupnpc-devel-2.2.8-1.el10_0.aarch64.rpm;name=aarch64_miniupnpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_miniupnpc-devel}"
SRC_URI[aarch64_miniupnpc-devel.sha256sum] = "ee2ad9a4a9fc8081373c2be09275694de10a90e80c9d5a3df2b9fa4e48e97c6c"

URI_aarch64_python3-miniupnpc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-miniupnpc-2.2.8-1.el10_0.aarch64.rpm;name=aarch64_python3-miniupnpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-miniupnpc}"
SRC_URI[aarch64_python3-miniupnpc.sha256sum] = "d72c7028f9bbffc730bc2f0f4ad2e5fe1b86ccbdebfecfe003d98e241076907a"

RDEPENDS:miniupnpc = " \
 glibc \
 "
RDEPENDS:miniupnpc-devel = " \
 cmake-filesystem \
 miniupnpc \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-miniupnpc = " \
 glibc \
 miniupnpc \
 python3 \
 "
