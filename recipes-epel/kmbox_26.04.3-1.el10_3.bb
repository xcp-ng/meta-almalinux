# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmbox"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kmbox \
 kmbox-devel \
 kmbox-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmbox-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f54ad9c54a4ac2ea1cf7c2ce6a4e8d9eeb2e34a5874dc7abc4cfced4f99ac715"

URI_x86_64_v2_kmbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmbox}"
SRC_URI[x86_64_v2_kmbox.sha256sum] = "915bb8a208b5595c5041fdda63c3c87d4e6d48a1136b78138e2cbfbd46ddfc16"

URI_x86_64_v2_kmbox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmbox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmbox-devel}"
SRC_URI[x86_64_v2_kmbox-devel.sha256sum] = "d4e742e7bfefbe5b46c7f096ec5c8e2f58a769179a72f985bfec18eb60a34ba6"

URI_x86_64_v2_kmbox-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmbox-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kmbox-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmbox-doc}"
SRC_URI[x86_64_v2_kmbox-doc.sha256sum] = "9950a17483fb97076eaafaca02fe08e5920489f4ac65956af682d2af7e8fc1f5"

URI_aarch64_kmbox = "${EPEL_MIRROR}/aarch64/Packages/k/kmbox-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmbox}"
SRC_URI[aarch64_kmbox.sha256sum] = "0d9f081c703e43bf54f442bfc7c4b081d0a36f0068d6c23e7e66d116f923b55e"

URI_aarch64_kmbox-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kmbox-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmbox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmbox-devel}"
SRC_URI[aarch64_kmbox-devel.sha256sum] = "dddb27340c55e4dd29b359faf13aa2d22c0aaf55b0b98e4fb90a2a29e8b90b9b"

URI_aarch64_kmbox-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kmbox-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kmbox-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmbox-doc}"
SRC_URI[aarch64_kmbox-doc.sha256sum] = "407b38b46e07c849eb38adc28c8af7c87ecc66c26cf6a279eed111139ec3ac57"

RDEPENDS:kmbox = " \
 glibc \
 kmime \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kmbox-devel = " \
 cmake-filesystem \
 kmbox \
 kmime-devel \
 "
RDEPENDS:kmbox-doc = " \
 "
