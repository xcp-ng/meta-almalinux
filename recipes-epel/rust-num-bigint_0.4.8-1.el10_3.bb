# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-bigint"
PV = "0.4.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-num-bigint+arbitrary-devel \
 rust-num-bigint+default-devel \
 rust-num-bigint+quickcheck-devel \
 rust-num-bigint+rand-devel \
 rust-num-bigint+serde-devel \
 rust-num-bigint+std-devel \
 rust-num-bigint-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-bigint-0.4.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3229aa9696db7b0aa44cb4f0c712d29482e4e2c215b35acb3ec063d914f5f68b"

URI_x86_64_v2_rust-num-bigint+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+arbitrary-devel-0.4.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+arbitrary-devel.sha256sum] = "c89ab9ac951d14fb5430e64c22b013248e7672745ec204836e50422b35f813f8"

URI_x86_64_v2_rust-num-bigint+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+default-devel-0.4.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+default-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+default-devel.sha256sum] = "1d1e6e0a7a453f0333a7e8a62b350a6c5a342fbed325d97b45440371a88cc21a"

URI_x86_64_v2_rust-num-bigint+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+quickcheck-devel-0.4.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+quickcheck-devel.sha256sum] = "420f1314736c065e4e30f1607eab6e1c3ec72f7d47982bb16251b136b3ac3ce7"

URI_x86_64_v2_rust-num-bigint+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+rand-devel-0.4.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+rand-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+rand-devel.sha256sum] = "286647510741f72a6ec6b73a0346dac1cbaca4c1aa4bd069df588b75caa77b1a"

URI_x86_64_v2_rust-num-bigint+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+serde-devel-0.4.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+serde-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+serde-devel.sha256sum] = "98893bdef4022752cb7a482d0cd893d471434a2b809eb959d9cf444b6d3b91c0"

URI_x86_64_v2_rust-num-bigint+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+std-devel-0.4.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+std-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+std-devel.sha256sum] = "9b30e42135effff2be04870b2695bdec43a684f291e82628f46def137366ec37"

URI_x86_64_v2_rust-num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-devel-0.4.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-devel.sha256sum] = "7fa825651bac736eeb1173014a16d1ae1403639d306e224318acd0f6ddeb0513"

URI_aarch64_rust-num-bigint+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+arbitrary-devel-0.4.8-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+arbitrary-devel}"
SRC_URI[aarch64_rust-num-bigint+arbitrary-devel.sha256sum] = "093d9d3bd1c857d2b7a3e9c35bfdda7ef2e41866871b8da768a6d9d541347f3c"

URI_aarch64_rust-num-bigint+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+default-devel-0.4.8-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+default-devel}"
SRC_URI[aarch64_rust-num-bigint+default-devel.sha256sum] = "5bf61afa88bd3ae50f817cb1f4e93c5fd315192eda551ba0f842ddc9104e4bb0"

URI_aarch64_rust-num-bigint+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+quickcheck-devel-0.4.8-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+quickcheck-devel}"
SRC_URI[aarch64_rust-num-bigint+quickcheck-devel.sha256sum] = "069ffce5e07296745dfb70ffce350dd35a46c9812044b25405d5a5b480edd24f"

URI_aarch64_rust-num-bigint+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+rand-devel-0.4.8-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+rand-devel}"
SRC_URI[aarch64_rust-num-bigint+rand-devel.sha256sum] = "f34c5dc88fa2e6b4a55ca858307d008ec1fed71166f73c433321c6b4394e73bb"

URI_aarch64_rust-num-bigint+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+serde-devel-0.4.8-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+serde-devel}"
SRC_URI[aarch64_rust-num-bigint+serde-devel.sha256sum] = "7da51013904b80b4501fea495ea5e47c671efafd0f3dab26533d9faff484d849"

URI_aarch64_rust-num-bigint+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+std-devel-0.4.8-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+std-devel}"
SRC_URI[aarch64_rust-num-bigint+std-devel.sha256sum] = "61ff170d4beba2edffbc3933b869713b8673c8304711c8cd744c3b426ef75454"

URI_aarch64_rust-num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-devel-0.4.8-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-devel}"
SRC_URI[aarch64_rust-num-bigint-devel.sha256sum] = "3b237bc5fd337a80637d0e1fa28c4a6d3a054a860aada5f761f5826f2ea27408"

RDEPENDS:rust-num-bigint+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-num-bigint-devel \
 "
RDEPENDS:rust-num-bigint+default-devel = " \
 cargo \
 rust-num-bigint+std-devel \
 rust-num-bigint-devel \
 "
RDEPENDS:rust-num-bigint+quickcheck-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-num-bigint+rand-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-num-bigint+serde-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-num-bigint+std-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-num-integer+std-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-bigint-devel = " \
 cargo \
 rust \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
