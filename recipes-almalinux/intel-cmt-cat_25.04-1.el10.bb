# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-cmt-cat"
PV = "25.04"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 intel-cmt-cat \
 intel-cmt-cat-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/intel-cmt-cat-25.04-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6328ffa81434b802dcec21bbda4341594d5c5be2d2c5cce644947bd79594b5ae"

URI_x86_64_v2_intel-cmt-cat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-cmt-cat-25.04-1.el10.x86_64_v2.rpm;name=x86_64_v2_intel-cmt-cat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-cmt-cat}"
SRC_URI[x86_64_v2_intel-cmt-cat.sha256sum] = "4795e16882c7bf04dc6b7ff47a1cc151485ef8893f14c6d85223f370ab2f796e"

URI_x86_64_v2_intel-cmt-cat-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/intel-cmt-cat-devel-25.04-1.el10.x86_64_v2.rpm;name=x86_64_v2_intel-cmt-cat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-cmt-cat-devel}"
SRC_URI[x86_64_v2_intel-cmt-cat-devel.sha256sum] = "fff2563abbb18453d3142989575fb3f1da39781445f10301602ae3f2d275fb32"

RDEPENDS:intel-cmt-cat = " \
 bash \
 glibc \
 "
RDEPENDS:intel-cmt-cat-devel = " \
 intel-cmt-cat \
 "
