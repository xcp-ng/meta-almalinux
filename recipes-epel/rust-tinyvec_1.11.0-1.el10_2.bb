# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tinyvec"
PV = "1.11.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+arbitrary-devel \
 rust-tinyvec+default-devel \
 rust-tinyvec+experimental_write_impl-devel \
 rust-tinyvec+grab_spare_slice-devel \
 rust-tinyvec+nightly_slice_partition_dedup-devel \
 rust-tinyvec+rustc_1_40-devel \
 rust-tinyvec+rustc_1_55-devel \
 rust-tinyvec+rustc_1_57-devel \
 rust-tinyvec+rustc_1_61-devel \
 rust-tinyvec+serde-devel \
 rust-tinyvec+std-devel \
 rust-tinyvec+tinyvec_macros-devel \
 rust-tinyvec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tinyvec-1.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85f9bf1df3bb4153b5270d9881205d867ab5281d6c709bc3589d90a9b3a0f984"

URI_x86_64_v2_rust-tinyvec+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+alloc-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+alloc-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+alloc-devel.sha256sum] = "e0f0e9b6e63c2ef31e4e7b5458cb04ba67020f20727fe22b75a278c5ca5d28ee"

URI_x86_64_v2_rust-tinyvec+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+arbitrary-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+arbitrary-devel.sha256sum] = "cee5e40b1f461b154accd6f8a952dc41ddd82b201c012115142b5a953b8de86e"

URI_x86_64_v2_rust-tinyvec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+default-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+default-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+default-devel.sha256sum] = "86a9088f9cbf9d5650835e7e5c8794657ddbcfd2e4f997e22d46c73a33456c90"

URI_x86_64_v2_rust-tinyvec+experimental_write_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+experimental_write_impl-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+experimental_write_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+experimental_write_impl-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+experimental_write_impl-devel.sha256sum] = "97be0458e501bba7774c0cc64bb520daca4dc66d1d9285c811490751cfc0b5be"

URI_x86_64_v2_rust-tinyvec+grab_spare_slice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+grab_spare_slice-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+grab_spare_slice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+grab_spare_slice-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+grab_spare_slice-devel.sha256sum] = "44b959a1e5871ef1140761993cf99f214d6d9d34d00edbffca5b5316768124f2"

URI_x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+nightly_slice_partition_dedup-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel.sha256sum] = "f7e44c503a022d96c66616fd989407659eca99e1ce071a61a59116f098d6382f"

URI_x86_64_v2_rust-tinyvec+rustc_1_40-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_40-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_40-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_40-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_40-devel.sha256sum] = "dcfad44ac591b623648cfe8573a521fcd121bfb1a7a9121b7d964c4c2960eda9"

URI_x86_64_v2_rust-tinyvec+rustc_1_55-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_55-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_55-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_55-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_55-devel.sha256sum] = "25fa1f1c87d2c54ce732020d28ea66da6b0f03eb62043f11b060e14c5d57155a"

URI_x86_64_v2_rust-tinyvec+rustc_1_57-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_57-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_57-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_57-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_57-devel.sha256sum] = "540031f8260d7725eca9888ffaef748fc87bbad5b80161350e2f479e29934188"

URI_x86_64_v2_rust-tinyvec+rustc_1_61-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_61-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_61-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_61-devel.sha256sum] = "e892b7192a31996bbda138212ff7b3e0b9b6302f2c0cb96fd25663c0d49f9ebb"

URI_x86_64_v2_rust-tinyvec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+serde-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+serde-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+serde-devel.sha256sum] = "638e1eb41f60fcc9f789aa9d634f24f16dd86c7fb7887f738203a8e9c872b55c"

URI_x86_64_v2_rust-tinyvec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+std-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+std-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+std-devel.sha256sum] = "82d0dbccce30f61b0f6a8f4ba2e81b9888299c66cbca801ddd9462887509fb21"

URI_x86_64_v2_rust-tinyvec+tinyvec_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+tinyvec_macros-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+tinyvec_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+tinyvec_macros-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+tinyvec_macros-devel.sha256sum] = "e17effa512019a4540cf12168f5bae6ba63b2bb8cd63eaf4574c4871dcf5c47f"

URI_x86_64_v2_rust-tinyvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec-devel}"
SRC_URI[x86_64_v2_rust-tinyvec-devel.sha256sum] = "e4fe51a76bdd5e70b9681d97c6ee1e56a4d67095dbe7fb46583bab0e357b6b81"

URI_aarch64_rust-tinyvec+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+alloc-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+alloc-devel}"
SRC_URI[aarch64_rust-tinyvec+alloc-devel.sha256sum] = "c44e906b7351fe6863173e0623df069ebbd3852cd6af49e7466c9fad7955101e"

URI_aarch64_rust-tinyvec+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+arbitrary-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+arbitrary-devel}"
SRC_URI[aarch64_rust-tinyvec+arbitrary-devel.sha256sum] = "c8a445b8f9a2b848fdb061519fccc4e547bce9feeaf97eaa3595f37798f619d8"

URI_aarch64_rust-tinyvec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+default-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+default-devel}"
SRC_URI[aarch64_rust-tinyvec+default-devel.sha256sum] = "082697f6c8633f21b87326d13d3bae86954038989252f836bc5ebf8ff438b84b"

URI_aarch64_rust-tinyvec+experimental_write_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+experimental_write_impl-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec+experimental_write_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+experimental_write_impl-devel}"
SRC_URI[aarch64_rust-tinyvec+experimental_write_impl-devel.sha256sum] = "e93ba7056524f340c81ee00f33e0d73d9ca14ff2bea8faa36dcb85b744c5e9d2"

URI_aarch64_rust-tinyvec+grab_spare_slice-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+grab_spare_slice-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec+grab_spare_slice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+grab_spare_slice-devel}"
SRC_URI[aarch64_rust-tinyvec+grab_spare_slice-devel.sha256sum] = "d79486a69e326e0d40a955de4e234ed6e9ee1127efa3b9044f651386499f02eb"

URI_aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+nightly_slice_partition_dedup-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel}"
SRC_URI[aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel.sha256sum] = "0c7ff6bae716ced28e8a0287c47e3f83ba83c04615a0891641a10945ce147765"

URI_aarch64_rust-tinyvec+rustc_1_40-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_40-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_40-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_40-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_40-devel.sha256sum] = "7c2f05f92ebe1f98bc9c650609c19eeaf3f977847c16f7bede1b68c712f1c5ea"

URI_aarch64_rust-tinyvec+rustc_1_55-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_55-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_55-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_55-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_55-devel.sha256sum] = "1ee382a18940abe093b7a5af8883d24f42d3f94adb0ce530cfad05426fb504c3"

URI_aarch64_rust-tinyvec+rustc_1_57-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_57-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_57-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_57-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_57-devel.sha256sum] = "4d5c30f6db0da8b5d3eca0e83a70fedf099419b1909d4ae6200be6eb8adce3f1"

URI_aarch64_rust-tinyvec+rustc_1_61-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_61-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_61-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_61-devel.sha256sum] = "6fbc157cf38dcc3b440440cd1aae4464027e4e0aa4ac16810f2c75688eaa47ec"

URI_aarch64_rust-tinyvec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+serde-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+serde-devel}"
SRC_URI[aarch64_rust-tinyvec+serde-devel.sha256sum] = "c42b282709028e47a9632919c90145f5fb59765b107763dc62cc29ffcbf318c3"

URI_aarch64_rust-tinyvec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+std-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+std-devel}"
SRC_URI[aarch64_rust-tinyvec+std-devel.sha256sum] = "45428263ec91eb78d1296a38e1f8a8e3989ff7479b4a4d169fc1ca6e87ca2357"

URI_aarch64_rust-tinyvec+tinyvec_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+tinyvec_macros-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec+tinyvec_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+tinyvec_macros-devel}"
SRC_URI[aarch64_rust-tinyvec+tinyvec_macros-devel.sha256sum] = "53e3722fcfc024acf171b42e59bf3df6d44e18d81e996a43a00efbece8107e1c"

URI_aarch64_rust-tinyvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-tinyvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec-devel}"
SRC_URI[aarch64_rust-tinyvec-devel.sha256sum] = "e425596493eeb98ac4c94e01759f66a875fbd0932e47c7e6dba88c55534e7aaf"

RDEPENDS:rust-tinyvec+alloc-devel = " \
 cargo \
 rust-tinyvec+tinyvec_macros-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+default-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+experimental_write_impl-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+grab_spare_slice-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+nightly_slice_partition_dedup-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_40-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_55-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_57-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_61-devel = " \
 cargo \
 rust-tinyvec+rustc_1_57-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+std-devel = " \
 cargo \
 rust-tinyvec+alloc-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+tinyvec_macros-devel = " \
 cargo \
 rust-tinyvec-devel \
 rust-tinyvec_macros+default-devel \
 "
RDEPENDS:rust-tinyvec-devel = " \
 cargo \
 "
