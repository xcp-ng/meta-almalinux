# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "juk"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 juk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/juk-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f0d61fe14e55736670a314ee5f9a361d4f84941657efff4f6964ff1fbffafc3"

URI_x86_64_v2_juk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/juk-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_juk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_juk}"
SRC_URI[x86_64_v2_juk.sha256sum] = "9cb21e10b008ab295bf4bb545a6bc2337c3b4ff200d73365f659b4e9d0781d66"

URI_aarch64_juk = "${EPEL_MIRROR}/aarch64/Packages/j/juk-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_juk;unpack=0"
SRC_URI:append = " ${URI_aarch64_juk}"
SRC_URI[aarch64_juk.sha256sum] = "9b3332dfbea10521f970fba735fd49cd78166b14fcc0ff99c8bb7ee3b7378982"

RDEPENDS:juk = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 taglib \
 "
