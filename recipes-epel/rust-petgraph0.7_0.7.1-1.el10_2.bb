# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-petgraph0.7"
PV = "0.7.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-petgraph0.7+all-devel \
 rust-petgraph0.7+default-devel \
 rust-petgraph0.7+generate-devel \
 rust-petgraph0.7+graphmap-devel \
 rust-petgraph0.7+matrix_graph-devel \
 rust-petgraph0.7+rayon-devel \
 rust-petgraph0.7+serde-1-devel \
 rust-petgraph0.7+serde-devel \
 rust-petgraph0.7+serde_derive-devel \
 rust-petgraph0.7+stable_graph-devel \
 rust-petgraph0.7+unstable-devel \
 rust-petgraph0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-petgraph0.7-0.7.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3c2f3ba0a7739cbf2f2c7cc9dbb9644d4c28ce328510ecce2ccfed093d04d42"

URI_x86_64_v2_rust-petgraph0.7+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.7+all-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.7+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.7+all-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.7+all-devel.sha256sum] = "ae017ccf619450cf369fe9f185b31aacedf840da47ef771efe9fa8fee01c1b07"

URI_x86_64_v2_rust-petgraph0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.7+default-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.7+default-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.7+default-devel.sha256sum] = "e9d73b561bb1bb1cce7d66167075eb61f38b2c8d39890d508bcb615738185672"

URI_x86_64_v2_rust-petgraph0.7+generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.7+generate-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.7+generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.7+generate-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.7+generate-devel.sha256sum] = "c4f4f86f25b0dfb7c9d9dbfdd36f792a216d541a24f8550808a3a799b6530079"

URI_x86_64_v2_rust-petgraph0.7+graphmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.7+graphmap-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.7+graphmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.7+graphmap-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.7+graphmap-devel.sha256sum] = "96e0ebfd35744cb46a78d71f78a5d0e0a8b4b84466941b3dd03ad19e9f4607b6"

URI_x86_64_v2_rust-petgraph0.7+matrix_graph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.7+matrix_graph-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.7+matrix_graph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.7+matrix_graph-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.7+matrix_graph-devel.sha256sum] = "e584971e7695a4bb3d40ce59c9ebbe5c7f70c12f892c9dd09c4afa5ec6025f08"

URI_x86_64_v2_rust-petgraph0.7+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.7+rayon-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.7+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.7+rayon-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.7+rayon-devel.sha256sum] = "321297ce37d145f6483abcb171df3fb3b57c54c0f09230d0b8860a22d0eaeb7e"

URI_x86_64_v2_rust-petgraph0.7+serde-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.7+serde-1-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.7+serde-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.7+serde-1-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.7+serde-1-devel.sha256sum] = "9e057d075fc68b7fc1223fce46edfad2d0527391c21e8ba414dfc8b3b22fcd5e"

URI_x86_64_v2_rust-petgraph0.7+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.7+serde-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.7+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.7+serde-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.7+serde-devel.sha256sum] = "09002918f37191c13cd3152901747f0a577576596e80ed3c98b2bc58feb3e264"

URI_x86_64_v2_rust-petgraph0.7+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.7+serde_derive-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.7+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.7+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.7+serde_derive-devel.sha256sum] = "ce4cd5a20e0d5d65eabc3bd1c676fb02766e19febe4fb39e71590b46c8043c51"

URI_x86_64_v2_rust-petgraph0.7+stable_graph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.7+stable_graph-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.7+stable_graph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.7+stable_graph-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.7+stable_graph-devel.sha256sum] = "b881dd79e1b14732b8eb2ef322549fa9049dda7780f458d6521a9c2420948b93"

URI_x86_64_v2_rust-petgraph0.7+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.7+unstable-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.7+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.7+unstable-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.7+unstable-devel.sha256sum] = "2eff31d66248cbb6e7062e65d8ad9b7f7f63cc29300cad9a3e33fd62d8501fb8"

URI_x86_64_v2_rust-petgraph0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.7-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.7-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.7-devel.sha256sum] = "9d5e2e93c65eff94eeb59456cd7c4f46329dd2feb8a87fa2bf6024304911c6d5"

URI_aarch64_rust-petgraph0.7+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.7+all-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph0.7+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.7+all-devel}"
SRC_URI[aarch64_rust-petgraph0.7+all-devel.sha256sum] = "19308516ba0e2b04b983329213fb8760ccd75dfebdc7c722068e75ed70570c45"

URI_aarch64_rust-petgraph0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.7+default-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.7+default-devel}"
SRC_URI[aarch64_rust-petgraph0.7+default-devel.sha256sum] = "2240872c9f91a54bb02578ea527ae23bf11f875e5653680705f5a2952524b6e0"

URI_aarch64_rust-petgraph0.7+generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.7+generate-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph0.7+generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.7+generate-devel}"
SRC_URI[aarch64_rust-petgraph0.7+generate-devel.sha256sum] = "30b0e2ae6fef7cbdb8b1157a3a8528267d2c56b961c2842b65bce575ab035acd"

URI_aarch64_rust-petgraph0.7+graphmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.7+graphmap-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph0.7+graphmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.7+graphmap-devel}"
SRC_URI[aarch64_rust-petgraph0.7+graphmap-devel.sha256sum] = "5c8f28f798165cb776ab5a21de04937bce5295bcd1312b298702659111a70b14"

URI_aarch64_rust-petgraph0.7+matrix_graph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.7+matrix_graph-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph0.7+matrix_graph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.7+matrix_graph-devel}"
SRC_URI[aarch64_rust-petgraph0.7+matrix_graph-devel.sha256sum] = "1b14b9db914ad134818b3b533f1ee664b8afb23f30bb2fcf2e52dd773eced364"

URI_aarch64_rust-petgraph0.7+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.7+rayon-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph0.7+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.7+rayon-devel}"
SRC_URI[aarch64_rust-petgraph0.7+rayon-devel.sha256sum] = "f293aa3f28bbe229bea5311282976a7543c1de14b97beb81591cd59c605cc8cf"

URI_aarch64_rust-petgraph0.7+serde-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.7+serde-1-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph0.7+serde-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.7+serde-1-devel}"
SRC_URI[aarch64_rust-petgraph0.7+serde-1-devel.sha256sum] = "e61d74682304ec6b46c925061c9fbd4a918b71092ab2016fb48892194c3162d7"

URI_aarch64_rust-petgraph0.7+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.7+serde-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph0.7+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.7+serde-devel}"
SRC_URI[aarch64_rust-petgraph0.7+serde-devel.sha256sum] = "0660b1ca54e22b18f2548f002e45f5279d83f870dc258f3ca235b1ed18dff6a4"

URI_aarch64_rust-petgraph0.7+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.7+serde_derive-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph0.7+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.7+serde_derive-devel}"
SRC_URI[aarch64_rust-petgraph0.7+serde_derive-devel.sha256sum] = "2372bbf6b76f0d0e25fcd90ecf3615f6b480c7b223691abbccd811fc640411c4"

URI_aarch64_rust-petgraph0.7+stable_graph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.7+stable_graph-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph0.7+stable_graph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.7+stable_graph-devel}"
SRC_URI[aarch64_rust-petgraph0.7+stable_graph-devel.sha256sum] = "eba7b22a44c94601b8b5f2094d9108c554babab4ceddb56696628659ffb6114c"

URI_aarch64_rust-petgraph0.7+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.7+unstable-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph0.7+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.7+unstable-devel}"
SRC_URI[aarch64_rust-petgraph0.7+unstable-devel.sha256sum] = "f64667028523e6969b53e21bb5ae1bce123156c43dd1ac2682619511bc5ddec5"

URI_aarch64_rust-petgraph0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.7-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.7-devel}"
SRC_URI[aarch64_rust-petgraph0.7-devel.sha256sum] = "b1461333e7eda4feebe07b65e6c970dcb3524e5ebbe68344dcbf37553017e036"

RDEPENDS:rust-petgraph0.7+all-devel = " \
 cargo \
 rust-petgraph0.7+graphmap-devel \
 rust-petgraph0.7+matrix_graph-devel \
 rust-petgraph0.7+rayon-devel \
 rust-petgraph0.7+stable_graph-devel \
 rust-petgraph0.7+unstable-devel \
 rust-petgraph0.7-devel \
 "
RDEPENDS:rust-petgraph0.7+default-devel = " \
 cargo \
 rust-petgraph0.7+graphmap-devel \
 rust-petgraph0.7+matrix_graph-devel \
 rust-petgraph0.7+stable_graph-devel \
 rust-petgraph0.7-devel \
 "
RDEPENDS:rust-petgraph0.7+generate-devel = " \
 cargo \
 rust-petgraph0.7-devel \
 "
RDEPENDS:rust-petgraph0.7+graphmap-devel = " \
 cargo \
 rust-petgraph0.7-devel \
 "
RDEPENDS:rust-petgraph0.7+matrix_graph-devel = " \
 cargo \
 rust-petgraph0.7-devel \
 "
RDEPENDS:rust-petgraph0.7+rayon-devel = " \
 cargo \
 rust-indexmap+rayon-devel \
 rust-petgraph0.7-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-petgraph0.7+serde-1-devel = " \
 cargo \
 rust-petgraph0.7+serde-devel \
 rust-petgraph0.7+serde_derive-devel \
 rust-petgraph0.7-devel \
 "
RDEPENDS:rust-petgraph0.7+serde-devel = " \
 cargo \
 rust-petgraph0.7-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-petgraph0.7+serde_derive-devel = " \
 cargo \
 rust-petgraph0.7-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-petgraph0.7+stable_graph-devel = " \
 cargo \
 rust-petgraph0.7-devel \
 "
RDEPENDS:rust-petgraph0.7+unstable-devel = " \
 cargo \
 rust-petgraph0.7+generate-devel \
 rust-petgraph0.7-devel \
 "
RDEPENDS:rust-petgraph0.7-devel = " \
 cargo \
 rust \
 rust-fixedbitset-devel \
 rust-indexmap+default-devel \
 "
