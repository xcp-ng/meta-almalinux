# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libinput"
PV = "1.26.1"
PR = "5.el10_0"
PACKAGES = " \
 libinput \
 libinput-devel \
 libinput-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libinput-1.26.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bfe1110abbba44725c5c6f3d5f5efd1b7c3fc9e93bead04dbb0e40f84726fb2"

URI_x86_64_v2_libinput = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libinput-1.26.1-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_libinput;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libinput}"
SRC_URI[x86_64_v2_libinput.sha256sum] = "841a3b0e729f5ae1c460c86bdaa6e2fde6d6f82f552390842241e7a7f3a9145d"

URI_x86_64_v2_libinput-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libinput-devel-1.26.1-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_libinput-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libinput-devel}"
SRC_URI[x86_64_v2_libinput-devel.sha256sum] = "7256b409823a57d271d0823bb3cd1f1f2c74d0c86c815a4fb40307eb43ff2e3f"

URI_x86_64_v2_libinput-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libinput-utils-1.26.1-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_libinput-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libinput-utils}"
SRC_URI[x86_64_v2_libinput-utils.sha256sum] = "54c1b012b371cfdc0c49d7fc626a0045c6c8de967071346455129e93b72b2510"

URI_aarch64_libinput = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libinput-1.26.1-5.el10_0.aarch64.rpm;name=aarch64_libinput;unpack=0"
SRC_URI:append = " ${URI_aarch64_libinput}"
SRC_URI[aarch64_libinput.sha256sum] = "bac12932847b5a62f1020b28caa1e5ed90a1ff7998f1df4174925c3840b92b07"

URI_aarch64_libinput-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libinput-devel-1.26.1-5.el10_0.aarch64.rpm;name=aarch64_libinput-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libinput-devel}"
SRC_URI[aarch64_libinput-devel.sha256sum] = "2cbf3797ffa3bcfb5d84858d29b76c8c5d939e9fcb40cfcdb64658b557a62629"

URI_aarch64_libinput-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libinput-utils-1.26.1-5.el10_0.aarch64.rpm;name=aarch64_libinput-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libinput-utils}"
SRC_URI[aarch64_libinput-utils.sha256sum] = "9feaea0fe61367737d62eb80d92d437c8a91b122cd079842b615cdc98fe0c3b5"

RDEPENDS:libinput = " \
 bash \
 glibc \
 libevdev \
 libwacom \
 mtdev \
 systemd-libs \
 "
RDEPENDS:libinput-devel = " \
 libinput \
 pkgconf-pkg-config \
 "
RDEPENDS:libinput-utils = " \
 glibc \
 libevdev \
 libinput \
 python3 \
 python3-libevdev \
 python3-pyudev \
 systemd-libs \
 "
