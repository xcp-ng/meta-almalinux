# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_core"
PV = "1.0.228"
PR = "1.el10_1"
PACKAGES = " \
 rust-serde_core+alloc-devel \
 rust-serde_core+default-devel \
 rust-serde_core+rc-devel \
 rust-serde_core+result-devel \
 rust-serde_core+std-devel \
 rust-serde_core+unstable-devel \
 rust-serde_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_core-1.0.228-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87fc1f15378bb4eb63874beee120ffb4391199b742a08a37b3842b99a0f036b6"

URI_x86_64_v2_rust-serde_core+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+alloc-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_core+alloc-devel.sha256sum] = "ab31ea8e8a99f88f825f255169c43b42d01ea70293d4acad65f5f8cb45a70f2b"

URI_x86_64_v2_rust-serde_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+default-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+default-devel}"
SRC_URI[x86_64_v2_rust-serde_core+default-devel.sha256sum] = "c81aea043683228a640419ad501d061c58f2f054700912275fed57fde93775e2"

URI_x86_64_v2_rust-serde_core+rc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+rc-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+rc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+rc-devel}"
SRC_URI[x86_64_v2_rust-serde_core+rc-devel.sha256sum] = "e45f628e729a5050a3eedc09e1bf60d9930699a440f95c1455f211137bc8febe"

URI_x86_64_v2_rust-serde_core+result-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+result-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+result-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+result-devel}"
SRC_URI[x86_64_v2_rust-serde_core+result-devel.sha256sum] = "7167609eddac62df9bcda03bc156f8d6ea3606a9b9bf077a7ae4ffd3bcdf014f"

URI_x86_64_v2_rust-serde_core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+std-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+std-devel}"
SRC_URI[x86_64_v2_rust-serde_core+std-devel.sha256sum] = "8622396068b2fff753713f5227fa23c8593f38d7aed21585c33ae7490d76201c"

URI_x86_64_v2_rust-serde_core+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+unstable-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+unstable-devel}"
SRC_URI[x86_64_v2_rust-serde_core+unstable-devel.sha256sum] = "a09c8d9adbdd18085264db2ea6c09f1a89eb826c57fdd76d039f5728f854f733"

URI_x86_64_v2_rust-serde_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core-devel}"
SRC_URI[x86_64_v2_rust-serde_core-devel.sha256sum] = "8eedbb42fe12a8104122946182b1b96065e432e09e8f56e1ba8d51c2a8b4ae57"

URI_aarch64_rust-serde_core+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+alloc-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+alloc-devel}"
SRC_URI[aarch64_rust-serde_core+alloc-devel.sha256sum] = "31ccfd8a2726a49fd79392d4a32476c7f5c87665df2044b9a78167b3aa1acbcb"

URI_aarch64_rust-serde_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+default-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+default-devel}"
SRC_URI[aarch64_rust-serde_core+default-devel.sha256sum] = "c4e3a055cfb8ffe8fe20ee3427aac8cc4fba77b42feb16ade345d79163b881d2"

URI_aarch64_rust-serde_core+rc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+rc-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde_core+rc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+rc-devel}"
SRC_URI[aarch64_rust-serde_core+rc-devel.sha256sum] = "e4733c69a29f332b237294d51700058b2d1dc351c88e583dc8fecb8cf50929bf"

URI_aarch64_rust-serde_core+result-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+result-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde_core+result-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+result-devel}"
SRC_URI[aarch64_rust-serde_core+result-devel.sha256sum] = "cbe6ffa783308e16dbb97b30a7e971d8c80d2227c7e1a593e0f3d146a4c570f2"

URI_aarch64_rust-serde_core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+std-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde_core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+std-devel}"
SRC_URI[aarch64_rust-serde_core+std-devel.sha256sum] = "76ed6a76ffcf83a7c76bf0b355718999f68124d34187a5371cd89f7d7d7a1117"

URI_aarch64_rust-serde_core+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+unstable-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde_core+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+unstable-devel}"
SRC_URI[aarch64_rust-serde_core+unstable-devel.sha256sum] = "1c806f9169424088a5171275714238ba123792e886f8f28fd22e63c1da858f59"

URI_aarch64_rust-serde_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core-devel}"
SRC_URI[aarch64_rust-serde_core-devel.sha256sum] = "b4e4f888967be9a8e93511bcc5ffc7d8ac1de4338cf2109c3dcacc7ebb74ebfa"

RDEPENDS:rust-serde_core+alloc-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+default-devel = " \
 cargo \
 rust-serde_core+result-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+rc-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+result-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+std-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+unstable-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core-devel = " \
 cargo \
 rust \
 rust-serde_derive+default-devel \
 "
