# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-simple_asn1"
PV = "0.6.3"
PR = "2.el10_1"
PACKAGES = " \
 rust-simple_asn1+default-devel \
 rust-simple_asn1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-simple_asn1-0.6.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7872f9475e50201c4bdd580b87bb8dd94f8c3d8f32de9d1ed355a33ed2d97166"

URI_x86_64_v2_rust-simple_asn1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_asn1+default-devel-0.6.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_asn1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_asn1+default-devel}"
SRC_URI[x86_64_v2_rust-simple_asn1+default-devel.sha256sum] = "a5658a367cd9fdb4cd8f5e2d3bf677b1b55e4c12ef1064fd98eff3e8878494f3"

URI_x86_64_v2_rust-simple_asn1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_asn1-devel-0.6.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_asn1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_asn1-devel}"
SRC_URI[x86_64_v2_rust-simple_asn1-devel.sha256sum] = "e88a38405f49c5254b24f1c7b421a22a58c866c129aaa24de6951434c328e73e"

URI_aarch64_rust-simple_asn1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_asn1+default-devel-0.6.3-2.el10_1.noarch.rpm;name=aarch64_rust-simple_asn1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_asn1+default-devel}"
SRC_URI[aarch64_rust-simple_asn1+default-devel.sha256sum] = "8dd47003fdb40d80e796846ba9a4f7bbcfd27927386f9c4059d40b561c470a4c"

URI_aarch64_rust-simple_asn1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_asn1-devel-0.6.3-2.el10_1.noarch.rpm;name=aarch64_rust-simple_asn1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_asn1-devel}"
SRC_URI[aarch64_rust-simple_asn1-devel.sha256sum] = "6ee691e6c9f4c10634b7628ee1146f70aa38ef827bddf1bae902d42c1a9b8d4f"

RDEPENDS:rust-simple_asn1+default-devel = " \
 cargo \
 rust-simple_asn1-devel \
 "
RDEPENDS:rust-simple_asn1-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-num-traits-devel \
 rust-thiserror-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 rust-time-devel \
 "
