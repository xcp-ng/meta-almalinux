# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spatialindex"
PV = "2.1.0"
PR = "4.el10_2"
PACKAGES = " \
 spatialindex \
 spatialindex-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/spatialindex-2.1.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a3c7cfb70744ba0b5fbe08bf5c1b15c74e148200ae1dde6c88e118d76b99d0d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spatialindex-2.1.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spatialindex;unpack=0"
SRC_URI[x86_64_v2_spatialindex.sha256sum] = "9aa08f4eb2f2412c723d12eacc86666e25fbf0614cf34e1053f893278d46314d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spatialindex-devel-2.1.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spatialindex-devel;unpack=0"
SRC_URI[x86_64_v2_spatialindex-devel.sha256sum] = "ff660c77fc80e9d11244cb9b6493be6e94aba303681d7ac924f505599a34a2cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/spatialindex-2.1.0-4.el10_2.aarch64.rpm;name=aarch64_spatialindex;unpack=0"
SRC_URI[aarch64_spatialindex.sha256sum] = "3249e3a4274c996f99ffb36209ef61fe5146aef4b8df89526a97fcde1cf1f499"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/spatialindex-devel-2.1.0-4.el10_2.aarch64.rpm;name=aarch64_spatialindex-devel;unpack=0"
SRC_URI[aarch64_spatialindex-devel.sha256sum] = "663a008f2ff919f854922feb154d5809fa82bb22826b5e4dd39b90081fc25b6c"

RDEPENDS:spatialindex = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:spatialindex-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 spatialindex \
 "
