# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-YAML-Syck"
PV = "1.47"
PR = "1.el10_2"
PACKAGES = " \
 perl-YAML-Syck \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-YAML-Syck-1.47-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d20fa8509072ff8cb1828160a63b91013438c0e95d9ee16f157b283caf1cbeba"

URI_x86_64_v2_perl-YAML-Syck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-YAML-Syck-1.47-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-YAML-Syck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-YAML-Syck}"
SRC_URI[x86_64_v2_perl-YAML-Syck.sha256sum] = "aa2deee8a86891020605cd66718d5a591ef6307830f762cebe333a5c721e6a4d"

URI_aarch64_perl-YAML-Syck = "${EPEL_MIRROR}/aarch64/Packages/p/perl-YAML-Syck-1.47-1.el10_2.aarch64.rpm;name=aarch64_perl-YAML-Syck;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-YAML-Syck}"
SRC_URI[aarch64_perl-YAML-Syck.sha256sum] = "ba975a2bff83173f3de012b3afb7d724d94330bca8b97946ea4b2eab6a9bcb1e"

RDEPENDS:perl-YAML-Syck = " \
 glibc \
 perl-Exporter \
 perl-YAML-Syck \
 perl-constant \
 perl-libs \
 "
