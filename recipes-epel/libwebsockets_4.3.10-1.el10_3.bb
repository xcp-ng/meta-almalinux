# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libwebsockets"
PV = "4.3.10"
PR = "1.el10_3"
PACKAGES = " \
 libwebsockets \
 libwebsockets-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libwebsockets-4.3.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b140c4437f928501df7718983de7b3b9e8821bddda5adfd48d919ca7e0bf99e5"

URI_x86_64_v2_libwebsockets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwebsockets-4.3.10-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwebsockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwebsockets}"
SRC_URI[x86_64_v2_libwebsockets.sha256sum] = "9f3e175472dc01f35287161cb7e5a6473c57c8f7bbd98556253647bb3374d8e3"

URI_x86_64_v2_libwebsockets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwebsockets-devel-4.3.10-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwebsockets-devel}"
SRC_URI[x86_64_v2_libwebsockets-devel.sha256sum] = "1eb82317e4c68a4a0f9cf7d1da4763253d122af02a08fa6fb4a8dbb39d3f0951"

URI_aarch64_libwebsockets = "${EPEL_MIRROR}/aarch64/Packages/l/libwebsockets-4.3.10-1.el10_3.aarch64.rpm;name=aarch64_libwebsockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwebsockets}"
SRC_URI[aarch64_libwebsockets.sha256sum] = "9ce460ffbe8151a5e6b86624ef2bbc8df4762668b995f76ba638d92b3103fe37"

URI_aarch64_libwebsockets-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libwebsockets-devel-4.3.10-1.el10_3.aarch64.rpm;name=aarch64_libwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwebsockets-devel}"
SRC_URI[aarch64_libwebsockets-devel.sha256sum] = "820442cd9580af3e78912e6a14ce6fc66437d527d5245c5844a6c59765a7eebf"

RDEPENDS:libwebsockets = " \
 glib2 \
 glibc \
 libev \
 libuv \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libwebsockets-devel = " \
 cmake-filesystem \
 libev-devel \
 libuv-devel \
 libwebsockets \
 openssl-devel \
 pkgconf-pkg-config \
 "
