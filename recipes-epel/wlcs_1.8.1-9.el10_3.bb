# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wlcs"
PV = "1.8.1"
PR = "9.el10_3"
PACKAGES = " \
 wlcs \
 wlcs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wlcs-1.8.1-9.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5235caa831763560a9c06e54d1aaef4f1e75d6d8269312127ba6591b4007ae76"

URI_x86_64_v2_wlcs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wlcs-1.8.1-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wlcs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wlcs}"
SRC_URI[x86_64_v2_wlcs.sha256sum] = "24f4a1e5b7b21d232a818e38c91ed410aed5abb408bc2c23f1d28ac86d75a645"

URI_x86_64_v2_wlcs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wlcs-devel-1.8.1-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wlcs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wlcs-devel}"
SRC_URI[x86_64_v2_wlcs-devel.sha256sum] = "0d3521794186c6e82d4cce90e460a75a1a1dde56bf619492fd844a57d0615323"

URI_aarch64_wlcs = "${EPEL_MIRROR}/aarch64/Packages/w/wlcs-1.8.1-9.el10_3.aarch64.rpm;name=aarch64_wlcs;unpack=0"
SRC_URI:append = " ${URI_aarch64_wlcs}"
SRC_URI[aarch64_wlcs.sha256sum] = "a6a7674f70dd49b5082a11f207b0ae7dac5c32e8c5638959112fbcb425ddb29f"

URI_aarch64_wlcs-devel = "${EPEL_MIRROR}/aarch64/Packages/w/wlcs-devel-1.8.1-9.el10_3.aarch64.rpm;name=aarch64_wlcs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wlcs-devel}"
SRC_URI[aarch64_wlcs-devel.sha256sum] = "da93efacfba2a1a2141ff0d2bdf3eefaed9c19f7a1d89914aec6e6e529ee240c"

RDEPENDS:wlcs = " \
 glibc \
 gmock \
 gtest \
 libasan \
 libgcc \
 libstdc++ \
 libtsan \
 libubsan \
 libwayland-client \
 libwayland-server \
 "
RDEPENDS:wlcs-devel = " \
 pkgconf-pkg-config \
 wayland-devel \
 wlcs \
 "
