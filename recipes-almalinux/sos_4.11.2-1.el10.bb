# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sos"
PV = "4.11.2"
PR = "1.el10"
PACKAGES = " \
 sos \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sos-4.11.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a6b06b7844f60173681fba705356452dbe9afe2f05538153824927076421cd0"

URI_x86_64_v2_sos = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sos-4.11.2-1.el10.noarch.rpm;name=x86_64_v2_sos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sos}"
SRC_URI[x86_64_v2_sos.sha256sum] = "3aba4b6a445a72884c0099db74c17b1ab50359420aaaab181f86409603bfa62f"

URI_aarch64_sos = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sos-4.11.2-1.el10.noarch.rpm;name=aarch64_sos;unpack=0"
SRC_URI:append = " ${URI_aarch64_sos}"
SRC_URI[aarch64_sos.sha256sum] = "3aba4b6a445a72884c0099db74c17b1ab50359420aaaab181f86409603bfa62f"

RDEPENDS:sos = " \
 python3 \
 python3-packaging \
 python3-pexpect \
 python3-pyyaml \
 python3-requests \
 python3-setuptools \
 "
