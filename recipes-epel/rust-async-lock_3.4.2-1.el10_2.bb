# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-lock"
PV = "3.4.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-async-lock+default-devel \
 rust-async-lock+std-devel \
 rust-async-lock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-lock-3.4.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d335c24a90e664e9107e8dae1ff2b1e2499db97e987900a1fa666a4461bf1581"

URI_x86_64_v2_rust-async-lock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-lock+default-devel-3.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-lock+default-devel}"
SRC_URI[x86_64_v2_rust-async-lock+default-devel.sha256sum] = "e14d98dff2acd1d777db681e9154c39e6b7151c19d91dc1118439110407185df"

URI_x86_64_v2_rust-async-lock+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-lock+std-devel-3.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-lock+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-lock+std-devel}"
SRC_URI[x86_64_v2_rust-async-lock+std-devel.sha256sum] = "710d01b2a070f86637474903ff99ede53045e1b5f47900131950082765e6f5b4"

URI_x86_64_v2_rust-async-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-lock-devel-3.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-lock-devel}"
SRC_URI[x86_64_v2_rust-async-lock-devel.sha256sum] = "0d2149da92d1247e31b59d161896336ed5e6cfc00892b38f8db20d70daf2d205"

URI_aarch64_rust-async-lock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-lock+default-devel-3.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-async-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-lock+default-devel}"
SRC_URI[aarch64_rust-async-lock+default-devel.sha256sum] = "6a45874a60f7763715e6e7f015d37d1e88f6f812ee73c663316e89634b5c78dd"

URI_aarch64_rust-async-lock+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-lock+std-devel-3.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-async-lock+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-lock+std-devel}"
SRC_URI[aarch64_rust-async-lock+std-devel.sha256sum] = "801740759c74e091a6224deaed18dfb49a6d4003425429c4d4cbf6717d1bf7e1"

URI_aarch64_rust-async-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-lock-devel-3.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-lock-devel}"
SRC_URI[aarch64_rust-async-lock-devel.sha256sum] = "b7bf961923e4e281c622e8e505ac4416a098b4b683f08944adb70748b10fc157"

RDEPENDS:rust-async-lock+default-devel = " \
 cargo \
 rust-async-lock+std-devel \
 rust-async-lock-devel \
 "
RDEPENDS:rust-async-lock+std-devel = " \
 cargo \
 rust-async-lock-devel \
 rust-event-listener+std-devel \
 rust-event-listener-strategy+std-devel \
 "
RDEPENDS:rust-async-lock-devel = " \
 cargo \
 rust \
 rust-event-listener-devel \
 rust-event-listener-strategy-devel \
 rust-pin-project-lite+default-devel \
 "
