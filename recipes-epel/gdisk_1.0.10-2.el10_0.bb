# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdisk"
PV = "1.0.10"
PR = "2.el10_0"
PACKAGES = " \
 gdisk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gdisk-1.0.10-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c59a16f0c04ae229bce06cd8f033b51e6d600c35eba46265672d016f14c169a4"

URI_x86_64_v2_gdisk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdisk-1.0.10-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdisk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdisk}"
SRC_URI[x86_64_v2_gdisk.sha256sum] = "12c76da501853a0068539fa3a2116285bee638c50f708a22fa3c843d1c515095"

URI_aarch64_gdisk = "${EPEL_MIRROR}/aarch64/Packages/g/gdisk-1.0.10-2.el10_0.aarch64.rpm;name=aarch64_gdisk;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdisk}"
SRC_URI[aarch64_gdisk.sha256sum] = "c8e716b8957663dc6d9f303bfd12c157baafb7e71b31e0cbf4dec5acbfabcdb8"

RDEPENDS:gdisk = " \
 glibc \
 libgcc \
 libstdc++ \
 libuuid \
 ncurses-libs \
 popt \
 "
