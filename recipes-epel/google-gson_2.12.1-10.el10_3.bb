# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-gson"
PV = "2.12.1"
PR = "10.el10_3"
PACKAGES = " \
 google-gson \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/google-gson-2.12.1-10.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "049b38ab38e19146a3899c5a40f52b207b6622ff92057245caf0cbc79326f892"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-gson-2.12.1-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_google-gson;unpack=0"
SRC_URI[x86_64_v2_google-gson.sha256sum] = "d495dfc27c7da209d63c96674d4334d2e965e759bbfa80a138a6adf5d184daf1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/google-gson-2.12.1-10.el10_3.noarch.rpm;name=aarch64_google-gson;unpack=0"
SRC_URI[aarch64_google-gson.sha256sum] = "df212e110d85f3425d3f1a02f7148cc7f24f9986bf66ef228882e1884df5bda6"

RDEPENDS:google-gson = " \
 jakarta-annotations \
 javapackages-filesystem \
 "
