# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yara-epel"
PV = "4.5.2"
PR = "2.el10_0"
PACKAGES = " \
 yara-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yara-epel-4.5.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74a0f86460c57a23881e04e94d6625e784d3bcb13c6f58e7fe9d85a6e2809e62"

URI_x86_64_v2_yara-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yara-devel-4.5.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yara-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yara-devel}"
SRC_URI[x86_64_v2_yara-devel.sha256sum] = "4d33148fefe518f625e9d9f62dbe79476e8aeb0f159725cca4c7051c5b01639d"

URI_aarch64_yara-devel = "${EPEL_MIRROR}/aarch64/Packages/y/yara-devel-4.5.2-2.el10_0.aarch64.rpm;name=aarch64_yara-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yara-devel}"
SRC_URI[aarch64_yara-devel.sha256sum] = "1d02d56df61fd91d99f408cfa9c1320e5cc5cf7663b1468f8f736817bdb38fe3"

RDEPENDS:yara-devel = " \
 jansson-devel \
 openssl-devel \
 pkgconf-pkg-config \
 protobuf-c-devel \
 yara \
 "
