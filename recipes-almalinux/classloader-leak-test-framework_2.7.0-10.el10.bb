# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "classloader-leak-test-framework"
PV = "2.7.0"
PR = "10.el10"
PACKAGES = " \
 classloader-leak-test-framework \
 classloader-leak-test-framework-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/classloader-leak-test-framework-2.7.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae5d9ffc34b67da72acc44cceb8c9b220b03a2b6d22e4b680cf587e522541fc0"

URI_x86_64_v2_classloader-leak-test-framework = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/classloader-leak-test-framework-2.7.0-10.el10.noarch.rpm;name=x86_64_v2_classloader-leak-test-framework;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_classloader-leak-test-framework}"
SRC_URI[x86_64_v2_classloader-leak-test-framework.sha256sum] = "9f752d09f62ff44d850b19dd6b4cace25b0306f84a2f4a4fb34f8bdb603c7fbf"

URI_x86_64_v2_classloader-leak-test-framework-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/classloader-leak-test-framework-javadoc-2.7.0-10.el10.noarch.rpm;name=x86_64_v2_classloader-leak-test-framework-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_classloader-leak-test-framework-javadoc}"
SRC_URI[x86_64_v2_classloader-leak-test-framework-javadoc.sha256sum] = "667d73373dca44a8f0bfaf2152c02e21cecff62b800b1623b8505fab91315c52"

URI_aarch64_classloader-leak-test-framework = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/classloader-leak-test-framework-2.7.0-10.el10.noarch.rpm;name=aarch64_classloader-leak-test-framework;unpack=0"
SRC_URI:append = " ${URI_aarch64_classloader-leak-test-framework}"
SRC_URI[aarch64_classloader-leak-test-framework.sha256sum] = "9f752d09f62ff44d850b19dd6b4cace25b0306f84a2f4a4fb34f8bdb603c7fbf"

URI_aarch64_classloader-leak-test-framework-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/classloader-leak-test-framework-javadoc-2.7.0-10.el10.noarch.rpm;name=aarch64_classloader-leak-test-framework-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_classloader-leak-test-framework-javadoc}"
SRC_URI[aarch64_classloader-leak-test-framework-javadoc.sha256sum] = "667d73373dca44a8f0bfaf2152c02e21cecff62b800b1623b8505fab91315c52"

RDEPENDS:classloader-leak-test-framework = " \
 bcel \
 javapackages-filesystem \
 junit \
 "
RDEPENDS:classloader-leak-test-framework-javadoc = " \
 javapackages-filesystem \
 "
