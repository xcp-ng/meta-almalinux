# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-conda-sphinx-theme"
PV = "0.3.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-conda-sphinx-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-conda-sphinx-theme-0.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60a3a2ea8129d52808a625f9f46e73c676ec112b5ac35b760bf71ce374c596d8"

URI_x86_64_v2_python3-conda-sphinx-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-conda-sphinx-theme-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-conda-sphinx-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-conda-sphinx-theme}"
SRC_URI[x86_64_v2_python3-conda-sphinx-theme.sha256sum] = "adbfb79620515c7c3462b016eeb72156fe695269e6b862409cf5950783afc60e"

URI_aarch64_python3-conda-sphinx-theme = "${EPEL_MIRROR}/aarch64/Packages/p/python3-conda-sphinx-theme-0.3.0-1.el10_2.noarch.rpm;name=aarch64_python3-conda-sphinx-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-conda-sphinx-theme}"
SRC_URI[aarch64_python3-conda-sphinx-theme.sha256sum] = "b4f22cc5337544f3787eb54dc1f7ad6f0feb37f36617cb9720456ebd5b4c3838"

RDEPENDS:python3-conda-sphinx-theme = " \
 python3 \
 python3-pydata-sphinx-theme \
 python3-sphinx-favicon \
 "
