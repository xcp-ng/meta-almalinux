# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kleopatra"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kleopatra \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kleopatra-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "669974bbaad353b72f715f47135010bf3f74bc24987ef9c79d08e0568b333409"

URI_x86_64_v2_kleopatra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kleopatra-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kleopatra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kleopatra}"
SRC_URI[x86_64_v2_kleopatra.sha256sum] = "afb7917232723a24864729c953d47a0a94c0e606eca6698c3bc29ec1479fce7e"

URI_aarch64_kleopatra = "${EPEL_MIRROR}/aarch64/Packages/k/kleopatra-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kleopatra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kleopatra}"
SRC_URI[aarch64_kleopatra.sha256sum] = "69f2c515814f4250f9185d9a78702c67eaeb92803bd153a529bada73d4ec5c04"

RDEPENDS:kleopatra = " \
 akonadi-mime \
 glibc \
 gnupg2 \
 gnupg2-smime \
 gpgmepp \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libassuan \
 libgcc \
 libgpg-error \
 libkleo \
 libstdc++ \
 mimetreeparser \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
