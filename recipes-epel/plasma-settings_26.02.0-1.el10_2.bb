# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-settings"
PV = "26.02.0"
PR = "1.el10_2"
PACKAGES = " \
 plasma-settings \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-settings-26.02.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ee0197838ec90555575b338702239bb0802c14d103135c63faaa4c4f3db0fb6"

URI_x86_64_v2_plasma-settings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-settings-26.02.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-settings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-settings}"
SRC_URI[x86_64_v2_plasma-settings.sha256sum] = "4b2b153688706bd42049c836bafb8b81a317a70ffc5136d349a483d79c161769"

URI_aarch64_plasma-settings = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-settings-26.02.0-1.el10_2.aarch64.rpm;name=aarch64_plasma-settings;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-settings}"
SRC_URI[aarch64_plasma-settings.sha256sum] = "72637384ad25d6f9e798bd5edc632a9fd1c7a8d7021af45aac992db068c2bd3a"

RDEPENDS:plasma-settings = " \
 accountsservice \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kservice \
 libstdc++ \
 polkit-kde \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 sound-theme-freedesktop \
 "
