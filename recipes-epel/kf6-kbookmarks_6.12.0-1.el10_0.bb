# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kbookmarks"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kbookmarks \
 kf6-kbookmarks-devel \
 kf6-kbookmarks-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kbookmarks-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79a95b556be94937d3bfa2eb80586c289e076b052d8d2170659cd9d1e297baef"

URI_x86_64_v2_kf6-kbookmarks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kbookmarks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks}"
SRC_URI[x86_64_v2_kf6-kbookmarks.sha256sum] = "6e26476531d722312b60b2a75cb6fda44d97913edbd43c597b0e7b5e8a7ffb16"

URI_x86_64_v2_kf6-kbookmarks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kbookmarks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks-devel}"
SRC_URI[x86_64_v2_kf6-kbookmarks-devel.sha256sum] = "893b146539b4b2159ed8a28f769ee0c4597829046466e8979c482e2a403cfc11"

URI_x86_64_v2_kf6-kbookmarks-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kbookmarks-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks-doc}"
SRC_URI[x86_64_v2_kf6-kbookmarks-doc.sha256sum] = "626e35302ee68cf9b2b4ebdeea5470d05311f215475d6e6341c23e07d4b15b25"

URI_aarch64_kf6-kbookmarks = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kbookmarks;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks}"
SRC_URI[aarch64_kf6-kbookmarks.sha256sum] = "38255df33c9545ef8348ad0b50bce2f5fac9842931c41444798115c16593aab5"

URI_aarch64_kf6-kbookmarks-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kbookmarks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks-devel}"
SRC_URI[aarch64_kf6-kbookmarks-devel.sha256sum] = "850fe68d22172565509b93a3886686ed43fce13268d51722da04a2477be49b41"

URI_aarch64_kf6-kbookmarks-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kbookmarks-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks-doc}"
SRC_URI[aarch64_kf6-kbookmarks-doc.sha256sum] = "c65a725c4d16e0f9f5e40a7fb099283b30fa27ec1ac0eb0b7618148640ad7377"

RDEPENDS:kf6-kbookmarks = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kbookmarks-devel = " \
 cmake-filesystem \
 kf6-kbookmarks \
 kf6-kwidgetsaddons-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kbookmarks-doc = " \
 "
