# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-axum"
PV = "0.7.9"
PR = "2.el10_1"
PACKAGES = " \
 rust-axum+default-devel \
 rust-axum+form-devel \
 rust-axum+http1-devel \
 rust-axum+http2-devel \
 rust-axum+json-devel \
 rust-axum+macros-devel \
 rust-axum+matched-path-devel \
 rust-axum+multipart-devel \
 rust-axum+original-uri-devel \
 rust-axum+query-devel \
 rust-axum+tokio-devel \
 rust-axum+tower-http-devel \
 rust-axum+tower-log-devel \
 rust-axum+tracing-devel \
 rust-axum+ws-devel \
 rust-axum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-axum-0.7.9-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a4dbc10981fd9c4067f1cc76ac72fa2e7ae33166de394953afe84a85b2f6be0"

URI_x86_64_v2_rust-axum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+default-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+default-devel}"
SRC_URI[x86_64_v2_rust-axum+default-devel.sha256sum] = "6a43b56d5eabdb3f66731faaf283906d2e39c93bd96a3581e01969fa95855f6e"

URI_x86_64_v2_rust-axum+form-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+form-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+form-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+form-devel}"
SRC_URI[x86_64_v2_rust-axum+form-devel.sha256sum] = "644ea1e81cc8ecdf65a11dc6b3d702c3c54f0ebdc3172ced97f0d2436d5d4ad3"

URI_x86_64_v2_rust-axum+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+http1-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+http1-devel}"
SRC_URI[x86_64_v2_rust-axum+http1-devel.sha256sum] = "9b162086e836aa735d4ed8bc0df105db453434210fd881e01274868db046d189"

URI_x86_64_v2_rust-axum+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+http2-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+http2-devel}"
SRC_URI[x86_64_v2_rust-axum+http2-devel.sha256sum] = "3b9fb1a3171fcfbb8f084427a9ad95235e4f2bb019683ee9c367fea600b1fb04"

URI_x86_64_v2_rust-axum+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+json-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+json-devel}"
SRC_URI[x86_64_v2_rust-axum+json-devel.sha256sum] = "3572f2cc5289d8e69e6d74dd4dc5132ee9deb8390dd9135a0717bb5c4cfc1a7d"

URI_x86_64_v2_rust-axum+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+macros-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+macros-devel}"
SRC_URI[x86_64_v2_rust-axum+macros-devel.sha256sum] = "bad6c27ebd53a658598b438594e0ff49c84ee4b866abf2d09cd4163a73cadb2c"

URI_x86_64_v2_rust-axum+matched-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+matched-path-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+matched-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+matched-path-devel}"
SRC_URI[x86_64_v2_rust-axum+matched-path-devel.sha256sum] = "799366d213ebe4247a1de6b2cf802a3d8c6a7dde4545452871cd9385bafac558"

URI_x86_64_v2_rust-axum+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+multipart-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+multipart-devel}"
SRC_URI[x86_64_v2_rust-axum+multipart-devel.sha256sum] = "d8018cf79f4a785e6370aea5bf0b30e9c42a01ca2140a5acc54cb597f720da80"

URI_x86_64_v2_rust-axum+original-uri-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+original-uri-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+original-uri-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+original-uri-devel}"
SRC_URI[x86_64_v2_rust-axum+original-uri-devel.sha256sum] = "128c6397a143c240b64299557201b1d877c4f0982b875b97cabb511ee1ad44ae"

URI_x86_64_v2_rust-axum+query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+query-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+query-devel}"
SRC_URI[x86_64_v2_rust-axum+query-devel.sha256sum] = "ba612ad081fee6228dd190560d9080deeb76ab55389c5461ffdc1a7b9b73a9cb"

URI_x86_64_v2_rust-axum+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tokio-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tokio-devel}"
SRC_URI[x86_64_v2_rust-axum+tokio-devel.sha256sum] = "0aab6f77ad22cd49be15d7cfb1c4bfd5b28fa811b77d4115adcde1155aed58c3"

URI_x86_64_v2_rust-axum+tower-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tower-http-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tower-http-devel}"
SRC_URI[x86_64_v2_rust-axum+tower-http-devel.sha256sum] = "e0139d32e5e10925efac47d7be7177bdf0564fdd502da69e055958d56498379c"

URI_x86_64_v2_rust-axum+tower-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tower-log-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tower-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tower-log-devel}"
SRC_URI[x86_64_v2_rust-axum+tower-log-devel.sha256sum] = "0368462c53e282dcaabce34e38d9da0d42e97f628cf87f549656bca773d3ba16"

URI_x86_64_v2_rust-axum+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tracing-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tracing-devel}"
SRC_URI[x86_64_v2_rust-axum+tracing-devel.sha256sum] = "9eae7d4f7f2f4a3326a8db96a4674d18f93469079ed4bd668d2cf9bf9067749f"

URI_x86_64_v2_rust-axum+ws-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+ws-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+ws-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+ws-devel}"
SRC_URI[x86_64_v2_rust-axum+ws-devel.sha256sum] = "0b32894a1fa56dc62fc78bef853493b02903d43801ccb49ee59c572f2d3b59ab"

URI_x86_64_v2_rust-axum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-devel-0.7.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-devel}"
SRC_URI[x86_64_v2_rust-axum-devel.sha256sum] = "fa9e514ec27ee9209d503e9443727ae3d0ffb2f1e7c15d40930c9e0f760fc4cc"

URI_aarch64_rust-axum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+default-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+default-devel}"
SRC_URI[aarch64_rust-axum+default-devel.sha256sum] = "cd6e0411b262f5adfcafa61ffca46721b2a2078ee4e04eecdf7e980d9b34280d"

URI_aarch64_rust-axum+form-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+form-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+form-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+form-devel}"
SRC_URI[aarch64_rust-axum+form-devel.sha256sum] = "c7ebb233f2617986e168f13a11d15f6407f323d80927916f02a4ef9e970eea69"

URI_aarch64_rust-axum+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+http1-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+http1-devel}"
SRC_URI[aarch64_rust-axum+http1-devel.sha256sum] = "ddb4d4463c57a10ebd338700ad75d154bc94eb7514d5e1cb1c5c87588ffb3f88"

URI_aarch64_rust-axum+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+http2-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+http2-devel}"
SRC_URI[aarch64_rust-axum+http2-devel.sha256sum] = "97575160039964d0673391b4211dae6ced64d2329707471c719ec199b655bb1b"

URI_aarch64_rust-axum+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+json-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+json-devel}"
SRC_URI[aarch64_rust-axum+json-devel.sha256sum] = "0e7f84d94e7b57db70374b0328a858e321b08043a81b24ece3a4f1bb2fb6f558"

URI_aarch64_rust-axum+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+macros-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+macros-devel}"
SRC_URI[aarch64_rust-axum+macros-devel.sha256sum] = "22c5b89af91cb7949af00767695777469efcf0a86d937d522f5e99f84efbb860"

URI_aarch64_rust-axum+matched-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+matched-path-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+matched-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+matched-path-devel}"
SRC_URI[aarch64_rust-axum+matched-path-devel.sha256sum] = "25f452bf48798ed2031df1c7b4174f521d30ead868e6baea150db63fe76ca680"

URI_aarch64_rust-axum+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+multipart-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+multipart-devel}"
SRC_URI[aarch64_rust-axum+multipart-devel.sha256sum] = "9b57fc4bac24e7ac340c6cdabaa96adde1ec7aa9930fa9bcb9c1425d660e5598"

URI_aarch64_rust-axum+original-uri-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+original-uri-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+original-uri-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+original-uri-devel}"
SRC_URI[aarch64_rust-axum+original-uri-devel.sha256sum] = "750a2933532e8267bb93a72ca6674151da9675c8e030e1097a809c9e48f0ad82"

URI_aarch64_rust-axum+query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+query-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+query-devel}"
SRC_URI[aarch64_rust-axum+query-devel.sha256sum] = "9573a38e95edc8832df480a75e2c6279f38f34f891256fb4502fd4cc215bd57f"

URI_aarch64_rust-axum+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tokio-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tokio-devel}"
SRC_URI[aarch64_rust-axum+tokio-devel.sha256sum] = "65abce3620c005e89eb77ea921268d8b6cb3131c93e0819f1c613a2c6d0f15d0"

URI_aarch64_rust-axum+tower-http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tower-http-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tower-http-devel}"
SRC_URI[aarch64_rust-axum+tower-http-devel.sha256sum] = "df3c8935300c64b8d7f13d2d05eeaa697ce193427d2bee83f32e03e6631bc3f1"

URI_aarch64_rust-axum+tower-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tower-log-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+tower-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tower-log-devel}"
SRC_URI[aarch64_rust-axum+tower-log-devel.sha256sum] = "e2f0953d16dccacf3fdf8b993359b4e387ff8f01ffbaa63c073f21b9dae75376"

URI_aarch64_rust-axum+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tracing-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tracing-devel}"
SRC_URI[aarch64_rust-axum+tracing-devel.sha256sum] = "d5265e48108d6685a92b4472bdd17c338826427048a225424dd61c9d43600e08"

URI_aarch64_rust-axum+ws-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+ws-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum+ws-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+ws-devel}"
SRC_URI[aarch64_rust-axum+ws-devel.sha256sum] = "f53122d6016e71c173c15a36c43d570a4a32fa8738bf31073458758d1219ad5b"

URI_aarch64_rust-axum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-devel-0.7.9-2.el10_1.noarch.rpm;name=aarch64_rust-axum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-devel}"
SRC_URI[aarch64_rust-axum-devel.sha256sum] = "5cc0ee73a97d294ccd9e23463932e429df20d0040fca38d6e7c9f50504d7822a"

RDEPENDS:rust-axum+default-devel = " \
 cargo \
 rust-axum+form-devel \
 rust-axum+http1-devel \
 rust-axum+json-devel \
 rust-axum+matched-path-devel \
 rust-axum+original-uri-devel \
 rust-axum+query-devel \
 rust-axum+tokio-devel \
 rust-axum+tower-log-devel \
 rust-axum+tracing-devel \
 rust-axum-devel \
 "
RDEPENDS:rust-axum+form-devel = " \
 cargo \
 rust-axum-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-axum+http1-devel = " \
 cargo \
 rust-axum-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 "
RDEPENDS:rust-axum+http2-devel = " \
 cargo \
 rust-axum-devel \
 rust-hyper+default-devel \
 rust-hyper+http2-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 "
RDEPENDS:rust-axum+json-devel = " \
 cargo \
 rust-axum-devel \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-serde_path_to_error+default-devel \
 "
RDEPENDS:rust-axum+macros-devel = " \
 cargo \
 rust-axum-devel \
 rust-axum-macros+default-devel \
 "
RDEPENDS:rust-axum+matched-path-devel = " \
 cargo \
 rust-axum-devel \
 "
RDEPENDS:rust-axum+multipart-devel = " \
 cargo \
 rust-axum-devel \
 rust-multer+default-devel \
 "
RDEPENDS:rust-axum+original-uri-devel = " \
 cargo \
 rust-axum-devel \
 "
RDEPENDS:rust-axum+query-devel = " \
 cargo \
 rust-axum-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-axum+tokio-devel = " \
 cargo \
 rust-axum-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-tokio+default-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+time-devel \
 rust-tower+make-devel \
 "
RDEPENDS:rust-axum+tower-http-devel = " \
 cargo \
 rust-axum-devel \
 rust-tower-http+add-extension-devel \
 rust-tower-http+auth-devel \
 rust-tower-http+catch-panic-devel \
 rust-tower-http+compression-br-devel \
 rust-tower-http+compression-deflate-devel \
 rust-tower-http+compression-gzip-devel \
 rust-tower-http+cors-devel \
 rust-tower-http+decompression-br-devel \
 rust-tower-http+decompression-deflate-devel \
 rust-tower-http+decompression-gzip-devel \
 rust-tower-http+default-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http+fs-devel \
 rust-tower-http+limit-devel \
 rust-tower-http+map-request-body-devel \
 rust-tower-http+map-response-body-devel \
 rust-tower-http+metrics-devel \
 rust-tower-http+normalize-path-devel \
 rust-tower-http+propagate-header-devel \
 rust-tower-http+redirect-devel \
 rust-tower-http+request-id-devel \
 rust-tower-http+sensitive-headers-devel \
 rust-tower-http+set-header-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+timeout-devel \
 rust-tower-http+trace-devel \
 rust-tower-http+util-devel \
 rust-tower-http+validate-request-devel \
 "
RDEPENDS:rust-axum+tower-log-devel = " \
 cargo \
 rust-axum-devel \
 rust-tower+log-devel \
 "
RDEPENDS:rust-axum+tracing-devel = " \
 cargo \
 rust-axum-core+tracing-devel \
 rust-axum-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-axum+ws-devel = " \
 cargo \
 rust-axum+tokio-devel \
 rust-axum-devel \
 rust-base64+default-devel \
 rust-hyper+default-devel \
 rust-sha1+default-devel \
 rust-tokio-tungstenite+default-devel \
 "
RDEPENDS:rust-axum-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-axum-core+default-devel \
 rust-bytes+default-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-itoa+default-devel \
 rust-matchit0.7+default-devel \
 rust-memchr+default-devel \
 rust-mime+default-devel \
 rust-percent-encoding+default-devel \
 rust-pin-project-lite+default-devel \
 rust-rustversion+default-devel \
 rust-serde+default-devel \
 rust-sync_wrapper+default-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
