# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby-build"
PV = "20260422"
PR = "1.el10_1"
PACKAGES = " \
 ruby-build \
 ruby-build-all \
 ruby-build-core \
 ruby-build-jruby \
 ruby-build-mruby \
 ruby-build-others \
 ruby-build-picoruby \
 ruby-build-rbenv \
 ruby-build-ruby \
 ruby-build-truffleruby \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/ruby-build-20260422-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79753c6b7ae5e7b808709d45d93158c97d9c2cbd88500dee90530ba7f334a928"

URI_x86_64_v2_ruby-build = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-20260422-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build}"
SRC_URI[x86_64_v2_ruby-build.sha256sum] = "1952b748c0c3938848ff752bec7b368421e69fd8528b910b832c74cb5290b79e"

URI_x86_64_v2_ruby-build-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-all-20260422-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-all}"
SRC_URI[x86_64_v2_ruby-build-all.sha256sum] = "68bf2630d65c740a1b1c90f000210af82944ca572c0ced0d8d74fff417fd691d"

URI_x86_64_v2_ruby-build-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-core-20260422-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-core}"
SRC_URI[x86_64_v2_ruby-build-core.sha256sum] = "e6116403e2c3ee99522bee5b3c0bbde8d631bffa22a8ae37f99164206d26a43c"

URI_x86_64_v2_ruby-build-jruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-jruby-20260422-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-jruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-jruby}"
SRC_URI[x86_64_v2_ruby-build-jruby.sha256sum] = "1ced367b91071236650c74e80bed0ee9b6505c1f45c888cb5ade1174cebc0b0e"

URI_x86_64_v2_ruby-build-mruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-mruby-20260422-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-mruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-mruby}"
SRC_URI[x86_64_v2_ruby-build-mruby.sha256sum] = "dcc52b7b310e62d074aebc2c61f2f5226564ed60745a91f7ccdc115076d5187f"

URI_x86_64_v2_ruby-build-others = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-others-20260422-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-others;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-others}"
SRC_URI[x86_64_v2_ruby-build-others.sha256sum] = "96bf0e6c2c5c4ac2f53f85bf7912a68f0f63c7c28541929c9dd2a753a2b4ec7f"

URI_x86_64_v2_ruby-build-picoruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-picoruby-20260422-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-picoruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-picoruby}"
SRC_URI[x86_64_v2_ruby-build-picoruby.sha256sum] = "b3c17e0972afc993f83e83590f05d01d66ae20fc72773d6966c94e1d75f804ff"

URI_x86_64_v2_ruby-build-rbenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-rbenv-20260422-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-rbenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-rbenv}"
SRC_URI[x86_64_v2_ruby-build-rbenv.sha256sum] = "bfa63760e5be135603e6efbcd1d22aa93d1903da9b22c3c6a992aef9366ede6b"

URI_x86_64_v2_ruby-build-ruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-ruby-20260422-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-ruby}"
SRC_URI[x86_64_v2_ruby-build-ruby.sha256sum] = "d07d64d962f2a9e990c5a6a2af46d8149488cd1f7b18b735339ebbee0c5efbc9"

URI_x86_64_v2_ruby-build-truffleruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-truffleruby-20260422-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-truffleruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-truffleruby}"
SRC_URI[x86_64_v2_ruby-build-truffleruby.sha256sum] = "098ea84f6348c624fbc65db1bc7c6cdd0e32884189d8bbea468131f57d553eca"

URI_aarch64_ruby-build = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-20260422-1.el10_1.noarch.rpm;name=aarch64_ruby-build;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build}"
SRC_URI[aarch64_ruby-build.sha256sum] = "7beaaa232e37f807fe6562e4a6b40875466e27ae0a2e9e78ab2eab0ee8a6f24e"

URI_aarch64_ruby-build-all = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-all-20260422-1.el10_1.noarch.rpm;name=aarch64_ruby-build-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-all}"
SRC_URI[aarch64_ruby-build-all.sha256sum] = "29aa8ee7be42900a979c0109d7ff4cf295cc47d9d1b159b9582b5f809cbb738e"

URI_aarch64_ruby-build-core = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-core-20260422-1.el10_1.noarch.rpm;name=aarch64_ruby-build-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-core}"
SRC_URI[aarch64_ruby-build-core.sha256sum] = "d003216654d073992d9273662170122974cd1003295f03d1d045188f4fd0087e"

URI_aarch64_ruby-build-jruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-jruby-20260422-1.el10_1.noarch.rpm;name=aarch64_ruby-build-jruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-jruby}"
SRC_URI[aarch64_ruby-build-jruby.sha256sum] = "d4c9f21140fcaeb2c7699aaa2fc5c9af9c4d90f4d3e63f8b610345223c5f2235"

URI_aarch64_ruby-build-mruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-mruby-20260422-1.el10_1.noarch.rpm;name=aarch64_ruby-build-mruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-mruby}"
SRC_URI[aarch64_ruby-build-mruby.sha256sum] = "5397171e32b78a802289a0cf33e06ef102f80568acc515e18307ff690af13781"

URI_aarch64_ruby-build-others = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-others-20260422-1.el10_1.noarch.rpm;name=aarch64_ruby-build-others;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-others}"
SRC_URI[aarch64_ruby-build-others.sha256sum] = "30536f7c7a376c788f4363139b80ba42984d33bef42147fa1e2be365bf5cf13a"

URI_aarch64_ruby-build-picoruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-picoruby-20260422-1.el10_1.noarch.rpm;name=aarch64_ruby-build-picoruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-picoruby}"
SRC_URI[aarch64_ruby-build-picoruby.sha256sum] = "ec22168f3fa3310c3c36c5dba4e609bd3f7c16b50b10d36b9d109a0d76f0dc9c"

URI_aarch64_ruby-build-rbenv = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-rbenv-20260422-1.el10_1.noarch.rpm;name=aarch64_ruby-build-rbenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-rbenv}"
SRC_URI[aarch64_ruby-build-rbenv.sha256sum] = "9f217478c9bbb36b9e7ed8a5a3ae9ed4b48543cc1d41ad3adc9d5a15daa2c335"

URI_aarch64_ruby-build-ruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-ruby-20260422-1.el10_1.noarch.rpm;name=aarch64_ruby-build-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-ruby}"
SRC_URI[aarch64_ruby-build-ruby.sha256sum] = "22dc2bdd4865ddf444f3ead6516da3c5745b36a4d3136674366e2f1e11f450e4"

URI_aarch64_ruby-build-truffleruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-truffleruby-20260422-1.el10_1.noarch.rpm;name=aarch64_ruby-build-truffleruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-truffleruby}"
SRC_URI[aarch64_ruby-build-truffleruby.sha256sum] = "b23543a5adecf94bfae657b5fa0b7f31d5055dcb192c518b826f8d13b7f9158e"

RDEPENDS:ruby-build = " \
 ruby-build-core \
 "
RDEPENDS:ruby-build-all = " \
 ruby-build \
 ruby-build-core \
 ruby-build-jruby \
 ruby-build-mruby \
 ruby-build-others \
 ruby-build-picoruby \
 ruby-build-ruby \
 ruby-build-truffleruby \
 "
RDEPENDS:ruby-build-core = " \
 bash \
 "
RDEPENDS:ruby-build-jruby = " \
 gcc-c++ \
 java-latest-openjdk-headless \
 make \
 ruby-build-core \
 "
RDEPENDS:ruby-build-mruby = " \
 ruby \
 ruby-build-core \
 rubygem-rake \
 "
RDEPENDS:ruby-build-others = " \
 ruby-build-core \
 "
RDEPENDS:ruby-build-picoruby = " \
 gcc \
 git-core \
 ruby \
 ruby-build-core \
 rubygem-rake \
 "
RDEPENDS:ruby-build-rbenv = " \
 bash \
 rbenv \
 ruby-build \
 "
RDEPENDS:ruby-build-ruby = " \
 gcc \
 libffi-devel \
 libyaml-devel \
 perl-File-Compare \
 perl-File-Copy \
 perl-FindBin \
 perl-IPC-Cmd \
 perl-Time-Piece \
 perl-interpreter \
 perl-lib \
 ruby-build-core \
 zlib-ng-compat-devel \
 "
RDEPENDS:ruby-build-truffleruby = " \
 gcc \
 libyaml-devel \
 ruby-build-core \
 "
