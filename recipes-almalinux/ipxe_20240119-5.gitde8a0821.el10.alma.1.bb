# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipxe"
PV = "20240119"
PR = "5.gitde8a0821.el10.alma.1"
PACKAGES = " \
 ipxe-bootimgs-aarch64 \
 ipxe-bootimgs-x86 \
 ipxe-roms-qemu \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ipxe-20240119-5.gitde8a0821.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "323259b1e9c7f068ebe98fe4b3757fc0e2e2f8d0935a878c48e70d5a0f74e303"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipxe-bootimgs-aarch64-20240119-5.gitde8a0821.el10.alma.1.noarch.rpm;name=x86_64_v2_ipxe-bootimgs-aarch64;unpack=0"
SRC_URI[x86_64_v2_ipxe-bootimgs-aarch64.sha256sum] = "37e68baae1b35bf54eef2ecf9c19a3512a8a1a0ee68da0cd14f4a6614cf47a7e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipxe-bootimgs-x86-20240119-5.gitde8a0821.el10.alma.1.noarch.rpm;name=x86_64_v2_ipxe-bootimgs-x86;unpack=0"
SRC_URI[x86_64_v2_ipxe-bootimgs-x86.sha256sum] = "d81711d6b19ecbb65030c29c42310758ef13bc061a1226ed476cf7c027ac29e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipxe-roms-qemu-20240119-5.gitde8a0821.el10.alma.1.noarch.rpm;name=x86_64_v2_ipxe-roms-qemu;unpack=0"
SRC_URI[x86_64_v2_ipxe-roms-qemu.sha256sum] = "fa49c444fb6ed7185f2ab0a5b82c67d94ab9cdd049fedede75805ece80762866"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipxe-bootimgs-aarch64-20240119-5.gitde8a0821.el10.alma.1.noarch.rpm;name=aarch64_ipxe-bootimgs-aarch64;unpack=0"
SRC_URI[aarch64_ipxe-bootimgs-aarch64.sha256sum] = "37e68baae1b35bf54eef2ecf9c19a3512a8a1a0ee68da0cd14f4a6614cf47a7e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipxe-bootimgs-x86-20240119-5.gitde8a0821.el10.alma.1.noarch.rpm;name=aarch64_ipxe-bootimgs-x86;unpack=0"
SRC_URI[aarch64_ipxe-bootimgs-x86.sha256sum] = "d81711d6b19ecbb65030c29c42310758ef13bc061a1226ed476cf7c027ac29e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipxe-roms-qemu-20240119-5.gitde8a0821.el10.alma.1.noarch.rpm;name=aarch64_ipxe-roms-qemu;unpack=0"
SRC_URI[aarch64_ipxe-roms-qemu.sha256sum] = "fa49c444fb6ed7185f2ab0a5b82c67d94ab9cdd049fedede75805ece80762866"

RDEPENDS:ipxe-bootimgs-aarch64 = " \
 "
RDEPENDS:ipxe-bootimgs-x86 = " \
 "
RDEPENDS:ipxe-roms-qemu = " \
 "
