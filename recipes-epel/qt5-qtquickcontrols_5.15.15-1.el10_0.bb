# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtquickcontrols"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtquickcontrols \
 qt5-qtquickcontrols-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtquickcontrols-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "077bf03f2d6f02060a55ea3de3fe2c214a2d270d5ce3595748e63fd322d897ab"

URI_x86_64_v2_qt5-qtquickcontrols = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols.sha256sum] = "9d07db6fe8e8757e6eb0f2464f155a28ea1b51ac9ab9f36f5a48ea2c6e25b31a"

URI_x86_64_v2_qt5-qtquickcontrols-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols-examples}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols-examples.sha256sum] = "3a41dc541cb6b162347d0a103c93fc518815b358884c512fca046947e36acd3d"

URI_aarch64_qt5-qtquickcontrols = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtquickcontrols;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols}"
SRC_URI[aarch64_qt5-qtquickcontrols.sha256sum] = "b046fdb1c629c4c3b136426be102368cdf92479437b9d23491476ff869b4f2f2"

URI_aarch64_qt5-qtquickcontrols-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtquickcontrols-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols-examples}"
SRC_URI[aarch64_qt5-qtquickcontrols-examples.sha256sum] = "0023c44f01bdfd5183f78d2fcde0695c30ab4707f4faa16286a5ae9bb85c82e1"

RDEPENDS:qt5-qtquickcontrols = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtquickcontrols-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtquickcontrols \
 "
