# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-common"
PV = "0.9.0"
PR = "17.el10_0"
PACKAGES = " \
 rust-unic-common+default-devel \
 rust-unic-common+unstable-devel \
 rust-unic-common-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-common-0.9.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65e3563cff4874d482dd9f5cf0f3a49e5dfafa25b49ba5a838d1e303344da06f"

URI_x86_64_v2_rust-unic-common+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-common+default-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-common+default-devel}"
SRC_URI[x86_64_v2_rust-unic-common+default-devel.sha256sum] = "ee0f9a76184983c14e854a7439f7f90af29cb0b1c095070cf6c2351c991ced25"

URI_x86_64_v2_rust-unic-common+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-common+unstable-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-common+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-common+unstable-devel}"
SRC_URI[x86_64_v2_rust-unic-common+unstable-devel.sha256sum] = "dbf6aac316e0f74174dfb5d0cbf1ad716f920962baf0375a7d5dd102d8284cf6"

URI_x86_64_v2_rust-unic-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-common-devel-0.9.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-common-devel}"
SRC_URI[x86_64_v2_rust-unic-common-devel.sha256sum] = "0485428b25c78ad42f30d95facda038974067a75c60f2b9cbaa2ee729cbb7932"

URI_aarch64_rust-unic-common+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-common+default-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-common+default-devel}"
SRC_URI[aarch64_rust-unic-common+default-devel.sha256sum] = "68a94759d1115d9df7490ecf190a2664d4c6bf01d45fae4fd496139b11054d95"

URI_aarch64_rust-unic-common+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-common+unstable-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-common+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-common+unstable-devel}"
SRC_URI[aarch64_rust-unic-common+unstable-devel.sha256sum] = "e815287ed96857ac85df426dc2cbb2c2548d67c22d72c6333c475885ef6d275e"

URI_aarch64_rust-unic-common-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-common-devel-0.9.0-17.el10_0.noarch.rpm;name=aarch64_rust-unic-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-common-devel}"
SRC_URI[aarch64_rust-unic-common-devel.sha256sum] = "d0be2c742c7f99e8bb8878bfbd53b8dc1880642a72061f74ba21b64cb8a9f4ab"

RDEPENDS:rust-unic-common+default-devel = " \
 cargo \
 rust-unic-common-devel \
 "
RDEPENDS:rust-unic-common+unstable-devel = " \
 cargo \
 rust-unic-common-devel \
 "
RDEPENDS:rust-unic-common-devel = " \
 cargo \
 "
