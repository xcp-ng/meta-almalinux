# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pkcs8"
PV = "0.10.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-pkcs8+3des-devel \
 rust-pkcs8+alloc-devel \
 rust-pkcs8+default-devel \
 rust-pkcs8+des-insecure-devel \
 rust-pkcs8+encryption-devel \
 rust-pkcs8+getrandom-devel \
 rust-pkcs8+pem-devel \
 rust-pkcs8+pkcs5-devel \
 rust-pkcs8+rand_core-devel \
 rust-pkcs8+sha1-insecure-devel \
 rust-pkcs8+std-devel \
 rust-pkcs8+subtle-devel \
 rust-pkcs8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pkcs8-0.10.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7d7c062181d05f140e5b31feb1bbfb5b6807d8ef117d3cc53487832e46f2e3f"

URI_x86_64_v2_rust-pkcs8+3des-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs8+3des-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs8+3des-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs8+3des-devel}"
SRC_URI[x86_64_v2_rust-pkcs8+3des-devel.sha256sum] = "6f295a9aed229b3229c68caaa036790938ad95e6e67e243da75656e478f9025d"

URI_x86_64_v2_rust-pkcs8+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs8+alloc-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs8+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs8+alloc-devel}"
SRC_URI[x86_64_v2_rust-pkcs8+alloc-devel.sha256sum] = "7b646aded134a9d0d4979f07ae988b237bea8add1298369cb2e7a0276b9a24ef"

URI_x86_64_v2_rust-pkcs8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs8+default-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs8+default-devel}"
SRC_URI[x86_64_v2_rust-pkcs8+default-devel.sha256sum] = "37a26e1be6d58af8592d4498b85b0b50bf4a72631718175ab932637b80f3b8cc"

URI_x86_64_v2_rust-pkcs8+des-insecure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs8+des-insecure-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs8+des-insecure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs8+des-insecure-devel}"
SRC_URI[x86_64_v2_rust-pkcs8+des-insecure-devel.sha256sum] = "303f9a82b9e32d3bbb61ed6ba556a088f9cb7db31b8a5d56fabd5e8e4bb6a97c"

URI_x86_64_v2_rust-pkcs8+encryption-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs8+encryption-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs8+encryption-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs8+encryption-devel}"
SRC_URI[x86_64_v2_rust-pkcs8+encryption-devel.sha256sum] = "3f8cdd6c7c32fd6930c1f9d8712ed6057bb2a66c88f87dc7e34e83afffe14614"

URI_x86_64_v2_rust-pkcs8+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs8+getrandom-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs8+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs8+getrandom-devel}"
SRC_URI[x86_64_v2_rust-pkcs8+getrandom-devel.sha256sum] = "6a44ebba9eb2a8a7216906ed0d4c4e41c4c7a1c4bb77f2fbdecb30b45badd12f"

URI_x86_64_v2_rust-pkcs8+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs8+pem-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs8+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs8+pem-devel}"
SRC_URI[x86_64_v2_rust-pkcs8+pem-devel.sha256sum] = "7d373b6cb7e6d3d8c6edeeb5d61d3b1a5b17e8e08a9b3b766cb403ca0e2ba5c5"

URI_x86_64_v2_rust-pkcs8+pkcs5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs8+pkcs5-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs8+pkcs5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs8+pkcs5-devel}"
SRC_URI[x86_64_v2_rust-pkcs8+pkcs5-devel.sha256sum] = "87ff983697312ee41de01e3097501fb13ed4f8afc1a2a363f46bebbee4a4eb85"

URI_x86_64_v2_rust-pkcs8+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs8+rand_core-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs8+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs8+rand_core-devel}"
SRC_URI[x86_64_v2_rust-pkcs8+rand_core-devel.sha256sum] = "37bcebae3e6df0cfb3f32e4e2af8e85f21f3f72f425d807a2b16bd41dd6b9ca3"

URI_x86_64_v2_rust-pkcs8+sha1-insecure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs8+sha1-insecure-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs8+sha1-insecure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs8+sha1-insecure-devel}"
SRC_URI[x86_64_v2_rust-pkcs8+sha1-insecure-devel.sha256sum] = "20f0ffaecdc382722b948365961ace7018e41afa76d00499bd27e725bb1cea2e"

URI_x86_64_v2_rust-pkcs8+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs8+std-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs8+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs8+std-devel}"
SRC_URI[x86_64_v2_rust-pkcs8+std-devel.sha256sum] = "d9b2a05680c53cb973448d59f3c7604b5f8b139209cd794c6e43e37ab87dda98"

URI_x86_64_v2_rust-pkcs8+subtle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs8+subtle-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs8+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs8+subtle-devel}"
SRC_URI[x86_64_v2_rust-pkcs8+subtle-devel.sha256sum] = "57479a6db9883c2b468c919e0cbca810de5a72baab48bcfc96fe89d2abeb6765"

URI_x86_64_v2_rust-pkcs8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs8-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs8-devel}"
SRC_URI[x86_64_v2_rust-pkcs8-devel.sha256sum] = "b10a666585634de03744ecbe069b3d26c2121ca148c3c7b3f4e6cc7b455dd2dd"

URI_aarch64_rust-pkcs8+3des-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs8+3des-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs8+3des-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs8+3des-devel}"
SRC_URI[aarch64_rust-pkcs8+3des-devel.sha256sum] = "af7b3975b2e934751d5d980b8f7105fae902fe21a7bb4970fd3989d12e1c01f7"

URI_aarch64_rust-pkcs8+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs8+alloc-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs8+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs8+alloc-devel}"
SRC_URI[aarch64_rust-pkcs8+alloc-devel.sha256sum] = "d7126b5afc7e597c2313550b68bd9fac36722af4f5eadb04ea966d493ca877c1"

URI_aarch64_rust-pkcs8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs8+default-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs8+default-devel}"
SRC_URI[aarch64_rust-pkcs8+default-devel.sha256sum] = "5a2ebfee5a57025d18cd7b48544b60e9f43f6ad1c0d67baaeef665da1295eaea"

URI_aarch64_rust-pkcs8+des-insecure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs8+des-insecure-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs8+des-insecure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs8+des-insecure-devel}"
SRC_URI[aarch64_rust-pkcs8+des-insecure-devel.sha256sum] = "5d195161fa38500aa23c0f509fdbed7e3094434769324f4d173cac4ae5edd793"

URI_aarch64_rust-pkcs8+encryption-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs8+encryption-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs8+encryption-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs8+encryption-devel}"
SRC_URI[aarch64_rust-pkcs8+encryption-devel.sha256sum] = "f338b1530a53f8b2b464e2d0ce00ad516b34998cb10803314ab65b58655c639c"

URI_aarch64_rust-pkcs8+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs8+getrandom-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs8+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs8+getrandom-devel}"
SRC_URI[aarch64_rust-pkcs8+getrandom-devel.sha256sum] = "367f5245c9c72c912b813f1d94ff76acc73d6503ef491e0695a84ecc12774d5d"

URI_aarch64_rust-pkcs8+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs8+pem-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs8+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs8+pem-devel}"
SRC_URI[aarch64_rust-pkcs8+pem-devel.sha256sum] = "eb27414d68b193ea86f996ef6264ab16af692db2f61c156c38bb9cc6dc14cd9c"

URI_aarch64_rust-pkcs8+pkcs5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs8+pkcs5-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs8+pkcs5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs8+pkcs5-devel}"
SRC_URI[aarch64_rust-pkcs8+pkcs5-devel.sha256sum] = "f1b40911c116c728fc79576020c731a80e17807641991ecc2c6c8feee054f6e8"

URI_aarch64_rust-pkcs8+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs8+rand_core-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs8+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs8+rand_core-devel}"
SRC_URI[aarch64_rust-pkcs8+rand_core-devel.sha256sum] = "14ba6a6cce29a4ffa9794c68419fa3ca2276a0687fae6183218f9ee93a7d9ece"

URI_aarch64_rust-pkcs8+sha1-insecure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs8+sha1-insecure-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs8+sha1-insecure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs8+sha1-insecure-devel}"
SRC_URI[aarch64_rust-pkcs8+sha1-insecure-devel.sha256sum] = "e2dd1194dde48f93e8bc2a535bbe82dd0d8a7170f1733a278801ca8c7e441a15"

URI_aarch64_rust-pkcs8+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs8+std-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs8+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs8+std-devel}"
SRC_URI[aarch64_rust-pkcs8+std-devel.sha256sum] = "4a63ae124b21645d07af2413a7106b74da94507c596f77072539733d4b685f3d"

URI_aarch64_rust-pkcs8+subtle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs8+subtle-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs8+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs8+subtle-devel}"
SRC_URI[aarch64_rust-pkcs8+subtle-devel.sha256sum] = "1ab20cb435787de7ea72e334780c95fd79efed993ea88700801c03d759a7f78f"

URI_aarch64_rust-pkcs8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs8-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs8-devel}"
SRC_URI[aarch64_rust-pkcs8-devel.sha256sum] = "514ade0fd17f3e71841744d454fef5ffb8a54945487ee5d7e92814ddb162ffd4"

RDEPENDS:rust-pkcs8+3des-devel = " \
 cargo \
 rust-pkcs5+3des-devel \
 rust-pkcs5+default-devel \
 rust-pkcs8+encryption-devel \
 rust-pkcs8-devel \
 "
RDEPENDS:rust-pkcs8+alloc-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-der+zeroize-devel \
 rust-pkcs8-devel \
 rust-spki+alloc-devel \
 "
RDEPENDS:rust-pkcs8+default-devel = " \
 cargo \
 rust-pkcs8-devel \
 "
RDEPENDS:rust-pkcs8+des-insecure-devel = " \
 cargo \
 rust-pkcs5+default-devel \
 rust-pkcs5+des-insecure-devel \
 rust-pkcs8+encryption-devel \
 rust-pkcs8-devel \
 "
RDEPENDS:rust-pkcs8+encryption-devel = " \
 cargo \
 rust-pkcs5+alloc-devel \
 rust-pkcs5+default-devel \
 rust-pkcs5+pbes2-devel \
 rust-pkcs8+alloc-devel \
 rust-pkcs8+rand_core-devel \
 rust-pkcs8-devel \
 "
RDEPENDS:rust-pkcs8+getrandom-devel = " \
 cargo \
 rust-pkcs8-devel \
 rust-rand_core0.6+getrandom-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-pkcs8+pem-devel = " \
 cargo \
 rust-der+pem-devel \
 rust-pkcs8+alloc-devel \
 rust-pkcs8-devel \
 rust-spki+pem-devel \
 "
RDEPENDS:rust-pkcs8+pkcs5-devel = " \
 cargo \
 rust-pkcs5+default-devel \
 rust-pkcs8-devel \
 "
RDEPENDS:rust-pkcs8+rand_core-devel = " \
 cargo \
 rust-pkcs8-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-pkcs8+sha1-insecure-devel = " \
 cargo \
 rust-pkcs5+default-devel \
 rust-pkcs5+sha1-insecure-devel \
 rust-pkcs8+encryption-devel \
 rust-pkcs8-devel \
 "
RDEPENDS:rust-pkcs8+std-devel = " \
 cargo \
 rust-der+std-devel \
 rust-pkcs8+alloc-devel \
 rust-pkcs8-devel \
 rust-spki+std-devel \
 "
RDEPENDS:rust-pkcs8+subtle-devel = " \
 cargo \
 rust-pkcs8-devel \
 rust-subtle-devel \
 "
RDEPENDS:rust-pkcs8-devel = " \
 cargo \
 rust \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-spki+default-devel \
 "
