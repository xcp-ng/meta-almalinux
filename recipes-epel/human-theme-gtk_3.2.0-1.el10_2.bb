# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "human-theme-gtk"
PV = "3.2.0"
PR = "1.el10_2"
PACKAGES = " \
 human-theme-gtk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/human-theme-gtk-3.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f874105a13444f036c18b4b343350dfd291900da4510a1fe28a7e5e6706d905"

URI_x86_64_v2_human-theme-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/human-theme-gtk-3.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_human-theme-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_human-theme-gtk}"
SRC_URI[x86_64_v2_human-theme-gtk.sha256sum] = "4ca20ba72eaf908763ff089fc39d2418d70a1313be0381f4c996b988e8132f0d"

URI_aarch64_human-theme-gtk = "${EPEL_MIRROR}/aarch64/Packages/h/human-theme-gtk-3.2.0-1.el10_2.noarch.rpm;name=aarch64_human-theme-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_human-theme-gtk}"
SRC_URI[aarch64_human-theme-gtk.sha256sum] = "e3a7bf6d207beef2d85c2d2686fb19685290fd86ffc6b8665506a2e8452d01c1"

RDEPENDS:human-theme-gtk = " \
 "
