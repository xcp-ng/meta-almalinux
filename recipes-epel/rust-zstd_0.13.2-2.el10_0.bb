# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zstd"
PV = "0.13.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-zstd+arrays-devel \
 rust-zstd+bindgen-devel \
 rust-zstd+debug-devel \
 rust-zstd+default-devel \
 rust-zstd+doc-cfg-devel \
 rust-zstd+experimental-devel \
 rust-zstd+fat-lto-devel \
 rust-zstd+legacy-devel \
 rust-zstd+no_asm-devel \
 rust-zstd+pkg-config-devel \
 rust-zstd+thin-devel \
 rust-zstd+thin-lto-devel \
 rust-zstd+wasm-devel \
 rust-zstd+zdict_builder-devel \
 rust-zstd+zstdmt-devel \
 rust-zstd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zstd-0.13.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3e4d7c429aac3ba9e15e4d85fe2b5846b935aa9273529781b2b97771c45f324"

URI_x86_64_v2_rust-zstd+arrays-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+arrays-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+arrays-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+arrays-devel}"
SRC_URI[x86_64_v2_rust-zstd+arrays-devel.sha256sum] = "d67429042e94546cf1fb02d174614d2d38c5a6615bef69a9d1a6654e8a4211d7"

URI_x86_64_v2_rust-zstd+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+bindgen-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+bindgen-devel}"
SRC_URI[x86_64_v2_rust-zstd+bindgen-devel.sha256sum] = "83d188389a7557c666b71a6d23386ef1c169ef13dfc4d0ccf721d92d6370992d"

URI_x86_64_v2_rust-zstd+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+debug-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+debug-devel}"
SRC_URI[x86_64_v2_rust-zstd+debug-devel.sha256sum] = "c1b9cfa9863f35d6dbbe8b5e6c41ea44de4b6aa2b9a1d18709490ffbc4b4b966"

URI_x86_64_v2_rust-zstd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+default-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+default-devel}"
SRC_URI[x86_64_v2_rust-zstd+default-devel.sha256sum] = "40d4d7cfd5efa1190cc82cfa0d2759bc99c12ae1713b0cbf99c26a83e391a951"

URI_x86_64_v2_rust-zstd+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+doc-cfg-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-zstd+doc-cfg-devel.sha256sum] = "6ce2ef4121667de076c91383cb13f9584d0e13318f6dada768353cb172e28f9b"

URI_x86_64_v2_rust-zstd+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+experimental-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+experimental-devel}"
SRC_URI[x86_64_v2_rust-zstd+experimental-devel.sha256sum] = "509aad3f02fe5be5e7de1358a25f694dc66c87a40794b5babf96c33182a183c6"

URI_x86_64_v2_rust-zstd+fat-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+fat-lto-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+fat-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd+fat-lto-devel.sha256sum] = "7a20eec6cc4bd6340a224800619ee25eea237753a1a80196c068acad0e88d0ea"

URI_x86_64_v2_rust-zstd+legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+legacy-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+legacy-devel}"
SRC_URI[x86_64_v2_rust-zstd+legacy-devel.sha256sum] = "43915844f9c8f6c548410c2f8f5f206256b0060f7bf50c3239f80196e2d8a790"

URI_x86_64_v2_rust-zstd+no_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+no_asm-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+no_asm-devel}"
SRC_URI[x86_64_v2_rust-zstd+no_asm-devel.sha256sum] = "bed9922107d60a2bf1476b9a8b46b6bb93f6fe0a0126c94ba6a049ac1a6a63e0"

URI_x86_64_v2_rust-zstd+pkg-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+pkg-config-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+pkg-config-devel}"
SRC_URI[x86_64_v2_rust-zstd+pkg-config-devel.sha256sum] = "139fcf76c807e8b15e7888d0aae74a7caeb5a099699b2af35c82570bdf3d4621"

URI_x86_64_v2_rust-zstd+thin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+thin-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+thin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+thin-devel}"
SRC_URI[x86_64_v2_rust-zstd+thin-devel.sha256sum] = "ee767b7c3c80ccde19f6c74b6b038d17c9acb1bdcd853fdf479cb2a182d2cc0d"

URI_x86_64_v2_rust-zstd+thin-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+thin-lto-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+thin-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd+thin-lto-devel.sha256sum] = "5ed425908cfbf332695141ed7e537fcf72464b0d4a8c98054b67bba809368b73"

URI_x86_64_v2_rust-zstd+wasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+wasm-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+wasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+wasm-devel}"
SRC_URI[x86_64_v2_rust-zstd+wasm-devel.sha256sum] = "b475ab5fcb84ceed2e0dc6a158523711363557324a6dbd5a621a96ffef118f24"

URI_x86_64_v2_rust-zstd+zdict_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+zdict_builder-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+zdict_builder-devel}"
SRC_URI[x86_64_v2_rust-zstd+zdict_builder-devel.sha256sum] = "5d1d791391b7b1039cc2bf1d2015240fc9338877036315a60d143bdf5978b1d2"

URI_x86_64_v2_rust-zstd+zstdmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+zstdmt-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+zstdmt-devel}"
SRC_URI[x86_64_v2_rust-zstd+zstdmt-devel.sha256sum] = "24fb83c4e7720f6c548a48bc9bea81ebe806930e6f08797acd69055b227d1808"

URI_x86_64_v2_rust-zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-devel-0.13.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-devel}"
SRC_URI[x86_64_v2_rust-zstd-devel.sha256sum] = "4cf38b40c1d75caba36493ac811e242b5c1b517e0fd372bcd561fd16e35e2dd6"

URI_aarch64_rust-zstd+arrays-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+arrays-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+arrays-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+arrays-devel}"
SRC_URI[aarch64_rust-zstd+arrays-devel.sha256sum] = "51ad273e668e57d548de72b8c7020c06a4100605f2d7129622f7f9ff49157586"

URI_aarch64_rust-zstd+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+bindgen-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+bindgen-devel}"
SRC_URI[aarch64_rust-zstd+bindgen-devel.sha256sum] = "fe358b250a9f1a52683224bc3ff6c5e0d650af4725c844ed83ef23f72a784c49"

URI_aarch64_rust-zstd+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+debug-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+debug-devel}"
SRC_URI[aarch64_rust-zstd+debug-devel.sha256sum] = "881b2e15f3867c0ffebe55c2dceaeec10fd3f8c51fddf6bdaab9e31e3a4590b5"

URI_aarch64_rust-zstd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+default-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+default-devel}"
SRC_URI[aarch64_rust-zstd+default-devel.sha256sum] = "c547b9198a84b183bced220f1eb65743951634d5a1a5c40191ee1cdd5eabcc92"

URI_aarch64_rust-zstd+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+doc-cfg-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+doc-cfg-devel}"
SRC_URI[aarch64_rust-zstd+doc-cfg-devel.sha256sum] = "b60002a94225362ade6a4b655a946df56ef8a3b0cb0c7d8dfdb6dbf3bd6173a3"

URI_aarch64_rust-zstd+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+experimental-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+experimental-devel}"
SRC_URI[aarch64_rust-zstd+experimental-devel.sha256sum] = "c3001d850ffaa8c0a084a74926f5df165e3bf93a4b76d4a13b1f3e72978c6517"

URI_aarch64_rust-zstd+fat-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+fat-lto-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+fat-lto-devel}"
SRC_URI[aarch64_rust-zstd+fat-lto-devel.sha256sum] = "3d0f98e5c921edf1f4ac20c750f825cd4512b499d21951d9527c3a7af2d8e41a"

URI_aarch64_rust-zstd+legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+legacy-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+legacy-devel}"
SRC_URI[aarch64_rust-zstd+legacy-devel.sha256sum] = "b389654bf21eb2c4f8ff346cfea636c4ff114c1c39ae8d64d0e1d22c2db8ff69"

URI_aarch64_rust-zstd+no_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+no_asm-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+no_asm-devel}"
SRC_URI[aarch64_rust-zstd+no_asm-devel.sha256sum] = "c9ccd0a8bdf53ff42439b27a63d956316e0664db00de0615facf7714914cf4b5"

URI_aarch64_rust-zstd+pkg-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+pkg-config-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+pkg-config-devel}"
SRC_URI[aarch64_rust-zstd+pkg-config-devel.sha256sum] = "37ee4583ee664b207a0009288601d61ddf5bdf2be8e2e812e62ac80cc670b7a6"

URI_aarch64_rust-zstd+thin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+thin-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+thin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+thin-devel}"
SRC_URI[aarch64_rust-zstd+thin-devel.sha256sum] = "2a076f8f54265d5b9e7c75db6ba166669484e88fd759592789bedcc3c04acb10"

URI_aarch64_rust-zstd+thin-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+thin-lto-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+thin-lto-devel}"
SRC_URI[aarch64_rust-zstd+thin-lto-devel.sha256sum] = "ad2affb6519706f839f9bda1823bc42cb81e7d9b79c8216080632de5684bec55"

URI_aarch64_rust-zstd+wasm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+wasm-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+wasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+wasm-devel}"
SRC_URI[aarch64_rust-zstd+wasm-devel.sha256sum] = "741739d01833bd45dca0c66f702082aff4ff5f20bc978d44e28b35725bf5c5e9"

URI_aarch64_rust-zstd+zdict_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+zdict_builder-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+zdict_builder-devel}"
SRC_URI[aarch64_rust-zstd+zdict_builder-devel.sha256sum] = "2bf8d219072138ca5c9fc2d1c6595b0f07057364de80a37458da1079fe933067"

URI_aarch64_rust-zstd+zstdmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+zstdmt-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+zstdmt-devel}"
SRC_URI[aarch64_rust-zstd+zstdmt-devel.sha256sum] = "f942157ed8b5967466c181c6e895a92c7ff393553d8cd890fbd05154abbcdbb1"

URI_aarch64_rust-zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-devel-0.13.2-2.el10_0.noarch.rpm;name=aarch64_rust-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-devel}"
SRC_URI[aarch64_rust-zstd-devel.sha256sum] = "7ba915e52229d85dedd1ca367c87565cfc46d1d1ea585d16ad9cb125cc7bdc78"

RDEPENDS:rust-zstd+arrays-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+arrays-devel \
 "
RDEPENDS:rust-zstd+bindgen-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+bindgen-devel \
 "
RDEPENDS:rust-zstd+debug-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+debug-devel \
 "
RDEPENDS:rust-zstd+default-devel = " \
 cargo \
 rust-zstd+arrays-devel \
 rust-zstd+legacy-devel \
 rust-zstd+zdict_builder-devel \
 rust-zstd-devel \
 "
RDEPENDS:rust-zstd+doc-cfg-devel = " \
 cargo \
 rust-zstd-devel \
 "
RDEPENDS:rust-zstd+experimental-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+experimental-devel \
 "
RDEPENDS:rust-zstd+fat-lto-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+fat-lto-devel \
 "
RDEPENDS:rust-zstd+legacy-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+legacy-devel \
 "
RDEPENDS:rust-zstd+no_asm-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+no_asm-devel \
 "
RDEPENDS:rust-zstd+pkg-config-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+pkg-config-devel \
 "
RDEPENDS:rust-zstd+thin-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+thin-devel \
 "
RDEPENDS:rust-zstd+thin-lto-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+thin-lto-devel \
 "
RDEPENDS:rust-zstd+wasm-devel = " \
 cargo \
 rust-zstd-devel \
 "
RDEPENDS:rust-zstd+zdict_builder-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+zdict_builder-devel \
 "
RDEPENDS:rust-zstd+zstdmt-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+zstdmt-devel \
 "
RDEPENDS:rust-zstd-devel = " \
 cargo \
 rust \
 rust-zstd-safe+std-devel \
 rust-zstd-safe-devel \
 "
