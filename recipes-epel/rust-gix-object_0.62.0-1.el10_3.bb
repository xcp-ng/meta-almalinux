# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-object"
PV = "0.62.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-object+default-devel \
 rust-gix-object+document-features-devel \
 rust-gix-object+serde-devel \
 rust-gix-object+sha1-devel \
 rust-gix-object+sha256-devel \
 rust-gix-object-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-object-0.62.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0946463a3b66d370d45e675e99a1b4a77524662d4086da80a558d828c4eb606b"

URI_x86_64_v2_rust-gix-object+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+default-devel-0.62.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+default-devel}"
SRC_URI[x86_64_v2_rust-gix-object+default-devel.sha256sum] = "7b3f202cf5121ced2de088497e7141360de2c4ce234e55d884a5947d7113e1ca"

URI_x86_64_v2_rust-gix-object+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+document-features-devel-0.62.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-object+document-features-devel.sha256sum] = "92a90933b905d7ff2b7f0d824c6e1739c0587bfe9e852c389d424596d6896662"

URI_x86_64_v2_rust-gix-object+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+serde-devel-0.62.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-object+serde-devel.sha256sum] = "6388c4f68e535ec54d4d4363202524511424714705efbe49e1d8a075ff5e349d"

URI_x86_64_v2_rust-gix-object+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+sha1-devel-0.62.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-object+sha1-devel.sha256sum] = "c27a0d95515bf108a836520f2ff43b74e828881234fb2dbfc415ff051714cadf"

URI_x86_64_v2_rust-gix-object+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+sha256-devel-0.62.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-object+sha256-devel.sha256sum] = "d43281eb23f55d4941890839001e5543a306404a4d93170581a8ba7061cfbdcd"

URI_x86_64_v2_rust-gix-object-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object-devel-0.62.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object-devel}"
SRC_URI[x86_64_v2_rust-gix-object-devel.sha256sum] = "8d6fdf467615008c7c2823f9489ed196b61e2ec13da34c67b7e7e9dea75a0158"

URI_aarch64_rust-gix-object+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+default-devel-0.62.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+default-devel}"
SRC_URI[aarch64_rust-gix-object+default-devel.sha256sum] = "22225e3f0aad8b78196d69928dc5fbc8d6c9b275c72db0ef460eaa17c2782317"

URI_aarch64_rust-gix-object+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+document-features-devel-0.62.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-object+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+document-features-devel}"
SRC_URI[aarch64_rust-gix-object+document-features-devel.sha256sum] = "a3d618758d757c585d836a9ae099465a455b9f420059bcbddfeaa7451af03e3a"

URI_aarch64_rust-gix-object+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+serde-devel-0.62.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-object+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+serde-devel}"
SRC_URI[aarch64_rust-gix-object+serde-devel.sha256sum] = "be870a9a3df89576fe12289d824e88d280858bbb6c547bb67e66b550ad18a21c"

URI_aarch64_rust-gix-object+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+sha1-devel-0.62.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-object+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+sha1-devel}"
SRC_URI[aarch64_rust-gix-object+sha1-devel.sha256sum] = "a2f48ed8d2ef80bb1f66d7b3b8a071d1ad1fee5f010ca9ae001deafd3b5082ec"

URI_aarch64_rust-gix-object+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+sha256-devel-0.62.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-object+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+sha256-devel}"
SRC_URI[aarch64_rust-gix-object+sha256-devel.sha256sum] = "72b32d05235928331560becf7f4170840dee1aa1a279be004cf38467f67725b5"

URI_aarch64_rust-gix-object-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object-devel-0.62.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-object-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object-devel}"
SRC_URI[aarch64_rust-gix-object-devel.sha256sum] = "f64bfaeefd58b9d708a02f3a8574b2722d3ae7637d2769bb66a796601ab9a302"

RDEPENDS:rust-gix-object+default-devel = " \
 cargo \
 rust-gix-object-devel \
 "
RDEPENDS:rust-gix-object+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-object-devel \
 "
RDEPENDS:rust-gix-object+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-actor+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-object-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-smallvec+serde-devel \
 "
RDEPENDS:rust-gix-object+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-object-devel \
 "
RDEPENDS:rust-gix-object+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-object-devel \
 "
RDEPENDS:rust-gix-object-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-actor+default-devel \
 rust-gix-date+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-itoa+default-devel \
 rust-smallvec+default-devel \
 rust-smallvec+write-devel \
 rust-thiserror+default-devel \
 "
