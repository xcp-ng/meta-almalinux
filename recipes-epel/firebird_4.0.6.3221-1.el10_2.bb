# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firebird"
PV = "4.0.6.3221"
PR = "1.el10_2"
PACKAGES = " \
 firebird \
 firebird-devel \
 firebird-doc \
 firebird-examples \
 firebird-utils \
 libfbclient2 \
 libfbclient2-devel \
 libib-util \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/firebird-4.0.6.3221-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "93eadcc1937a9b332fc8999b49ba3804b7d1d8d827080abf7243823c00afa254"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firebird-4.0.6.3221-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_firebird;unpack=0"
SRC_URI[x86_64_v2_firebird.sha256sum] = "b11a92bff1166424de714fef0883d7e0c8402ec56d96a38360e70a4aac42c90d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firebird-devel-4.0.6.3221-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_firebird-devel;unpack=0"
SRC_URI[x86_64_v2_firebird-devel.sha256sum] = "a6771ca10235968eb0e6b666185860b948be3f64d8acb26b3acb29dd1318054d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firebird-doc-4.0.6.3221-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_firebird-doc;unpack=0"
SRC_URI[x86_64_v2_firebird-doc.sha256sum] = "8eaa4e81005e9a7702a213f49df4a473b3b6bb597cd8ed7d270fc8f33d22e576"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firebird-examples-4.0.6.3221-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_firebird-examples;unpack=0"
SRC_URI[x86_64_v2_firebird-examples.sha256sum] = "a467f81f6b239fb104ded546c00a3d0b73fd7aaa8461966b8e52a9cc4c54810b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firebird-utils-4.0.6.3221-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_firebird-utils;unpack=0"
SRC_URI[x86_64_v2_firebird-utils.sha256sum] = "2641d0a26bf2c2023fdc538b3d71763c190fa3bf9cb9f3e26faa988b8fc76da5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfbclient2-4.0.6.3221-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfbclient2;unpack=0"
SRC_URI[x86_64_v2_libfbclient2.sha256sum] = "fe81d6d0b29c28ab2397b22ef361efc4339df37209459c365d9c6abe244471e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfbclient2-devel-4.0.6.3221-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfbclient2-devel;unpack=0"
SRC_URI[x86_64_v2_libfbclient2-devel.sha256sum] = "f9f84e8024c4264a5163a4ecd82e83d15175c795a9342c91d721693758da102e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libib-util-4.0.6.3221-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libib-util;unpack=0"
SRC_URI[x86_64_v2_libib-util.sha256sum] = "bce511703d09f275a9ff9f12e9fc5e3114ac328b0e3e25b39d01823d50bf847b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/firebird-4.0.6.3221-1.el10_2.aarch64.rpm;name=aarch64_firebird;unpack=0"
SRC_URI[aarch64_firebird.sha256sum] = "192f314b1b112f0d6e2d9b83343ccaa6b889908fbc4dc947444f12af1259daed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/firebird-devel-4.0.6.3221-1.el10_2.aarch64.rpm;name=aarch64_firebird-devel;unpack=0"
SRC_URI[aarch64_firebird-devel.sha256sum] = "e8414606455064408ae6aa4c098ae6858a72c444a2c0b4896bb8a39586dcfb34"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/firebird-doc-4.0.6.3221-1.el10_2.noarch.rpm;name=aarch64_firebird-doc;unpack=0"
SRC_URI[aarch64_firebird-doc.sha256sum] = "4fa2cb2b2daad0c8ce78e7f20c62671bc62e9de3780a59e721e06578fef490df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/firebird-examples-4.0.6.3221-1.el10_2.noarch.rpm;name=aarch64_firebird-examples;unpack=0"
SRC_URI[aarch64_firebird-examples.sha256sum] = "511235e4f09a4b8493579cf332d4ba200fe4293f9377cf25fa5cb276644084a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/firebird-utils-4.0.6.3221-1.el10_2.aarch64.rpm;name=aarch64_firebird-utils;unpack=0"
SRC_URI[aarch64_firebird-utils.sha256sum] = "8f1da3b76314b0748bc0561462bbe44c1ec0fe9b41354bf228b56ede1cda6e19"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libfbclient2-4.0.6.3221-1.el10_2.aarch64.rpm;name=aarch64_libfbclient2;unpack=0"
SRC_URI[aarch64_libfbclient2.sha256sum] = "db3ae24c8b90624cade6153a20c4ff4b4194b328958f5551749a578f655d8074"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libfbclient2-devel-4.0.6.3221-1.el10_2.aarch64.rpm;name=aarch64_libfbclient2-devel;unpack=0"
SRC_URI[aarch64_libfbclient2-devel.sha256sum] = "75d2d73db93b9db70d7ae1320d9742f061a07722e315ac4d935cad3da8f16b30"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libib-util-4.0.6.3221-1.el10_2.aarch64.rpm;name=aarch64_libib-util;unpack=0"
SRC_URI[aarch64_libib-util.sha256sum] = "6ddb4e8e297863f0ff3bddfba12321204b64df51805fc1f7ee5050bc2afdf099"

RDEPENDS:firebird = " \
 bash \
 firebird-utils \
 glibc \
 libfbclient2 \
 libgcc \
 libib-util \
 libtomcrypt \
 libtommath \
 shadow-utils \
 "
RDEPENDS:firebird-devel = " \
 bash \
 firebird \
 libfbclient2-devel \
 "
RDEPENDS:firebird-doc = " \
 firebird \
 "
RDEPENDS:firebird-examples = " \
 firebird-doc \
 "
RDEPENDS:firebird-utils = " \
 glibc \
 libedit \
 libfbclient2 \
 libgcc \
 "
RDEPENDS:libfbclient2 = " \
 glibc \
 libgcc \
 libtommath \
 "
RDEPENDS:libfbclient2-devel = " \
 firebird-devel \
 libfbclient2 \
 pkgconf-pkg-config \
 "
RDEPENDS:libib-util = " \
 glibc \
 "
