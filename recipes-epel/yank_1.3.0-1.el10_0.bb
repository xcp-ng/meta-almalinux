# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yank"
PV = "1.3.0"
PR = "1.el10_0"
PACKAGES = " \
 yank \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/y/yank-1.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a0b88be716c4334e4378e705937cb154a9bb78cbfed6b8baff9b1332ba632c31"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yank-1.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yank;unpack=0"
SRC_URI[x86_64_v2_yank.sha256sum] = "b507a36ef2f085aeadffba158c930dcf5ec5445974e9d59084c61c1f9950c72e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/y/yank-1.3.0-1.el10_0.aarch64.rpm;name=aarch64_yank;unpack=0"
SRC_URI[aarch64_yank.sha256sum] = "809962a254ee8797c7772e773348573a05a9d98122290ccbf8fcd4c3659785dd"

RDEPENDS:yank = " \
 bash \
 glibc \
 "
