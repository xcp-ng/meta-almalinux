# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "s390utils"
PE = "2"
PV = "2.36.0"
PR = "2.el10"
PACKAGES = " \
 s390utils \
 s390utils-se-data \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/s390utils-2.36.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e6969fd2587f28e0f817287fbdf2cf2a7458c1a3a63351b808a4968ba8d99fa7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/s390utils-2.36.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_s390utils;unpack=0"
SRC_URI[x86_64_v2_s390utils.sha256sum] = "bc8f78a25fd6af6e369c9832caec9e09fbdffce83e196e6d670d5e53262dd7a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/s390utils-se-data-2.36.0-2.el10.noarch.rpm;name=x86_64_v2_s390utils-se-data;unpack=0"
SRC_URI[x86_64_v2_s390utils-se-data.sha256sum] = "fb0809eee6d6d2a5a26f496cd913afedee7a9d8160b8d576aff6e7ea08fe9955"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/s390utils-2.36.0-2.el10.aarch64.rpm;name=aarch64_s390utils;unpack=0"
SRC_URI[aarch64_s390utils.sha256sum] = "0175c3c2a4fa71c2839d76957a604467fe7ca7166dc88c93280e4a8bf097aa42"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/s390utils-se-data-2.36.0-2.el10.noarch.rpm;name=aarch64_s390utils-se-data;unpack=0"
SRC_URI[aarch64_s390utils-se-data.sha256sum] = "fb0809eee6d6d2a5a26f496cd913afedee7a9d8160b8d576aff6e7ea08fe9955"

RDEPENDS:s390utils = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 s390utils-se-data \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:s390utils-se-data = " \
 bash \
 "
