# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zip2"
PV = "2.4.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-zip2+_all-features-devel \
 rust-zip2+_deflate-any-devel \
 rust-zip2+aes-crypto-devel \
 rust-zip2+aes-devel \
 rust-zip2+bzip2-devel \
 rust-zip2+chrono-devel \
 rust-zip2+constant_time_eq-devel \
 rust-zip2+default-devel \
 rust-zip2+deflate-devel \
 rust-zip2+deflate-flate2-devel \
 rust-zip2+deflate-miniz-devel \
 rust-zip2+deflate-zlib-devel \
 rust-zip2+deflate-zlib-ng-devel \
 rust-zip2+deflate-zopfli-devel \
 rust-zip2+deflate64-devel \
 rust-zip2+flate2-devel \
 rust-zip2+getrandom-devel \
 rust-zip2+hmac-devel \
 rust-zip2+lzma-devel \
 rust-zip2+lzma-rs-devel \
 rust-zip2+pbkdf2-devel \
 rust-zip2+sha1-devel \
 rust-zip2+time-devel \
 rust-zip2+unreserved-devel \
 rust-zip2+xz-devel \
 rust-zip2+zeroize-devel \
 rust-zip2+zopfli-devel \
 rust-zip2+zstd-devel \
 rust-zip2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zip2-2.4.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12f8a3b96998f5939aa191535338d8ed6cd30ca206c578fb2ff4625247f24366"

URI_x86_64_v2_rust-zip2+_all-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+_all-features-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+_all-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+_all-features-devel}"
SRC_URI[x86_64_v2_rust-zip2+_all-features-devel.sha256sum] = "fd4a2e5d0aa3fb9b38c93660317fe0db515a98b851431f76aa08fc2ab424282c"

URI_x86_64_v2_rust-zip2+_deflate-any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+_deflate-any-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+_deflate-any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+_deflate-any-devel}"
SRC_URI[x86_64_v2_rust-zip2+_deflate-any-devel.sha256sum] = "9b52b2587380617c5470e51adc76cfa3b74ef9e239fe7c9b506b7ae55bf87a90"

URI_x86_64_v2_rust-zip2+aes-crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+aes-crypto-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+aes-crypto-devel}"
SRC_URI[x86_64_v2_rust-zip2+aes-crypto-devel.sha256sum] = "41713ad57dd75c05b926acdb53acac8b71684c277af89c206bcf88af6a77a941"

URI_x86_64_v2_rust-zip2+aes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+aes-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+aes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+aes-devel}"
SRC_URI[x86_64_v2_rust-zip2+aes-devel.sha256sum] = "0bb5a02451d822912135345ae47ddc158cc3bc058d3d3e2761ecc70770858e5b"

URI_x86_64_v2_rust-zip2+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+bzip2-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+bzip2-devel}"
SRC_URI[x86_64_v2_rust-zip2+bzip2-devel.sha256sum] = "aaff27a13d19797d628bccafeff9e0d7df6f51d711ff1ccf3533d4b15c1cad4e"
RPROVIDES:rust-zip2+bzip2-devel:append:x86_64_v2 = " virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_7.0.0~"

URI_x86_64_v2_rust-zip2+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+chrono-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+chrono-devel}"
SRC_URI[x86_64_v2_rust-zip2+chrono-devel.sha256sum] = "cc62c4c9627d2583dbec2445854db54399ceedd13c61ede3b30d16af6e8841a4"

URI_x86_64_v2_rust-zip2+constant_time_eq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+constant_time_eq-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+constant_time_eq-devel}"
SRC_URI[x86_64_v2_rust-zip2+constant_time_eq-devel.sha256sum] = "6a5e27d6af4317160b3d6a24f901711f7901053d2167a1535b32243e2f618e37"

URI_x86_64_v2_rust-zip2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+default-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+default-devel}"
SRC_URI[x86_64_v2_rust-zip2+default-devel.sha256sum] = "6f4e273d06cb6b1ec6995d7d3d3eba161be7c2f934e4fcb0c714c9583d3e8e48"

URI_x86_64_v2_rust-zip2+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate-devel.sha256sum] = "8e40270e550ad87280d9ef36a1bc347fe8251c0d5804d521126bc78a423117f8"
RPROVIDES:rust-zip2+deflate-devel:append:x86_64_v2 = " virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_7.0.0~"

URI_x86_64_v2_rust-zip2+deflate-flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate-flate2-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate-flate2-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate-flate2-devel.sha256sum] = "1538b9465e01394e672ebcc297f5644e21927c4f0a000c83188b9bf40793d2e6"

URI_x86_64_v2_rust-zip2+deflate-miniz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate-miniz-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate-miniz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate-miniz-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate-miniz-devel.sha256sum] = "56741b8ce99d828536bc2ba8edc73df002d70300c3b20ddc60f5b99a11870d4f"

URI_x86_64_v2_rust-zip2+deflate-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate-zlib-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate-zlib-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate-zlib-devel.sha256sum] = "c3db3511d463fe5a14fdb9763cecc056af5b4d59aab7634b580ea8192ff9933b"

URI_x86_64_v2_rust-zip2+deflate-zlib-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate-zlib-ng-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate-zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate-zlib-ng-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate-zlib-ng-devel.sha256sum] = "126ad2209a199716bc510c85bcd52d823f98f7f1e44267f9e082fe45d5c44603"

URI_x86_64_v2_rust-zip2+deflate-zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate-zopfli-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate-zopfli-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate-zopfli-devel.sha256sum] = "bc74ef71c9498e26b1e417b1c5d821f60b1f9376b6449d93cf66977299aa80b2"

URI_x86_64_v2_rust-zip2+deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate64-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate64-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate64-devel.sha256sum] = "90247509be578a210bc54b22c022c4abb3afbcb2d9491611faafd61ee4dfc8d0"

URI_x86_64_v2_rust-zip2+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+flate2-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+flate2-devel}"
SRC_URI[x86_64_v2_rust-zip2+flate2-devel.sha256sum] = "29b46d9e0566a7708401c36e83e48873bb1db76d08a4564f499280107670ac87"

URI_x86_64_v2_rust-zip2+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+getrandom-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+getrandom-devel}"
SRC_URI[x86_64_v2_rust-zip2+getrandom-devel.sha256sum] = "9008115926cf16b6762166911ee315e93d5d8b566c50e511ffc763ab52fdd42a"

URI_x86_64_v2_rust-zip2+hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+hmac-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+hmac-devel}"
SRC_URI[x86_64_v2_rust-zip2+hmac-devel.sha256sum] = "67cc8b029da2c61e442335e0066c10d27e7b2554515a4f2df7de0f2f937064fc"

URI_x86_64_v2_rust-zip2+lzma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+lzma-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+lzma-devel}"
SRC_URI[x86_64_v2_rust-zip2+lzma-devel.sha256sum] = "8c217d3143bec461b8f78448417c9d47035abd7b8f78ec62c18edba2686f90fd"

URI_x86_64_v2_rust-zip2+lzma-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+lzma-rs-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+lzma-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+lzma-rs-devel}"
SRC_URI[x86_64_v2_rust-zip2+lzma-rs-devel.sha256sum] = "55c3edaf2f6173b90720d6e6e71450d8e0e77f583f41d85e0a04545d4f52bca0"

URI_x86_64_v2_rust-zip2+pbkdf2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+pbkdf2-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+pbkdf2-devel}"
SRC_URI[x86_64_v2_rust-zip2+pbkdf2-devel.sha256sum] = "312fe1cba95d6394999346a0407aa1b0119c578d3a0a6e9cde3e45bdd1bb1afd"

URI_x86_64_v2_rust-zip2+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+sha1-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+sha1-devel}"
SRC_URI[x86_64_v2_rust-zip2+sha1-devel.sha256sum] = "4d6415ffee69f1ab3d5683f6d7231c1795d2afd51700171cf749e9ed2dd64eaa"

URI_x86_64_v2_rust-zip2+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+time-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+time-devel}"
SRC_URI[x86_64_v2_rust-zip2+time-devel.sha256sum] = "48789f8c532f4ece5c7e531962c49001efe51201c0588467001a44b1af840dd1"

URI_x86_64_v2_rust-zip2+unreserved-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+unreserved-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+unreserved-devel}"
SRC_URI[x86_64_v2_rust-zip2+unreserved-devel.sha256sum] = "065f73079c73e6ef5d7c61db63a276e2ba1d3a832dbc3f43f6c04537105e3f78"

URI_x86_64_v2_rust-zip2+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+xz-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+xz-devel}"
SRC_URI[x86_64_v2_rust-zip2+xz-devel.sha256sum] = "944fb731072c38da3db7dd0406d65633f9579633ba14c1af1bdf297d8ed05d7b"

URI_x86_64_v2_rust-zip2+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+zeroize-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+zeroize-devel}"
SRC_URI[x86_64_v2_rust-zip2+zeroize-devel.sha256sum] = "f6c4526672f8435dd161ec0f336472e00e0e750903d1ecd0fd8ce2114d635d32"

URI_x86_64_v2_rust-zip2+zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+zopfli-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+zopfli-devel}"
SRC_URI[x86_64_v2_rust-zip2+zopfli-devel.sha256sum] = "1fb53ec8137f184fcc3cb493b60ad906efb8b1c0918a51c6402e31f2c10466cd"

URI_x86_64_v2_rust-zip2+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+zstd-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+zstd-devel}"
SRC_URI[x86_64_v2_rust-zip2+zstd-devel.sha256sum] = "4f06154c23c24c97cbfb39a7407894924cbd3dee56781708514357dd7730890c"

URI_x86_64_v2_rust-zip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2-devel-2.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2-devel}"
SRC_URI[x86_64_v2_rust-zip2-devel.sha256sum] = "aa68f9a1e2f57d187adefb3db71e4003453fbe23ca3fddd1d63445ebd96abf6b"
RPROVIDES:rust-zip2-devel:append:x86_64_v2 = " virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_7.0.0~"

URI_aarch64_rust-zip2+_all-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+_all-features-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+_all-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+_all-features-devel}"
SRC_URI[aarch64_rust-zip2+_all-features-devel.sha256sum] = "20ae213c030ef9c300a8d28a5f66c42ed1abfff445bedb44d47f660e1c4d76d4"

URI_aarch64_rust-zip2+_deflate-any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+_deflate-any-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+_deflate-any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+_deflate-any-devel}"
SRC_URI[aarch64_rust-zip2+_deflate-any-devel.sha256sum] = "3bcd79971bed2f5e4fee40ea9f82d2dc1e0926644348ce4378731d1cd92cc450"

URI_aarch64_rust-zip2+aes-crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+aes-crypto-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+aes-crypto-devel}"
SRC_URI[aarch64_rust-zip2+aes-crypto-devel.sha256sum] = "4a204ab1941be5ed87341e5d09697446c1f15ec11562406e9edf935d40dc1186"

URI_aarch64_rust-zip2+aes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+aes-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+aes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+aes-devel}"
SRC_URI[aarch64_rust-zip2+aes-devel.sha256sum] = "fb6500577d8bfdce01f98ba4d8ca160eacb089086b152abadfcd93cd8dded9bd"

URI_aarch64_rust-zip2+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+bzip2-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+bzip2-devel}"
SRC_URI[aarch64_rust-zip2+bzip2-devel.sha256sum] = "d119fe569fb2ac72e46c275439d8668ca9e8b84fc44fb8e49b21e87cf6df17c9"
RPROVIDES:rust-zip2+bzip2-devel:append:aarch64 = " virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_7.0.0~"

URI_aarch64_rust-zip2+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+chrono-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+chrono-devel}"
SRC_URI[aarch64_rust-zip2+chrono-devel.sha256sum] = "e6dacf6e7f98f85e030217db83dbb8fcd7cfb6b34eb27630d476f0ababb4fa0c"

URI_aarch64_rust-zip2+constant_time_eq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+constant_time_eq-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+constant_time_eq-devel}"
SRC_URI[aarch64_rust-zip2+constant_time_eq-devel.sha256sum] = "94051a862947d2975041429b5de4f69908168b8917500a3ab84da3dad702b486"

URI_aarch64_rust-zip2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+default-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+default-devel}"
SRC_URI[aarch64_rust-zip2+default-devel.sha256sum] = "72276e129f0cc73a09028e9203fd665c549b378b3a4aeae49eb3ce0a3d449e0e"

URI_aarch64_rust-zip2+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate-devel}"
SRC_URI[aarch64_rust-zip2+deflate-devel.sha256sum] = "5ce46fc807156b202acb0b7b70139fbcc5d520684d9bd5412fa484af54694730"
RPROVIDES:rust-zip2+deflate-devel:append:aarch64 = " virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_7.0.0~"

URI_aarch64_rust-zip2+deflate-flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate-flate2-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+deflate-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate-flate2-devel}"
SRC_URI[aarch64_rust-zip2+deflate-flate2-devel.sha256sum] = "bdf74692dd261cfe1fc68f02b7353b8c3f51c19d1a0b9ce2dd64d32f2f16effd"

URI_aarch64_rust-zip2+deflate-miniz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate-miniz-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+deflate-miniz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate-miniz-devel}"
SRC_URI[aarch64_rust-zip2+deflate-miniz-devel.sha256sum] = "d27db862b0bbc4e54a66c4a49ad6b6a8f1e255e44fa5fc86241c384ce9a5ea82"

URI_aarch64_rust-zip2+deflate-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate-zlib-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+deflate-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate-zlib-devel}"
SRC_URI[aarch64_rust-zip2+deflate-zlib-devel.sha256sum] = "e2433d2bf0f22f52816fcb50b335175a2ddacb48bdd884baac467f165f8d9b9f"

URI_aarch64_rust-zip2+deflate-zlib-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate-zlib-ng-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+deflate-zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate-zlib-ng-devel}"
SRC_URI[aarch64_rust-zip2+deflate-zlib-ng-devel.sha256sum] = "1af8e5722cf800928aa0455213d2ead02cdaf53aafd14546f3a0c1c897c68b09"

URI_aarch64_rust-zip2+deflate-zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate-zopfli-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+deflate-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate-zopfli-devel}"
SRC_URI[aarch64_rust-zip2+deflate-zopfli-devel.sha256sum] = "9000991bb7fd2ee5ec2f1c4c8e8068994e5f7eb57ae9553f4cc52b757637835e"

URI_aarch64_rust-zip2+deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate64-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate64-devel}"
SRC_URI[aarch64_rust-zip2+deflate64-devel.sha256sum] = "9ae52eea54e08895682194605c63aa5caa9e0a4da9532f35bc9d77f1834c8186"

URI_aarch64_rust-zip2+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+flate2-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+flate2-devel}"
SRC_URI[aarch64_rust-zip2+flate2-devel.sha256sum] = "accfea886fda4875b5494f4075318389363194c041dd4d0fcf63b05b1a95e9a8"

URI_aarch64_rust-zip2+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+getrandom-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+getrandom-devel}"
SRC_URI[aarch64_rust-zip2+getrandom-devel.sha256sum] = "40085a10ce104a58d32b554f2b9812f3311ca073d7de724925bc861339e89875"

URI_aarch64_rust-zip2+hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+hmac-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+hmac-devel}"
SRC_URI[aarch64_rust-zip2+hmac-devel.sha256sum] = "1f66426edf8b182f05dcc65d1b6b0de5e03154cd21fc66744cc818adfd959c44"

URI_aarch64_rust-zip2+lzma-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+lzma-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+lzma-devel}"
SRC_URI[aarch64_rust-zip2+lzma-devel.sha256sum] = "a597ff3d318deae6534fce91cc4929fb788793bd4506dd653d5f57ec434e1134"

URI_aarch64_rust-zip2+lzma-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+lzma-rs-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+lzma-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+lzma-rs-devel}"
SRC_URI[aarch64_rust-zip2+lzma-rs-devel.sha256sum] = "d5da4227acf40707dfd5790eae79be24d8f3c2b45d295a4c823a240a58cd46d9"

URI_aarch64_rust-zip2+pbkdf2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+pbkdf2-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+pbkdf2-devel}"
SRC_URI[aarch64_rust-zip2+pbkdf2-devel.sha256sum] = "ed01ce6003b4750c3631c203e5c8ca30d4f96c3ce3670b5bebde739d0674d3aa"

URI_aarch64_rust-zip2+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+sha1-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+sha1-devel}"
SRC_URI[aarch64_rust-zip2+sha1-devel.sha256sum] = "54a19bea7c4291b2163932a38b5fb76bd3357aa83da1d84b3548876b3398dbb9"

URI_aarch64_rust-zip2+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+time-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+time-devel}"
SRC_URI[aarch64_rust-zip2+time-devel.sha256sum] = "d862c4751c7d89c2c9990e96bfdbbca257d2eb4705abdb29da7b642ef623b795"

URI_aarch64_rust-zip2+unreserved-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+unreserved-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+unreserved-devel}"
SRC_URI[aarch64_rust-zip2+unreserved-devel.sha256sum] = "dc6de0c312cc4a77a0dc6a77ae2cc08bafad467cc83e21c6449a425dc327373e"

URI_aarch64_rust-zip2+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+xz-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+xz-devel}"
SRC_URI[aarch64_rust-zip2+xz-devel.sha256sum] = "c1b1e5b4ee0fecc0b45a0b612eafedf151e1a751e5f4878a60f0b088a742d3dc"

URI_aarch64_rust-zip2+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+zeroize-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+zeroize-devel}"
SRC_URI[aarch64_rust-zip2+zeroize-devel.sha256sum] = "2ccc6389fab24be335f749e044940cb72b975287a04ce542c754451c3ba111d9"

URI_aarch64_rust-zip2+zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+zopfli-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+zopfli-devel}"
SRC_URI[aarch64_rust-zip2+zopfli-devel.sha256sum] = "fa418ea94164e296f65b20c170d613da25eb58fa1664c32f2835b6a790095c92"

URI_aarch64_rust-zip2+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+zstd-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+zstd-devel}"
SRC_URI[aarch64_rust-zip2+zstd-devel.sha256sum] = "5fa697ff9738c862a04e8a0b4419d3f8114019a1ec30272f5f78aba280447398"

URI_aarch64_rust-zip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2-devel-2.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-zip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2-devel}"
SRC_URI[aarch64_rust-zip2-devel.sha256sum] = "a08f46bdaf186254ffe6219ef71c94f2bcee106455238cb7f52974f02b5838ef"
RPROVIDES:rust-zip2-devel:append:aarch64 = " virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_7.0.0~"

RDEPENDS:rust-zip2+_all-features-devel = " \
 cargo \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+_deflate-any-devel = " \
 cargo \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+aes-crypto-devel = " \
 cargo \
 rust-zip2+aes-devel \
 rust-zip2+constant_time_eq-devel \
 rust-zip2+getrandom-devel \
 rust-zip2+hmac-devel \
 rust-zip2+pbkdf2-devel \
 rust-zip2+sha1-devel \
 rust-zip2+zeroize-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+aes-devel = " \
 cargo \
 rust-aes+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+chrono-devel = " \
 cargo \
 rust-chrono+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+constant_time_eq-devel = " \
 cargo \
 rust-constant_time_eq+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+default-devel = " \
 cargo \
 rust-zip2+aes-crypto-devel \
 rust-zip2+bzip2-devel \
 rust-zip2+deflate-devel \
 rust-zip2+deflate64-devel \
 rust-zip2+lzma-devel \
 rust-zip2+time-devel \
 rust-zip2+xz-devel \
 rust-zip2+zstd-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate-devel = " \
 cargo \
 rust-flate2+rust_backend-devel \
 rust-flate2-devel \
 rust-zip2+deflate-flate2-devel \
 rust-zip2+deflate-zopfli-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate-flate2-devel = " \
 cargo \
 rust-zip2+_deflate-any-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate-miniz-devel = " \
 cargo \
 rust-zip2+deflate-devel \
 rust-zip2+deflate-flate2-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate-zlib-devel = " \
 cargo \
 rust-flate2+zlib-devel \
 rust-flate2-devel \
 rust-zip2+deflate-flate2-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate-zlib-ng-devel = " \
 cargo \
 rust-flate2+zlib-ng-devel \
 rust-flate2-devel \
 rust-zip2+deflate-flate2-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate-zopfli-devel = " \
 cargo \
 rust-zip2+_deflate-any-devel \
 rust-zip2+zopfli-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate64-devel = " \
 cargo \
 rust-deflate64+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+flate2-devel = " \
 cargo \
 rust-flate2-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-getrandom+std-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+hmac-devel = " \
 cargo \
 rust-hmac+default-devel \
 rust-hmac+reset-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+lzma-devel = " \
 cargo \
 rust-lzma-rs+stream-devel \
 rust-lzma-rs-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+lzma-rs-devel = " \
 cargo \
 rust-lzma-rs-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+pbkdf2-devel = " \
 cargo \
 rust-pbkdf2+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+sha1-devel = " \
 cargo \
 rust-sha1+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+time-devel = " \
 cargo \
 rust-time+std-devel \
 rust-time-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+unreserved-devel = " \
 cargo \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+xz-devel = " \
 cargo \
 rust-xz2+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+zeroize-devel = " \
 cargo \
 rust-zeroize+default-devel \
 rust-zeroize+zeroize_derive-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+zopfli-devel = " \
 cargo \
 rust-zip2-devel \
 rust-zopfli+default-devel \
 "
RDEPENDS:rust-zip2+zstd-devel = " \
 cargo \
 rust-zip2-devel \
 rust-zstd-devel \
 "
RDEPENDS:rust-zip2-devel = " \
 cargo \
 rust \
 rust-crc32fast+default-devel \
 rust-displaydoc-devel \
 rust-indexmap+default-devel \
 rust-memchr+default-devel \
 rust-thiserror+default-devel \
 "
