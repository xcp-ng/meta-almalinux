# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_sleep"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_sleep+default-devel \
 rust-uu_sleep-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_sleep-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1352b7fb9d3e7404f850f8d146bd4e8ab846890665c19178bd26578cd7632190"

URI_x86_64_v2_rust-uu_sleep+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sleep+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sleep+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sleep+default-devel}"
SRC_URI[x86_64_v2_rust-uu_sleep+default-devel.sha256sum] = "ec46dd6c2119ab9c480c88bcc2c62dfde52c33d8d950732df85e4aa7d6cba28a"

URI_x86_64_v2_rust-uu_sleep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sleep-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sleep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sleep-devel}"
SRC_URI[x86_64_v2_rust-uu_sleep-devel.sha256sum] = "289bb6a88f4152292e6fb0fa31bf9676984789614e8bfd2bc7d213e07b2184e3"

URI_aarch64_rust-uu_sleep+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sleep+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sleep+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sleep+default-devel}"
SRC_URI[aarch64_rust-uu_sleep+default-devel.sha256sum] = "a14bf5dd5e71412c9724b785860ac6713efb060071e784378399ffec6abc7be1"

URI_aarch64_rust-uu_sleep-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sleep-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sleep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sleep-devel}"
SRC_URI[aarch64_rust-uu_sleep-devel.sha256sum] = "6dcc094c941d08f1312bd1feb21588ab92782343be5ebd525ec14af2aec08a42"

RDEPENDS:rust-uu_sleep+default-devel = " \
 cargo \
 rust-uu_sleep-devel \
 "
RDEPENDS:rust-uu_sleep-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+parser-devel \
 "
