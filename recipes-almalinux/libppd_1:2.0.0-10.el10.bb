# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libppd"
PE = "1"
PV = "2.0.0"
PR = "10.el10"
PACKAGES = " \
 libppd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libppd-2.0.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf6d899d25e3e0a2e5a4b01442ae4dea68d6849cb0b6c2a9d343ee6b1b957788"

URI_x86_64_v2_libppd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libppd-2.0.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_libppd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libppd}"
SRC_URI[x86_64_v2_libppd.sha256sum] = "4c4a581c4085bdf9d8e3f422b213fee92bf9ff109cf0e2d32b81ead58c460abf"

URI_aarch64_libppd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libppd-2.0.0-10.el10.aarch64.rpm;name=aarch64_libppd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libppd}"
SRC_URI[aarch64_libppd.sha256sum] = "5a19442334b64d790b535278c6edf9372d37bcc8870225fd18669a710c919077"

RDEPENDS:libppd = " \
 cups \
 cups-libs \
 ghostscript \
 glibc \
 libcupsfilters \
 libgcc \
 libstdc++ \
 poppler-utils \
 "
