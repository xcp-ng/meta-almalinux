# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-PerlIO-via-QuotedPrint"
PV = "0.10"
PR = "511.el10"
PACKAGES = " \
 perl-PerlIO-via-QuotedPrint \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-PerlIO-via-QuotedPrint-0.10-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afce2ee316a9d9ef139803f38992354c0bee43b7475cc6f01f36e4abe7abe590"

URI_x86_64_v2_perl-PerlIO-via-QuotedPrint = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PerlIO-via-QuotedPrint-0.10-511.el10.noarch.rpm;name=x86_64_v2_perl-PerlIO-via-QuotedPrint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PerlIO-via-QuotedPrint}"
SRC_URI[x86_64_v2_perl-PerlIO-via-QuotedPrint.sha256sum] = "9ada7dfa5482247b7a3b596f8f4cb802450a4366a817730c8560bb7a8a780611"

URI_aarch64_perl-PerlIO-via-QuotedPrint = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PerlIO-via-QuotedPrint-0.10-511.el10.noarch.rpm;name=aarch64_perl-PerlIO-via-QuotedPrint;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PerlIO-via-QuotedPrint}"
SRC_URI[aarch64_perl-PerlIO-via-QuotedPrint.sha256sum] = "9ada7dfa5482247b7a3b596f8f4cb802450a4366a817730c8560bb7a8a780611"

RDEPENDS:perl-PerlIO-via-QuotedPrint = " \
 perl-MIME-Base64 \
 perl-libs \
 "
