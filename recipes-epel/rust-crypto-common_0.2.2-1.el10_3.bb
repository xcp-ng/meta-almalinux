# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crypto-common"
PV = "0.2.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-crypto-common+default-devel \
 rust-crypto-common+getrandom-devel \
 rust-crypto-common+rand_core-devel \
 rust-crypto-common+zeroize-devel \
 rust-crypto-common-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crypto-common-0.2.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6a2f4601d440c38c27be892ea7640b68a485c2adf0d1ad1469d8f229eba34b3"

URI_x86_64_v2_rust-crypto-common+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+default-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+default-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+default-devel.sha256sum] = "28403eecc16ea0503190e924b35d5b47dddb77cc6f2183eae3bc5fc152885ee2"

URI_x86_64_v2_rust-crypto-common+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+getrandom-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+getrandom-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+getrandom-devel.sha256sum] = "41e47e9c124a3c73c3f6e48b780885f31905cf774f99cfea58a6a1690dde246e"

URI_x86_64_v2_rust-crypto-common+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+rand_core-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+rand_core-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+rand_core-devel.sha256sum] = "526f72634e6741c45b3570c9a4f3d1dc0f5704dc2aef777367d4d5abd507f05e"

URI_x86_64_v2_rust-crypto-common+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+zeroize-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+zeroize-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+zeroize-devel.sha256sum] = "01848674a7247f32c04d0b1680007f6da04f74238a9f252eb8bb989e8d1d97a3"

URI_x86_64_v2_rust-crypto-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common-devel}"
SRC_URI[x86_64_v2_rust-crypto-common-devel.sha256sum] = "cf66803aa9c19b26fa93362940c14d74ce6225c555137d9bca8194e18210e30f"

URI_aarch64_rust-crypto-common+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+default-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+default-devel}"
SRC_URI[aarch64_rust-crypto-common+default-devel.sha256sum] = "ddcc195fcc6b81331db1735a39933d793be9a3d2f9695003824d08a889396a0f"

URI_aarch64_rust-crypto-common+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+getrandom-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-common+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+getrandom-devel}"
SRC_URI[aarch64_rust-crypto-common+getrandom-devel.sha256sum] = "f9dde9da9238bdee1f1df1723c50f2952fcacde1559adefbc2ee4af3282c8df4"

URI_aarch64_rust-crypto-common+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+rand_core-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-common+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+rand_core-devel}"
SRC_URI[aarch64_rust-crypto-common+rand_core-devel.sha256sum] = "703d64ded2403003f06cfb2cd9d64f8adf7005251865157fab89f3619aee6896"

URI_aarch64_rust-crypto-common+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+zeroize-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-common+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+zeroize-devel}"
SRC_URI[aarch64_rust-crypto-common+zeroize-devel.sha256sum] = "4ec0b059a829687315b769a532793949ca35458b720f08219f7b62206e1bc14b"

URI_aarch64_rust-crypto-common-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-crypto-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common-devel}"
SRC_URI[aarch64_rust-crypto-common-devel.sha256sum] = "a054bdae6ad64757a5abe416f3b1c16017f3725c13c38021ff28fd2c55eb08a1"

RDEPENDS:rust-crypto-common+default-devel = " \
 cargo \
 rust-crypto-common-devel \
 "
RDEPENDS:rust-crypto-common+getrandom-devel = " \
 cargo \
 rust-crypto-common+rand_core-devel \
 rust-crypto-common-devel \
 rust-getrandom+default-devel \
 rust-getrandom+sys_rng-devel \
 "
RDEPENDS:rust-crypto-common+rand_core-devel = " \
 cargo \
 rust-crypto-common-devel \
 rust-rand_core+default-devel \
 "
RDEPENDS:rust-crypto-common+zeroize-devel = " \
 cargo \
 rust-crypto-common-devel \
 rust-hybrid-array+zeroize-devel \
 "
RDEPENDS:rust-crypto-common-devel = " \
 cargo \
 rust \
 rust-hybrid-array+default-devel \
 "
