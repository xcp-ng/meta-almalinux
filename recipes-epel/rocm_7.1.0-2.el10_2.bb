# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm"
PV = "7.1.0"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 rocm \
 rocm-devel \
 rocm-test \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-7.1.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3411b52579de19539e1e2102c4d7ba10f0fcae8f9ff8d1ee2261d0d5ccd29a8e"

URI_x86_64_v2_rocm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-7.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rocm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm}"
SRC_URI[x86_64_v2_rocm.sha256sum] = "993f8fb4f4a3e37c9b0553003567cf54019882a538c842b489e3d6037dbaddf6"

URI_x86_64_v2_rocm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-devel-7.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rocm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-devel}"
SRC_URI[x86_64_v2_rocm-devel.sha256sum] = "8b72547e637536e459499fe036fe8567a6e8261a9cb016fc297c455cc2efe0bc"

URI_x86_64_v2_rocm-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-test-7.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rocm-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-test}"
SRC_URI[x86_64_v2_rocm-test.sha256sum] = "f43c73c4f036b05f93a786d6bdddb38af94bb2d132f5cf92a809d2f684b4c8c5"

RDEPENDS:rocm = " \
 amdsmi \
 hipblas \
 hipcc \
 hipfft \
 hiprand \
 hipsolver \
 hipsparse \
 rocblas \
 rocfft \
 rocm-clang \
 rocm-hip \
 rocm-runtime \
 rocm-smi \
 rocminfo \
 rocrand \
 rocsolver \
 rocsparse \
 "
RDEPENDS:rocm-devel = " \
 amdsmi-devel \
 half-devel \
 hipblas-common-devel \
 hipblas-devel \
 hipcub-devel \
 hipfft-devel \
 hiprand-devel \
 hipsolver-devel \
 hipsparse-devel \
 rocblas-devel \
 rocfft-devel \
 rocm-clang-devel \
 rocm-cmake \
 rocm-compilersupport-macros \
 rocm-hip-devel \
 rocm-rpm-macros \
 rocm-rpm-macros-modules \
 rocm-runtime-devel \
 rocm-smi-devel \
 rocprim-devel \
 rocrand-devel \
 rocsolver-devel \
 rocsparse-devel \
 "
RDEPENDS:rocm-test = " \
 kfdtest \
 "
