# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "po-debconf"
PV = "1.0.21"
PR = "17.nmu1.el10_0"
PACKAGES = " \
 po-debconf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/po-debconf-1.0.21-17.nmu1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "548e11d9a42a01c6f31acd811b81cdd26f6912f7469984bcc45cc4fe7dc630d7"

URI_x86_64_v2_po-debconf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/po-debconf-1.0.21-17.nmu1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_po-debconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_po-debconf}"
SRC_URI[x86_64_v2_po-debconf.sha256sum] = "2d8fcfede26b77f7875441cebc94f087c47736b07f23ee9a37252fc7728fb659"

URI_aarch64_po-debconf = "${EPEL_MIRROR}/aarch64/Packages/p/po-debconf-1.0.21-17.nmu1.el10_0.noarch.rpm;name=aarch64_po-debconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_po-debconf}"
SRC_URI[aarch64_po-debconf.sha256sum] = "11cc9c7a95b7fc825cbe655ad5e2fb41ce384c09df528b5713b45263cdcd14ef"

RDEPENDS:po-debconf = " \
 bash \
 gettext \
 intltool \
 perl-interpreter \
 "
