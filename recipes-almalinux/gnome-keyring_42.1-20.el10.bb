# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-keyring"
PV = "42.1"
PR = "20.el10"
PACKAGES = " \
 gnome-keyring \
 gnome-keyring-pam \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-keyring-42.1-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a13e498e88d4ffb69d21739142743c401d9af129dbc4288993ba54db37e2b73a"

URI_x86_64_v2_gnome-keyring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-keyring-42.1-20.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-keyring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-keyring}"
SRC_URI[x86_64_v2_gnome-keyring.sha256sum] = "2370975c17dd2e068b1b24f4aabbb3a8b019172546935c22705d23ce63adc83f"

URI_x86_64_v2_gnome-keyring-pam = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-keyring-pam-42.1-20.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-keyring-pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-keyring-pam}"
SRC_URI[x86_64_v2_gnome-keyring-pam.sha256sum] = "33dae31095ee30ed2c0b41b823805952337176473d3e9c20a3c01099a26c57d0"

URI_aarch64_gnome-keyring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-keyring-42.1-20.el10.aarch64.rpm;name=aarch64_gnome-keyring;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-keyring}"
SRC_URI[aarch64_gnome-keyring.sha256sum] = "b465c219cbecc21a960a46863816ff6f446d42807627150a7ee13628381d8f2e"

URI_aarch64_gnome-keyring-pam = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-keyring-pam-42.1-20.el10.aarch64.rpm;name=aarch64_gnome-keyring-pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-keyring-pam}"
SRC_URI[aarch64_gnome-keyring-pam.sha256sum] = "6b38e3826cc78ee56e2d471250aea1b63f3220ce6b940b94a06b0bf780301292"

RDEPENDS:gnome-keyring = " \
 bash \
 gcr3 \
 gcr3-base \
 glib2 \
 glibc \
 libgcrypt \
 openssh-clients \
 systemd-libs \
 "
RDEPENDS:gnome-keyring-pam = " \
 glibc \
 gnome-keyring \
 libselinux \
 pam \
 pam-libs \
 "
