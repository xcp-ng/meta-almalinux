# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-machines"
PV = "328.2"
PR = "1.el10_0"
PACKAGES = " \
 cockpit-machines \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-machines-328.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fae80128f82ba91b1c38e9eaecaec7b117af5e2b2b930cd440e3563c4cd84ab9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-machines-328.2-1.el10_0.noarch.rpm;name=x86_64_v2_cockpit-machines;unpack=0"
SRC_URI[x86_64_v2_cockpit-machines.sha256sum] = "e0a79838d51c53d20a7d6b7676dd9cafe121681ab13a40136d6805c4666b4325"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-machines-328.2-1.el10_0.noarch.rpm;name=aarch64_cockpit-machines;unpack=0"
SRC_URI[aarch64_cockpit-machines.sha256sum] = "e0a79838d51c53d20a7d6b7676dd9cafe121681ab13a40136d6805c4666b4325"

RDEPENDS:cockpit-machines = " \
 cockpit-bridge \
 libvirt-client \
 libvirt-daemon-config-network \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-storage-core \
 libvirt-dbus \
 qemu-kvm \
 virt-install \
 "
