# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "layer-shell-qt"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 layer-shell-qt \
 layer-shell-qt-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/layer-shell-qt-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1d7c33fb0339f9b3eb4f528d4b194890e54697e56046039e06711b09a58b5cbe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/layer-shell-qt-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_layer-shell-qt;unpack=0"
SRC_URI[x86_64_v2_layer-shell-qt.sha256sum] = "113d58987d2ef32e2e3b6a589896c28d9bf2c43123b6dee281c9bff3bbf54a42"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/layer-shell-qt-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_layer-shell-qt-devel;unpack=0"
SRC_URI[x86_64_v2_layer-shell-qt-devel.sha256sum] = "fab57e87a0a6d3d47ba131a6dbfa5050b5b957ab600c7010701f5bbea075f53c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/layer-shell-qt-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_layer-shell-qt;unpack=0"
SRC_URI[aarch64_layer-shell-qt.sha256sum] = "d705a307386f532d33810711fe69bb7548075c4d22542cc5db9a25a36c144cb8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/layer-shell-qt-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_layer-shell-qt-devel;unpack=0"
SRC_URI[aarch64_layer-shell-qt-devel.sha256sum] = "4b6de6e1c2cdaff7e298654ea0862f36e87c822f1e48ba7a46633db1114c814e"

RDEPENDS:layer-shell-qt = " \
 glibc \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:layer-shell-qt-devel = " \
 cmake-filesystem \
 layer-shell-qt \
 qt6-qtbase-devel \
 "
