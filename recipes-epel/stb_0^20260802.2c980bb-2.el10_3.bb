# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stb"
PV = "0^20260802.2c980bb"
PR = "2.el10_3"
PACKAGES = " \
 stb-devel \
 stb-doc \
 stb_c_lexer-devel \
 stb_connected_components-devel \
 stb_divide-devel \
 stb_ds-devel \
 stb_dxt-devel \
 stb_easy_font-devel \
 stb_herringbone_wang_tile-devel \
 stb_hexwave-devel \
 stb_image-devel \
 stb_image_resize-devel \
 stb_image_resize2-devel \
 stb_image_write-devel \
 stb_leakcheck-devel \
 stb_perlin-devel \
 stb_rect_pack-devel \
 stb_sprintf-devel \
 stb_textedit-devel \
 stb_tilemap_editor-devel \
 stb_truetype-devel \
 stb_vorbis-devel \
 stb_voxel_render-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/stb-0^20260802.2c980bb-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8c72d87ce6d8ba64adc4defb76b326993f974c836d1580b0358b47ccf40d391f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb-devel-0^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb-devel;unpack=0"
SRC_URI[x86_64_v2_stb-devel.sha256sum] = "a5de2050a740cfce034f8d5cc3ec603ae007200e618ca4a40d16ec130af2e34e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb-doc-0^20260802.2c980bb-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_stb-doc;unpack=0"
SRC_URI[x86_64_v2_stb-doc.sha256sum] = "aada8073e7a1809430c14fd62e55c831e5b7f4efd823c6e900d20009a02050b1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_c_lexer-devel-0.12^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_c_lexer-devel;unpack=0"
SRC_URI[x86_64_v2_stb_c_lexer-devel.sha256sum] = "b1fae1ce36fdc4cda09a8c1c0a577d94660ee49723c30074ac43354a0f49deb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_connected_components-devel-0.96^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_connected_components-devel;unpack=0"
SRC_URI[x86_64_v2_stb_connected_components-devel.sha256sum] = "826235878d9a4ea55a6f066fa803a8d76794a25635a5cc02cdb1e3a2b2d0342e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_divide-devel-0.94^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_divide-devel;unpack=0"
SRC_URI[x86_64_v2_stb_divide-devel.sha256sum] = "a9a1a3a6512a47bdd02b6d9972c0542cd4d75866bdaf6bc8a0a2d986b1cd60d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_ds-devel-0.67^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_ds-devel;unpack=0"
SRC_URI[x86_64_v2_stb_ds-devel.sha256sum] = "220506573a03dfda74b77c754ebd88fbe0c395f1a9d42b710384c0a28e4f6138"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_dxt-devel-1.12^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_dxt-devel;unpack=0"
SRC_URI[x86_64_v2_stb_dxt-devel.sha256sum] = "c38b4844c130b235be33eddf40036d7ea63bc7abe5fe5505710679cc2ac0adac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_easy_font-devel-1.1^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_easy_font-devel;unpack=0"
SRC_URI[x86_64_v2_stb_easy_font-devel.sha256sum] = "11e3cc9cb9ba8e8ad59c2f8cd8de6f921d3d6fcf20d2122faa8b6190e5a72865"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_herringbone_wang_tile-devel-0.7^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_herringbone_wang_tile-devel;unpack=0"
SRC_URI[x86_64_v2_stb_herringbone_wang_tile-devel.sha256sum] = "2e34b5161e006aff201d00e4d438e0b65359125f849719c0a4c3b76cea93e062"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_hexwave-devel-0.5^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_hexwave-devel;unpack=0"
SRC_URI[x86_64_v2_stb_hexwave-devel.sha256sum] = "15d6e94f1301437458c81294dc060203466f720af60ea29a5d7857f17d7713d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image-devel-2.30^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image-devel;unpack=0"
SRC_URI[x86_64_v2_stb_image-devel.sha256sum] = "05b5331954634c59acb717626555922af8a537abf6e6c55d29e4256f63fc668b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_resize-devel-0.97^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_resize-devel;unpack=0"
SRC_URI[x86_64_v2_stb_image_resize-devel.sha256sum] = "074eff5b4c3ef5443a60e4c50dac9d2151f93d5b0b084c20b9fec29ff10bc411"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_resize2-devel-2.18^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_resize2-devel;unpack=0"
SRC_URI[x86_64_v2_stb_image_resize2-devel.sha256sum] = "9ac978b602b8380ff8afd8addec615f5fbecc23716c64c0148039dacdb374d64"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_write-devel-1.16^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_write-devel;unpack=0"
SRC_URI[x86_64_v2_stb_image_write-devel.sha256sum] = "7aa5487e7973976e99b12bfd28ddc91dbfa7e595bbde2deb00f04b38a7928ed5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_leakcheck-devel-0.6^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_leakcheck-devel;unpack=0"
SRC_URI[x86_64_v2_stb_leakcheck-devel.sha256sum] = "306744418652086502001acaed1c11b9bc452b336dc0c151033ecec76a80fee4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_perlin-devel-0.5^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_perlin-devel;unpack=0"
SRC_URI[x86_64_v2_stb_perlin-devel.sha256sum] = "678e62a312ea57f813055a4804f78e95ecec097c68ab1b84361df36a31649fb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_rect_pack-devel-1.1^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_rect_pack-devel;unpack=0"
SRC_URI[x86_64_v2_stb_rect_pack-devel.sha256sum] = "9339a381cae03f89c232198fe4e94f7d74307a2489f017952454becaf7e3bddd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_sprintf-devel-1.10^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_sprintf-devel;unpack=0"
SRC_URI[x86_64_v2_stb_sprintf-devel.sha256sum] = "163c555005ef75048013027a3b3c55658ab79dbbc1078ef60fcb08c07c632d8c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_textedit-devel-1.14^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_textedit-devel;unpack=0"
SRC_URI[x86_64_v2_stb_textedit-devel.sha256sum] = "70eb88abdf8ad810a2d18eb4a040b8f0a6ebf3839253ee963788477af7e5d6f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_tilemap_editor-devel-0.42^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_tilemap_editor-devel;unpack=0"
SRC_URI[x86_64_v2_stb_tilemap_editor-devel.sha256sum] = "8510fd4d014508ee461da895ef49fb6b4a2c347ab060fc2abba56b8b71fb3697"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_truetype-devel-1.26^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_truetype-devel;unpack=0"
SRC_URI[x86_64_v2_stb_truetype-devel.sha256sum] = "e491dd640e4d025bcc89e08a3991e49132e1637015de3137dc9eda7b5e2ce009"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_vorbis-devel-1.22^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_vorbis-devel;unpack=0"
SRC_URI[x86_64_v2_stb_vorbis-devel.sha256sum] = "881f8b39bcd78e9e193b832e304eb9cdc3fe63a289dba03c9086f44775aafba6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_voxel_render-devel-0.89^20260802.2c980bb-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_voxel_render-devel;unpack=0"
SRC_URI[x86_64_v2_stb_voxel_render-devel.sha256sum] = "19ca0d3441b88e02aeb1c74adf6a62965ea8dde9dd861061c83c3d519cb11b5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb-devel-0^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb-devel;unpack=0"
SRC_URI[aarch64_stb-devel.sha256sum] = "e0cd1c8d7c7c1fb9fe4dab658728207a1719624cc1ecdef0835d2723e5391d7f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb-doc-0^20260802.2c980bb-2.el10_3.noarch.rpm;name=aarch64_stb-doc;unpack=0"
SRC_URI[aarch64_stb-doc.sha256sum] = "3d954e645cccb611caa3d393cd48c26e5151809cecbc49042460f57d4e928cf7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_c_lexer-devel-0.12^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_c_lexer-devel;unpack=0"
SRC_URI[aarch64_stb_c_lexer-devel.sha256sum] = "b5bc09095566a7d5e3686a3312ae2c40642d9e2f8a131bc22768c93ccbdf057c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_connected_components-devel-0.96^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_connected_components-devel;unpack=0"
SRC_URI[aarch64_stb_connected_components-devel.sha256sum] = "bc02824110b0ddf3e6cc9d772cc6778930c42ed20c867b016325f94041a678d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_divide-devel-0.94^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_divide-devel;unpack=0"
SRC_URI[aarch64_stb_divide-devel.sha256sum] = "808f14a9fffa97e433ad2d90a1b5843d4de2e7a1563f9cfcbd726784db2b4dc2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_ds-devel-0.67^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_ds-devel;unpack=0"
SRC_URI[aarch64_stb_ds-devel.sha256sum] = "6aa0eb427c4135ffd9f206b283a7cd9889d32ab4ac74ddf290fa260bf6800369"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_dxt-devel-1.12^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_dxt-devel;unpack=0"
SRC_URI[aarch64_stb_dxt-devel.sha256sum] = "da90f9a65bcfc569fcf43bd21d1226d9f8b5b8059ce1e11b0850a86cded8a327"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_easy_font-devel-1.1^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_easy_font-devel;unpack=0"
SRC_URI[aarch64_stb_easy_font-devel.sha256sum] = "705d5ced5c492b6c0c1b98029daeef480bdfb18ad62fb5b69783114783bba7e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_herringbone_wang_tile-devel-0.7^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_herringbone_wang_tile-devel;unpack=0"
SRC_URI[aarch64_stb_herringbone_wang_tile-devel.sha256sum] = "9daef302efc4efb81d574862019608527267015d1ee302b944febd65c400b095"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_hexwave-devel-0.5^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_hexwave-devel;unpack=0"
SRC_URI[aarch64_stb_hexwave-devel.sha256sum] = "c89b244ccb48638d0e663191f5f4a1f00f15f751c221d9f8fb1afcb36efb2cab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_image-devel-2.30^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_image-devel;unpack=0"
SRC_URI[aarch64_stb_image-devel.sha256sum] = "589bace69612f0c845d370509a976aefb0ee7f7067753b5d118bceff81527e67"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_image_resize-devel-0.97^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_image_resize-devel;unpack=0"
SRC_URI[aarch64_stb_image_resize-devel.sha256sum] = "5957e48e37d9b8998ac542b00fc894dc4ed127bd6e584ef5fa03c92d001398bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_image_resize2-devel-2.18^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_image_resize2-devel;unpack=0"
SRC_URI[aarch64_stb_image_resize2-devel.sha256sum] = "35e2b2a693504f6cdbcbb8751232f589f477b1048c42e56541235190c093addb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_image_write-devel-1.16^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_image_write-devel;unpack=0"
SRC_URI[aarch64_stb_image_write-devel.sha256sum] = "602731b2a86c09be3fb2252ac5f16e9402713dff72e882ec2d00460be866bd24"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_leakcheck-devel-0.6^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_leakcheck-devel;unpack=0"
SRC_URI[aarch64_stb_leakcheck-devel.sha256sum] = "a2df05b32a8c8e4bb042964d98ad15e61db5c87d41e15f82329db90cd1dae2f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_perlin-devel-0.5^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_perlin-devel;unpack=0"
SRC_URI[aarch64_stb_perlin-devel.sha256sum] = "0cd3607282f0576a689196ad1bb9f7c96560b8cf0841e1fd1e78c7158ee00a38"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_rect_pack-devel-1.1^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_rect_pack-devel;unpack=0"
SRC_URI[aarch64_stb_rect_pack-devel.sha256sum] = "92e3e624cfba14e576f9a23cacd4e4f48013e1864492498a1e921ed149ad974e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_sprintf-devel-1.10^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_sprintf-devel;unpack=0"
SRC_URI[aarch64_stb_sprintf-devel.sha256sum] = "022861930f1d2700d4de40befc2648414de847b0928cf14d6d548bc9fe5dba0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_textedit-devel-1.14^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_textedit-devel;unpack=0"
SRC_URI[aarch64_stb_textedit-devel.sha256sum] = "ae168e7fea277bc35af471b0f1e3a3fc21b581774129c4721a2cc2bb8e4506d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_tilemap_editor-devel-0.42^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_tilemap_editor-devel;unpack=0"
SRC_URI[aarch64_stb_tilemap_editor-devel.sha256sum] = "59732b5e2302db360d0628d6c4c2870db70b1a39b5704bd27ede731229325e44"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_truetype-devel-1.26^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_truetype-devel;unpack=0"
SRC_URI[aarch64_stb_truetype-devel.sha256sum] = "97c5c4c9c7659b11e55f3f2e822b2ac62ccf20dccb1f2ee71e5de68b16d52494"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_vorbis-devel-1.22^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_vorbis-devel;unpack=0"
SRC_URI[aarch64_stb_vorbis-devel.sha256sum] = "20f01a84e439395a5bd31520658b587716aee2d2d4f0bd44755f308024bbf229"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stb_voxel_render-devel-0.89^20260802.2c980bb-2.el10_3.aarch64.rpm;name=aarch64_stb_voxel_render-devel;unpack=0"
SRC_URI[aarch64_stb_voxel_render-devel.sha256sum] = "5a056d2d5df20e1087d9d44d7bd7a6f0f3871337350fdc799624d3a9e8429e7b"

RDEPENDS:stb-devel = " \
 stb_c_lexer-devel \
 stb_connected_components-devel \
 stb_divide-devel \
 stb_ds-devel \
 stb_dxt-devel \
 stb_easy_font-devel \
 stb_herringbone_wang_tile-devel \
 stb_hexwave-devel \
 stb_image-devel \
 stb_image_resize2-devel \
 stb_image_write-devel \
 stb_leakcheck-devel \
 stb_perlin-devel \
 stb_rect_pack-devel \
 stb_sprintf-devel \
 stb_textedit-devel \
 stb_tilemap_editor-devel \
 stb_truetype-devel \
 stb_vorbis-devel \
 stb_voxel_render-devel \
 "
RDEPENDS:stb-doc = " \
 "
RDEPENDS:stb_c_lexer-devel = " \
 "
RDEPENDS:stb_connected_components-devel = " \
 "
RDEPENDS:stb_divide-devel = " \
 "
RDEPENDS:stb_ds-devel = " \
 "
RDEPENDS:stb_dxt-devel = " \
 "
RDEPENDS:stb_easy_font-devel = " \
 "
RDEPENDS:stb_herringbone_wang_tile-devel = " \
 "
RDEPENDS:stb_hexwave-devel = " \
 "
RDEPENDS:stb_image-devel = " \
 "
RDEPENDS:stb_image_resize-devel = " \
 "
RDEPENDS:stb_image_resize2-devel = " \
 "
RDEPENDS:stb_image_write-devel = " \
 "
RDEPENDS:stb_leakcheck-devel = " \
 "
RDEPENDS:stb_perlin-devel = " \
 "
RDEPENDS:stb_rect_pack-devel = " \
 "
RDEPENDS:stb_sprintf-devel = " \
 "
RDEPENDS:stb_textedit-devel = " \
 "
RDEPENDS:stb_tilemap_editor-devel = " \
 "
RDEPENDS:stb_truetype-devel = " \
 "
RDEPENDS:stb_vorbis-devel = " \
 "
RDEPENDS:stb_voxel_render-devel = " \
 "
