# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apache-commons-cli"
PV = "1.6.0"
PR = "6.el10"
PACKAGES = " \
 apache-commons-cli \
 apache-commons-cli-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/apache-commons-cli-1.6.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2d07a331697c837cbed13fa4ba3cb8ca003dfe177f08d791d181fb011c05193"

URI_x86_64_v2_apache-commons-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apache-commons-cli-1.6.0-6.el10.noarch.rpm;name=x86_64_v2_apache-commons-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-cli}"
SRC_URI[x86_64_v2_apache-commons-cli.sha256sum] = "b8ee3cb004963d02e09cd9bfbf7de6309acfbeee715061e6432fb353ab282411"

URI_x86_64_v2_apache-commons-cli-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-cli-javadoc-1.6.0-6.el10.noarch.rpm;name=x86_64_v2_apache-commons-cli-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-cli-javadoc}"
SRC_URI[x86_64_v2_apache-commons-cli-javadoc.sha256sum] = "f09c21817095b9b17793a2f0530f8c8c73c494cf70a4e62d2dead37c6235e36f"

URI_aarch64_apache-commons-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apache-commons-cli-1.6.0-6.el10.noarch.rpm;name=aarch64_apache-commons-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-cli}"
SRC_URI[aarch64_apache-commons-cli.sha256sum] = "b8ee3cb004963d02e09cd9bfbf7de6309acfbeee715061e6432fb353ab282411"

URI_aarch64_apache-commons-cli-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-cli-javadoc-1.6.0-6.el10.noarch.rpm;name=aarch64_apache-commons-cli-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-cli-javadoc}"
SRC_URI[aarch64_apache-commons-cli-javadoc.sha256sum] = "f09c21817095b9b17793a2f0530f8c8c73c494cf70a4e62d2dead37c6235e36f"

RDEPENDS:apache-commons-cli = " \
 javapackages-filesystem \
 "
RDEPENDS:apache-commons-cli-javadoc = " \
 javapackages-filesystem \
 "
