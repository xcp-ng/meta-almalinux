# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-slog"
PV = "2.7.0"
PR = "11.el10_0"
PACKAGES = " \
 rust-slog+default-devel \
 rust-slog+dynamic-keys-devel \
 rust-slog+erased-serde-devel \
 rust-slog+max_level_debug-devel \
 rust-slog+max_level_error-devel \
 rust-slog+max_level_info-devel \
 rust-slog+max_level_off-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+max_level_warn-devel \
 rust-slog+nested-values-devel \
 rust-slog+nothreads-devel \
 rust-slog+release_max_level_debug-devel \
 rust-slog+release_max_level_error-devel \
 rust-slog+release_max_level_info-devel \
 rust-slog+release_max_level_off-devel \
 rust-slog+release_max_level_trace-devel \
 rust-slog+release_max_level_warn-devel \
 rust-slog+std-devel \
 rust-slog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-slog-2.7.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66e4191b94989ae439819c006b73d6ece1b07ca16f3cae1e7e63bb58b438dfa1"

URI_x86_64_v2_rust-slog+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+default-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+default-devel}"
SRC_URI[x86_64_v2_rust-slog+default-devel.sha256sum] = "ca25488876f259cf7ee7fdc6e938b54db791f126af91b432ece5fda0d142a139"

URI_x86_64_v2_rust-slog+dynamic-keys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+dynamic-keys-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+dynamic-keys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+dynamic-keys-devel}"
SRC_URI[x86_64_v2_rust-slog+dynamic-keys-devel.sha256sum] = "388f3cd7d7f7a6b342bb9d5ccfa47648ebfcd99a1869a0a6bddc578d823a1101"

URI_x86_64_v2_rust-slog+erased-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+erased-serde-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+erased-serde-devel}"
SRC_URI[x86_64_v2_rust-slog+erased-serde-devel.sha256sum] = "b891830f7c6dfd400b0cf63cb12dae227357ffa03b927b07c9af68b8819b7216"

URI_x86_64_v2_rust-slog+max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+max_level_debug-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-slog+max_level_debug-devel.sha256sum] = "374ff8e417965c95e01f48de10ecaa49015d19f0580c4b8e821f5916df2f3996"

URI_x86_64_v2_rust-slog+max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+max_level_error-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+max_level_error-devel}"
SRC_URI[x86_64_v2_rust-slog+max_level_error-devel.sha256sum] = "bd3a6b4b22374a321280018dfab05cd965cc9b04c42092d8ea25e2e46924096e"

URI_x86_64_v2_rust-slog+max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+max_level_info-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+max_level_info-devel}"
SRC_URI[x86_64_v2_rust-slog+max_level_info-devel.sha256sum] = "8d694795fb4cff5ec69f3cf093c75d2c99aa0b9cc89903cd3b19a7da2a72713e"

URI_x86_64_v2_rust-slog+max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+max_level_off-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+max_level_off-devel}"
SRC_URI[x86_64_v2_rust-slog+max_level_off-devel.sha256sum] = "37ddaa2229ca8b3bc6b673019178796fe2f5c8344270fe6506652693355ba6dc"

URI_x86_64_v2_rust-slog+max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+max_level_trace-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-slog+max_level_trace-devel.sha256sum] = "c24c25b81e07b7c889e6f17a8c067d50e59f6dfcd3d2bf39155d8858153d8fd9"

URI_x86_64_v2_rust-slog+max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+max_level_warn-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-slog+max_level_warn-devel.sha256sum] = "a4e29655491bcc51d7dc8ed27e6819c492ca4c88eb3138e1523cf5cef3baac98"

URI_x86_64_v2_rust-slog+nested-values-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+nested-values-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+nested-values-devel}"
SRC_URI[x86_64_v2_rust-slog+nested-values-devel.sha256sum] = "c8f020bc242f20fb173e56e3fd35a5390ef1ce24939117801e688109569fc535"

URI_x86_64_v2_rust-slog+nothreads-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+nothreads-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+nothreads-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+nothreads-devel}"
SRC_URI[x86_64_v2_rust-slog+nothreads-devel.sha256sum] = "5e5f8d705da2f2567fac00ea4333a749530573c1e617a3f90a460691857c3f71"

URI_x86_64_v2_rust-slog+release_max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+release_max_level_debug-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+release_max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-slog+release_max_level_debug-devel.sha256sum] = "af37da04d392419613662420783ab32480f2707df8d2a95c3d0627ec83289a1a"

URI_x86_64_v2_rust-slog+release_max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+release_max_level_error-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+release_max_level_error-devel}"
SRC_URI[x86_64_v2_rust-slog+release_max_level_error-devel.sha256sum] = "48439ad32f92eae83b62c9e16d71c86eb53807a467d4867b6fd20c2f4e4ab7c2"

URI_x86_64_v2_rust-slog+release_max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+release_max_level_info-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+release_max_level_info-devel}"
SRC_URI[x86_64_v2_rust-slog+release_max_level_info-devel.sha256sum] = "945d909c563949184a0ffc47f1996c68db87737f7365319f402bc691d4196562"

URI_x86_64_v2_rust-slog+release_max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+release_max_level_off-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+release_max_level_off-devel}"
SRC_URI[x86_64_v2_rust-slog+release_max_level_off-devel.sha256sum] = "556758cb4c8a2b2157baf1bf6e5d9fdd288063582f7e1952bd4a2ebf2a3f7210"

URI_x86_64_v2_rust-slog+release_max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+release_max_level_trace-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+release_max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-slog+release_max_level_trace-devel.sha256sum] = "fc33b2780a412f89105c34037bf32b2cbde9a1070a72e776376f9b12828f07bb"

URI_x86_64_v2_rust-slog+release_max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+release_max_level_warn-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+release_max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-slog+release_max_level_warn-devel.sha256sum] = "234b4d4261649ac3b9c791917b17d25b191fae2d349cf77a9d0532913835c9d6"

URI_x86_64_v2_rust-slog+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+std-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+std-devel}"
SRC_URI[x86_64_v2_rust-slog+std-devel.sha256sum] = "3dc6191079b2ba2a6bb28b7c1ecaa5e5e23d33652474bee443e810145a0e2c24"

URI_x86_64_v2_rust-slog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-devel-2.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-devel}"
SRC_URI[x86_64_v2_rust-slog-devel.sha256sum] = "a3e05a33dde8adbcfa7b506433360daafbc8479c0d17d077d95cb784ed500606"

URI_aarch64_rust-slog+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+default-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+default-devel}"
SRC_URI[aarch64_rust-slog+default-devel.sha256sum] = "0d668c01afd9249d3e297cde88c30abe92c9182b6aa0a952319ab733aa7b2525"

URI_aarch64_rust-slog+dynamic-keys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+dynamic-keys-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+dynamic-keys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+dynamic-keys-devel}"
SRC_URI[aarch64_rust-slog+dynamic-keys-devel.sha256sum] = "aec2e15afff7510060966af7b797c43ca82feffb9271a6e9dbf77624dee21096"

URI_aarch64_rust-slog+erased-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+erased-serde-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+erased-serde-devel}"
SRC_URI[aarch64_rust-slog+erased-serde-devel.sha256sum] = "9005ec4992b633da7c26849a1470935fad9ad9fea579745163849ac9986422ea"

URI_aarch64_rust-slog+max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+max_level_debug-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+max_level_debug-devel}"
SRC_URI[aarch64_rust-slog+max_level_debug-devel.sha256sum] = "d627e91a7818604a9193641898609ff4bfe66050312a7e3f3d212b164831701f"

URI_aarch64_rust-slog+max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+max_level_error-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+max_level_error-devel}"
SRC_URI[aarch64_rust-slog+max_level_error-devel.sha256sum] = "2e45941425b88e4982a5941b3f09141a5c3551d1483f9a120b5e77fd52b8990b"

URI_aarch64_rust-slog+max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+max_level_info-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+max_level_info-devel}"
SRC_URI[aarch64_rust-slog+max_level_info-devel.sha256sum] = "4b5e79ab259cb87d4a1454dc4f2712d0cff0f80a72559b6ae094035128e790ce"

URI_aarch64_rust-slog+max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+max_level_off-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+max_level_off-devel}"
SRC_URI[aarch64_rust-slog+max_level_off-devel.sha256sum] = "c732cfa8772886d927c4bd6c05d9f67aaf41cd9d89ecab0d3a93ecd967e3c16b"

URI_aarch64_rust-slog+max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+max_level_trace-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+max_level_trace-devel}"
SRC_URI[aarch64_rust-slog+max_level_trace-devel.sha256sum] = "3fed5a65f08e26220945994e55ea7acd000a45c42d2c7c9f463aab892e7eedda"

URI_aarch64_rust-slog+max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+max_level_warn-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+max_level_warn-devel}"
SRC_URI[aarch64_rust-slog+max_level_warn-devel.sha256sum] = "96c9022ae9ade65070f47fa3d1b2d3493bf740c8110b4e3baf5148fea6a10858"

URI_aarch64_rust-slog+nested-values-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+nested-values-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+nested-values-devel}"
SRC_URI[aarch64_rust-slog+nested-values-devel.sha256sum] = "9ad255efae5af9bfa98629ad4c2a5fb6b84b602bc21a32b03dfe6f8e0812b49e"

URI_aarch64_rust-slog+nothreads-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+nothreads-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+nothreads-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+nothreads-devel}"
SRC_URI[aarch64_rust-slog+nothreads-devel.sha256sum] = "78270fc05328c7ef49892880c59e3d34a1ba91e5c539360404f154954a0eb535"

URI_aarch64_rust-slog+release_max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+release_max_level_debug-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+release_max_level_debug-devel}"
SRC_URI[aarch64_rust-slog+release_max_level_debug-devel.sha256sum] = "608c3d84b67367a3f743fdff86f85500a874914a91c2a1998eb526b3323deaaa"

URI_aarch64_rust-slog+release_max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+release_max_level_error-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+release_max_level_error-devel}"
SRC_URI[aarch64_rust-slog+release_max_level_error-devel.sha256sum] = "1b8e5c5e157585cf2562692b4720b115aca16c7fd06ea8121589726924c4da34"

URI_aarch64_rust-slog+release_max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+release_max_level_info-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+release_max_level_info-devel}"
SRC_URI[aarch64_rust-slog+release_max_level_info-devel.sha256sum] = "fc391c806ef72c60aca0895b403d00cbb429fd88bf0565de422e194fd962074a"

URI_aarch64_rust-slog+release_max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+release_max_level_off-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+release_max_level_off-devel}"
SRC_URI[aarch64_rust-slog+release_max_level_off-devel.sha256sum] = "1178044c2beeedd16d5b966b314bd24be9527a57e9a3b9b004de196b6110cc78"

URI_aarch64_rust-slog+release_max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+release_max_level_trace-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+release_max_level_trace-devel}"
SRC_URI[aarch64_rust-slog+release_max_level_trace-devel.sha256sum] = "9edc9fbc9a052b8c72852873936ed26696ba1586362500f2621a7b6018acde81"

URI_aarch64_rust-slog+release_max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+release_max_level_warn-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+release_max_level_warn-devel}"
SRC_URI[aarch64_rust-slog+release_max_level_warn-devel.sha256sum] = "82c0206965f3608328538cc6f45c01f642c3998a5a09f84d9cb4c98589a0a450"

URI_aarch64_rust-slog+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+std-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+std-devel}"
SRC_URI[aarch64_rust-slog+std-devel.sha256sum] = "0310ace01ff2ff64bd7b017e01ca95db469e207131436eba7f281ed0e166512c"

URI_aarch64_rust-slog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-devel-2.7.0-11.el10_0.noarch.rpm;name=aarch64_rust-slog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-devel}"
SRC_URI[aarch64_rust-slog-devel.sha256sum] = "34161ab45faa4491d816ee4e78a62c124f225e00cb139f8cddb8380c0a6ca296"

RDEPENDS:rust-slog+default-devel = " \
 cargo \
 rust-slog+std-devel \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+dynamic-keys-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+erased-serde-devel = " \
 cargo \
 rust-erased-serde0.3+default-devel \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+max_level_debug-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+max_level_error-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+max_level_info-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+max_level_off-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+max_level_trace-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+max_level_warn-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+nested-values-devel = " \
 cargo \
 rust-slog+erased-serde-devel \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+nothreads-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+release_max_level_debug-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+release_max_level_error-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+release_max_level_info-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+release_max_level_off-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+release_max_level_trace-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+release_max_level_warn-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+std-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog-devel = " \
 cargo \
 "
