# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glfw"
PE = "1"
PV = "3.4"
PR = "4.el10_1"
PACKAGES = " \
 glfw \
 glfw-devel \
 glfw-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glfw-3.4-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3781ef2b213cca257013b75e56bb7c6dd1d193326aad3f91f31bfc0d54929979"

URI_x86_64_v2_glfw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glfw-3.4-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glfw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glfw}"
SRC_URI[x86_64_v2_glfw.sha256sum] = "069dace0599e6e93109b7aa31975a37d98d5fed42f592aac3cb88268a125e7a1"

URI_x86_64_v2_glfw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glfw-devel-3.4-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glfw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glfw-devel}"
SRC_URI[x86_64_v2_glfw-devel.sha256sum] = "1062feb64a1eb362546061d253734341b6bd8a40487e3fa6178b51ca35a2116a"

URI_x86_64_v2_glfw-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glfw-doc-3.4-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_glfw-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glfw-doc}"
SRC_URI[x86_64_v2_glfw-doc.sha256sum] = "56af4cb0e99c2cb08d45a67c9d7492e03ef4ab7a0e125edf17d8a21790e68822"

URI_aarch64_glfw = "${EPEL_MIRROR}/aarch64/Packages/g/glfw-3.4-4.el10_1.aarch64.rpm;name=aarch64_glfw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glfw}"
SRC_URI[aarch64_glfw.sha256sum] = "03b5a6665fd7616fa9e1f0a73e8c7f0f54cc6178434d36e906572b5e065d1a30"

URI_aarch64_glfw-devel = "${EPEL_MIRROR}/aarch64/Packages/g/glfw-devel-3.4-4.el10_1.aarch64.rpm;name=aarch64_glfw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glfw-devel}"
SRC_URI[aarch64_glfw-devel.sha256sum] = "b6b2314c2be076ff416ec2f544daa08f60448372caeb4c346a35b4a2ed030b52"

URI_aarch64_glfw-doc = "${EPEL_MIRROR}/aarch64/Packages/g/glfw-doc-3.4-4.el10_1.noarch.rpm;name=aarch64_glfw-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glfw-doc}"
SRC_URI[aarch64_glfw-doc.sha256sum] = "24e6b086b3323c3038fb815bfe3d0f1c750bb44b14b773fa4861c0f598fb0cce"

RDEPENDS:glfw = " \
 glibc \
 "
RDEPENDS:glfw-devel = " \
 cmake-filesystem \
 glfw \
 libX11-devel \
 libXcursor-devel \
 libXi-devel \
 libXinerama-devel \
 libXrandr-devel \
 mesa-libGL-devel \
 mesa-libGLU-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:glfw-doc = " \
 "
