# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khelpcenter"
PE = "1"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 khelpcenter \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/khelpcenter-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "faa079fb231a2a12878910dbd8800f62bd7db9c5d5a117c3bd624973a0cc3cfc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khelpcenter-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khelpcenter;unpack=0"
SRC_URI[x86_64_v2_khelpcenter.sha256sum] = "580a8f34c4a29cc9ba11b2d5041eddb3c3a20d7520acdfd1b3614d963ee22ecb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/khelpcenter-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_khelpcenter;unpack=0"
SRC_URI[aarch64_khelpcenter.sha256sum] = "a4229e7e94da53ccf688a3ab76e1d6cca0f8139e9a8c03bc6ba8dbd5ac2b9202"

RDEPENDS:khelpcenter = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdoctools \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kservice \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 libxml2 \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 xapian-core-libs \
 "
