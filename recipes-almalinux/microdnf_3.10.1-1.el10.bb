# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "microdnf"
PV = "3.10.1"
PR = "1.el10"
PACKAGES = " \
 microdnf \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/microdnf-3.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f8dae2f9005c8e808fd9fc43802cf68147602f54ef8db9c45c9f8213889efcf"

URI_x86_64_v2_microdnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/microdnf-3.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_microdnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_microdnf}"
SRC_URI[x86_64_v2_microdnf.sha256sum] = "3aa3b23db616429a1533d583e1e8bfbcd1a6358a5a3dbb236c6282836730d5f2"

URI_aarch64_microdnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/microdnf-3.10.1-1.el10.aarch64.rpm;name=aarch64_microdnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_microdnf}"
SRC_URI[aarch64_microdnf.sha256sum] = "f50cb6122221b4eace81ffbd78dc9e1c2c4b8ecbdcd8dc944072a30a5b77ec28"

RDEPENDS:microdnf = " \
 dnf-data \
 glib2 \
 glibc \
 libdnf \
 libgcc \
 libpeas1 \
 libsmartcols \
 rpm-libs \
 "
