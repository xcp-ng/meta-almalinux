# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ocean-sound-theme"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 ocean-sound-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/ocean-sound-theme-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf80c698c78ab2af57841690ed011b41c2426c0fc972b6b2712da5b7d7602acc"

URI_x86_64_v2_ocean-sound-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ocean-sound-theme-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ocean-sound-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocean-sound-theme}"
SRC_URI[x86_64_v2_ocean-sound-theme.sha256sum] = "dc84e571b1399f60e6163fb14fa437b964bf08bfebfa74396d4711bee378cafc"

URI_aarch64_ocean-sound-theme = "${EPEL_MIRROR}/aarch64/Packages/o/ocean-sound-theme-6.4.5-1.el10_1.noarch.rpm;name=aarch64_ocean-sound-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocean-sound-theme}"
SRC_URI[aarch64_ocean-sound-theme.sha256sum] = "a3efbf4317015c835a9bc7ff9ba791fd22739ea8c093360c901960b7a72f8bd3"

RDEPENDS:ocean-sound-theme = " \
 kf6-filesystem \
 "
