# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libcramjam"
PV = "0.7.0"
PR = "7.el10_1"
PACKAGES = " \
 rust-libcramjam+brotli-devel \
 rust-libcramjam+bzip2-devel \
 rust-libcramjam+capi-devel \
 rust-libcramjam+default-devel \
 rust-libcramjam+deflate-devel \
 rust-libcramjam+deflate-shared-devel \
 rust-libcramjam+gzip-devel \
 rust-libcramjam+gzip-shared-devel \
 rust-libcramjam+lz4-devel \
 rust-libcramjam+snappy-devel \
 rust-libcramjam+xz-devel \
 rust-libcramjam+xz-shared-devel \
 rust-libcramjam+zlib-devel \
 rust-libcramjam+zlib-shared-devel \
 rust-libcramjam+zstd-devel \
 rust-libcramjam-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libcramjam-0.7.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84f5a953e291b5a85a63ecea8fcf0ee24ca9cefb6e910277d3181446f4a5fc98"

URI_x86_64_v2_rust-libcramjam+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+brotli-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+brotli-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+brotli-devel.sha256sum] = "f441d2b70f9a10971b24fe196375f4d30393790f08765f71edc2d9ee69d41f67"

URI_x86_64_v2_rust-libcramjam+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+bzip2-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+bzip2-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+bzip2-devel.sha256sum] = "f918f84222984cfec007fbc27bdb0471383255c436318b3c1987331907f76078"

URI_x86_64_v2_rust-libcramjam+capi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+capi-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+capi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+capi-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+capi-devel.sha256sum] = "8e631171770701f67ae6cde5ad635ceb60dd801752554c910cba4500e19e1ea1"

URI_x86_64_v2_rust-libcramjam+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+default-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+default-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+default-devel.sha256sum] = "ce0cbb6fa5bf48a06ace955db18c08b1ed81379fe14130055071c1b8047c6071"

URI_x86_64_v2_rust-libcramjam+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+deflate-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+deflate-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+deflate-devel.sha256sum] = "b656bdfd8e501566af1037e6b5bedecaabd1e692b3798e491d816d1bad791b8c"

URI_x86_64_v2_rust-libcramjam+deflate-shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+deflate-shared-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+deflate-shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+deflate-shared-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+deflate-shared-devel.sha256sum] = "62f5884f59bb2c243a25f2fd3bd5fdbcf042c867fc4ae06bb03ec353b0a23f37"

URI_x86_64_v2_rust-libcramjam+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+gzip-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+gzip-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+gzip-devel.sha256sum] = "d61df08aaea1b0a466907c2fa1e9821fd0ee96554089e5bdad2be9244d1d90ba"

URI_x86_64_v2_rust-libcramjam+gzip-shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+gzip-shared-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+gzip-shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+gzip-shared-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+gzip-shared-devel.sha256sum] = "708cb17e6fd02a4ccb75c8665f88583f7d1fdebfdb2a4e1e9c4af66403a8ded0"

URI_x86_64_v2_rust-libcramjam+lz4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+lz4-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+lz4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+lz4-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+lz4-devel.sha256sum] = "d79422aaba5df1588abec9edf726c38d4b2bcbf72f82b73a11cb73d932d2864d"

URI_x86_64_v2_rust-libcramjam+snappy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+snappy-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+snappy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+snappy-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+snappy-devel.sha256sum] = "647ad822e084606e4c3932462587c2336b870f2a4fabe56c29bf55dbacbbd5d5"

URI_x86_64_v2_rust-libcramjam+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+xz-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+xz-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+xz-devel.sha256sum] = "72d0b177bb80e20cd1dc7671cbc52664e6ef1f691607a707c2cd36f12749794a"

URI_x86_64_v2_rust-libcramjam+xz-shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+xz-shared-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+xz-shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+xz-shared-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+xz-shared-devel.sha256sum] = "26a68cd485d36065494b42dca81c803d6eb36e0e2c164881156cc65e2e189803"

URI_x86_64_v2_rust-libcramjam+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+zlib-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+zlib-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+zlib-devel.sha256sum] = "42f66ac992eabcc9e340b4eea85f25d7eb5edad7cf687bb7fd3eeafe814daaa4"

URI_x86_64_v2_rust-libcramjam+zlib-shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+zlib-shared-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+zlib-shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+zlib-shared-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+zlib-shared-devel.sha256sum] = "94190844cc7f902b038e804d7a9dfa9d8df1e262ad7e222a6ea797425efdfba3"

URI_x86_64_v2_rust-libcramjam+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+zstd-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+zstd-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+zstd-devel.sha256sum] = "46eab0589665f41b06e34027b495e3bc70b6f6ac26aceda3441bb6a63665d864"

URI_x86_64_v2_rust-libcramjam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam-devel-0.7.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam-devel}"
SRC_URI[x86_64_v2_rust-libcramjam-devel.sha256sum] = "5dbb7f6a6db93bc8205d1d6de17b350f946ab8e272463df420516fd9e8430b53"

URI_aarch64_rust-libcramjam+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+brotli-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+brotli-devel}"
SRC_URI[aarch64_rust-libcramjam+brotli-devel.sha256sum] = "85412a8f7ac36570655d98d027a34aa0b43c38027ec5254964cab518969b8630"

URI_aarch64_rust-libcramjam+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+bzip2-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+bzip2-devel}"
SRC_URI[aarch64_rust-libcramjam+bzip2-devel.sha256sum] = "a16a3f2c4eaae96079ec10d27006dc245ebbd8f429913c20c64530ea91c0b110"

URI_aarch64_rust-libcramjam+capi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+capi-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+capi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+capi-devel}"
SRC_URI[aarch64_rust-libcramjam+capi-devel.sha256sum] = "241acb2abb7306a52dd5dc0c7b3fbb06bb84fbd70800b9bf44ae632fecb99398"

URI_aarch64_rust-libcramjam+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+default-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+default-devel}"
SRC_URI[aarch64_rust-libcramjam+default-devel.sha256sum] = "ad70e760da56a8e6acc384ecfc8b8553d3c19f836763e01faecc0128bce60b82"

URI_aarch64_rust-libcramjam+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+deflate-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+deflate-devel}"
SRC_URI[aarch64_rust-libcramjam+deflate-devel.sha256sum] = "648f763d9bf19ebcdf2fd5c46a6701fb21f6f9d977ecc188415768fc04df4c28"

URI_aarch64_rust-libcramjam+deflate-shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+deflate-shared-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+deflate-shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+deflate-shared-devel}"
SRC_URI[aarch64_rust-libcramjam+deflate-shared-devel.sha256sum] = "11a0e7b0e7c00a2a625b6aa02362de700834822fc0a35b05fce4645590f528cb"

URI_aarch64_rust-libcramjam+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+gzip-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+gzip-devel}"
SRC_URI[aarch64_rust-libcramjam+gzip-devel.sha256sum] = "efa5495594d2c324731b7cbd1979ad60f21fe9ddf1618192f1bbee538205d7f2"

URI_aarch64_rust-libcramjam+gzip-shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+gzip-shared-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+gzip-shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+gzip-shared-devel}"
SRC_URI[aarch64_rust-libcramjam+gzip-shared-devel.sha256sum] = "7a967b49ed9629f2725111d32476c092c12935d7c3c0894bd930853be4168bcb"

URI_aarch64_rust-libcramjam+lz4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+lz4-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+lz4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+lz4-devel}"
SRC_URI[aarch64_rust-libcramjam+lz4-devel.sha256sum] = "26c62f8b57cbf1ac43334f7d0dafbc31e226db5d4c5d1a95ff1ebc4a17bd653f"

URI_aarch64_rust-libcramjam+snappy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+snappy-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+snappy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+snappy-devel}"
SRC_URI[aarch64_rust-libcramjam+snappy-devel.sha256sum] = "03fe373f9c50ac1784e927bef0864fbcbfe0cf3387243a044e47a6c73fe07726"

URI_aarch64_rust-libcramjam+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+xz-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+xz-devel}"
SRC_URI[aarch64_rust-libcramjam+xz-devel.sha256sum] = "f7fa9a099b45438c710ad4234dca0357f0b661a578f28cc9a3cf447425a01266"

URI_aarch64_rust-libcramjam+xz-shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+xz-shared-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+xz-shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+xz-shared-devel}"
SRC_URI[aarch64_rust-libcramjam+xz-shared-devel.sha256sum] = "937ee872dab26123a54062c303c10f21e6d07ed40916b975adcdd95bdfb80e3d"

URI_aarch64_rust-libcramjam+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+zlib-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+zlib-devel}"
SRC_URI[aarch64_rust-libcramjam+zlib-devel.sha256sum] = "d7ad36a3a9c074a49affcb104e7088f418ec5f93add16280119df36804a9c6cd"

URI_aarch64_rust-libcramjam+zlib-shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+zlib-shared-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+zlib-shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+zlib-shared-devel}"
SRC_URI[aarch64_rust-libcramjam+zlib-shared-devel.sha256sum] = "e4b28ae4539b3e58f95d78a900cb852f7a31729e9e32f8aed062f762fa6c26ef"

URI_aarch64_rust-libcramjam+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+zstd-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+zstd-devel}"
SRC_URI[aarch64_rust-libcramjam+zstd-devel.sha256sum] = "e894c44aa70387c2f4224e81396779c537e208fb3414d0168416dc1a4f6ee2fa"

URI_aarch64_rust-libcramjam-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam-devel-0.7.0-7.el10_1.noarch.rpm;name=aarch64_rust-libcramjam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam-devel}"
SRC_URI[aarch64_rust-libcramjam-devel.sha256sum] = "cb99ba3a12e1fce0252a01e597aa229d6cee15213354e17bce0b83ec4ea52879"

RDEPENDS:rust-libcramjam+brotli-devel = " \
 cargo \
 rust-brotli+ffi-api-devel \
 rust-brotli+std-devel \
 rust-brotli-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+capi-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+default-devel = " \
 cargo \
 rust-libcramjam+brotli-devel \
 rust-libcramjam+bzip2-devel \
 rust-libcramjam+deflate-devel \
 rust-libcramjam+gzip-devel \
 rust-libcramjam+lz4-devel \
 rust-libcramjam+snappy-devel \
 rust-libcramjam+xz-devel \
 rust-libcramjam+zlib-devel \
 rust-libcramjam+zstd-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+deflate-devel = " \
 cargo \
 rust-libcramjam+deflate-shared-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+deflate-shared-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-libcramjam-devel \
 rust-libdeflate-sys+default-devel \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflater+default-devel \
 "
RDEPENDS:rust-libcramjam+gzip-devel = " \
 cargo \
 rust-libcramjam+gzip-shared-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+gzip-shared-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-libcramjam-devel \
 rust-libdeflate-sys+default-devel \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflater+default-devel \
 "
RDEPENDS:rust-libcramjam+lz4-devel = " \
 cargo \
 rust-libcramjam-devel \
 rust-lz4+default-devel \
 "
RDEPENDS:rust-libcramjam+snappy-devel = " \
 cargo \
 rust-libcramjam-devel \
 rust-snap+default-devel \
 "
RDEPENDS:rust-libcramjam+xz-devel = " \
 cargo \
 rust-libcramjam+xz-shared-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+xz-shared-devel = " \
 cargo \
 rust-libcramjam-devel \
 rust-xz2+default-devel \
 "
RDEPENDS:rust-libcramjam+zlib-devel = " \
 cargo \
 rust-libcramjam+zlib-shared-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+zlib-shared-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-libcramjam-devel \
 rust-libdeflate-sys+default-devel \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflater+default-devel \
 "
RDEPENDS:rust-libcramjam+zstd-devel = " \
 cargo \
 rust-libcramjam-devel \
 rust-zstd+default-devel \
 "
RDEPENDS:rust-libcramjam-devel = " \
 cargo \
 "
