# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "erfa"
PV = "2.0.1"
PR = "5.el10_0"
PACKAGES = " \
 erfa \
 erfa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/erfa-2.0.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bd9e89bcb39f8adff2dbcbbafc6f5fd6e71b0f1fb33a80ac2bee430ca4b1fd9"

URI_x86_64_v2_erfa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/erfa-2.0.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_erfa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_erfa}"
SRC_URI[x86_64_v2_erfa.sha256sum] = "4267284c3a0a520b6f69d2ff6cd08ceba830ad19a11a2299e64b20a2b527151e"

URI_x86_64_v2_erfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/erfa-devel-2.0.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_erfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_erfa-devel}"
SRC_URI[x86_64_v2_erfa-devel.sha256sum] = "4f9cf6dabec5000e85dfe99f5c790df736eb7e353ed1e909424851055533306d"

URI_aarch64_erfa = "${EPEL_MIRROR}/aarch64/Packages/e/erfa-2.0.1-5.el10_0.aarch64.rpm;name=aarch64_erfa;unpack=0"
SRC_URI:append = " ${URI_aarch64_erfa}"
SRC_URI[aarch64_erfa.sha256sum] = "f2950e495f42c47628014e7bc1718ea293d8be2327da71a13ccb3efa4fc41c91"

URI_aarch64_erfa-devel = "${EPEL_MIRROR}/aarch64/Packages/e/erfa-devel-2.0.1-5.el10_0.aarch64.rpm;name=aarch64_erfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_erfa-devel}"
SRC_URI[aarch64_erfa-devel.sha256sum] = "8a4d223d633ef314b9248c226f386f4be3cd8e72360197a3f7db42b974ad044b"

RDEPENDS:erfa = " \
 glibc \
 "
RDEPENDS:erfa-devel = " \
 erfa \
 pkgconf-pkg-config \
 "
