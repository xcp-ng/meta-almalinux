# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-gi-atk"
PV = "2.0.28"
PR = "1.el10_0"
PACKAGES = " \
 ghc-gi-atk \
 ghc-gi-atk-devel \
 ghc-gi-atk-doc \
 ghc-gi-atk-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-gi-atk-2.0.28-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "836386bf54c4b2a55f638ece3559b7cca36fdde17348196c517a59e87014912f"

URI_x86_64_v2_ghc-gi-atk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-atk-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gi-atk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-atk}"
SRC_URI[x86_64_v2_ghc-gi-atk.sha256sum] = "fa5f816300fdc8bba388f05bd7ab5a5f994c23a051d44277a78fa476c79e26ed"

URI_x86_64_v2_ghc-gi-atk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-atk-devel-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gi-atk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-atk-devel}"
SRC_URI[x86_64_v2_ghc-gi-atk-devel.sha256sum] = "25f5494b529d93fe253a8ab0614d9ee865ea8475ec94267f92536ce7231882cf"

URI_x86_64_v2_ghc-gi-atk-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-atk-doc-2.0.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-gi-atk-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-atk-doc}"
SRC_URI[x86_64_v2_ghc-gi-atk-doc.sha256sum] = "12efca6e0e16af755d9f82ab8614065646ab22ceb4534a9ee41b34d87cb2321e"

URI_x86_64_v2_ghc-gi-atk-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-atk-prof-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gi-atk-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-atk-prof}"
SRC_URI[x86_64_v2_ghc-gi-atk-prof.sha256sum] = "aaeabd31049dc570475e74d650702ba126685f0dd7a42e71a590b40e2b9644b7"

URI_aarch64_ghc-gi-atk = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-atk-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_ghc-gi-atk;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-atk}"
SRC_URI[aarch64_ghc-gi-atk.sha256sum] = "7caf1f7a8261d7e316286d7b1537e033d565d8586337366a8d6a525c8dc566ed"

URI_aarch64_ghc-gi-atk-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-atk-devel-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_ghc-gi-atk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-atk-devel}"
SRC_URI[aarch64_ghc-gi-atk-devel.sha256sum] = "14ed0cdcea398e48f02819ead42db529370dc1f5eca8b7a71714962f2a3eceb8"

URI_aarch64_ghc-gi-atk-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-atk-doc-2.0.28-1.el10_0.noarch.rpm;name=aarch64_ghc-gi-atk-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-atk-doc}"
SRC_URI[aarch64_ghc-gi-atk-doc.sha256sum] = "f434b04321762748f9117261e5f59bb3788b60970adb9b12727f7fe1f970a6fe"

URI_aarch64_ghc-gi-atk-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-atk-prof-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_ghc-gi-atk-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-atk-prof}"
SRC_URI[aarch64_ghc-gi-atk-prof.sha256sum] = "326abba0c84622fd1b0ae845845513087f08277e6132811990154b8db41869e4"

RDEPENDS:ghc-gi-atk = " \
 atk \
 ghc-Cabal \
 ghc-Cabal-syntax \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-colour \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-gi-glib \
 ghc-gi-gobject \
 ghc-hashable \
 ghc-haskell-gi \
 ghc-haskell-gi-base \
 ghc-haskell-lexer \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-pretty-show \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-xdg-basedir \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glib2 \
 glibc \
 gmp \
 gobject-introspection \
 zlib-ng-compat \
 "
RDEPENDS:ghc-gi-atk-devel = " \
 atk-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-gi-atk \
 ghc-gi-glib-devel \
 ghc-gi-gobject-devel \
 ghc-haskell-gi-base-devel \
 ghc-haskell-gi-devel \
 ghc-haskell-gi-overloading-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-gi-atk-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-gi-atk-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-gi-atk-devel \
 ghc-gi-glib-prof \
 ghc-gi-gobject-prof \
 ghc-haskell-gi-base-prof \
 ghc-haskell-gi-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 "
