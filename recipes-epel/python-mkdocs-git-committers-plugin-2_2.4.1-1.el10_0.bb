# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-git-committers-plugin-2"
PV = "2.4.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-mkdocs-git-committers-plugin-2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-git-committers-plugin-2-2.4.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55a32bb09c447b4de36f949334932752009f0a7f961f0a42ef17a4841236fa91"

URI_x86_64_v2_python3-mkdocs-git-committers-plugin-2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-git-committers-plugin-2-2.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-git-committers-plugin-2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-git-committers-plugin-2}"
SRC_URI[x86_64_v2_python3-mkdocs-git-committers-plugin-2.sha256sum] = "db584626f10c4ef73e0c1b569cdb933114a34f41e311567c7600c984eaee1ecb"

URI_aarch64_python3-mkdocs-git-committers-plugin-2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-git-committers-plugin-2-2.4.1-1.el10_0.noarch.rpm;name=aarch64_python3-mkdocs-git-committers-plugin-2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-git-committers-plugin-2}"
SRC_URI[aarch64_python3-mkdocs-git-committers-plugin-2.sha256sum] = "7005ef49f50496dd36d18b95d4a5e84a2050c2d75971eb6a9f13ef710fe3f96a"

RDEPENDS:python3-mkdocs-git-committers-plugin-2 = " \
 mkdocs \
 python3 \
 python3-GitPython \
 python3-requests \
 "
