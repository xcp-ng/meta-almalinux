# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Config-IniFiles"
PV = "3.001000"
PR = "1.el10_2"
PACKAGES = " \
 perl-Config-IniFiles \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Config-IniFiles-3.001000-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60813a6b02d9fc52842cd90ff19952a3909249b90c84b29106389928ee350a14"

URI_x86_64_v2_perl-Config-IniFiles = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Config-IniFiles-3.001000-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Config-IniFiles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Config-IniFiles}"
SRC_URI[x86_64_v2_perl-Config-IniFiles.sha256sum] = "009c06a39c850778e19ee3f9e4ef246ef0dc570bbb88c71c14ff4939e221618b"

URI_aarch64_perl-Config-IniFiles = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Config-IniFiles-3.001000-1.el10_2.noarch.rpm;name=aarch64_perl-Config-IniFiles;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Config-IniFiles}"
SRC_URI[aarch64_perl-Config-IniFiles.sha256sum] = "4dcf2eb26a50acd85bbb7667d6292dca6688ad762a28bf10a05dbbed1a11f115"

RDEPENDS:perl-Config-IniFiles = " \
 perl-Carp \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Temp \
 perl-IO-stringy \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-libs \
 perl-vars \
 "
