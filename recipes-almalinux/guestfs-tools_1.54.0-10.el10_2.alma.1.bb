# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "guestfs-tools"
PV = "1.54.0"
PR = "10.el10_2.alma.1"
PACKAGES = " \
 guestfs-tools \
 virt-win-reg \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/guestfs-tools-1.54.0-10.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79c5586d911b611b67497bc00a20661f6297648d5d005664742cbbf7b8bb2f7f"

URI_x86_64_v2_guestfs-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/guestfs-tools-1.54.0-10.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_guestfs-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guestfs-tools}"
SRC_URI[x86_64_v2_guestfs-tools.sha256sum] = "51815098649880e5371962909466aab7900bc816e531c9cf3fad90a494607436"

URI_x86_64_v2_virt-win-reg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-win-reg-1.54.0-10.el10_2.alma.1.noarch.rpm;name=x86_64_v2_virt-win-reg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-win-reg}"
SRC_URI[x86_64_v2_virt-win-reg.sha256sum] = "c48d668417eaca8169b16c60174ef1c213720163310c54c956891f76549e060b"

URI_aarch64_guestfs-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/guestfs-tools-1.54.0-10.el10_2.alma.1.aarch64.rpm;name=aarch64_guestfs-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_guestfs-tools}"
SRC_URI[aarch64_guestfs-tools.sha256sum] = "85f36838b831424f02c6ce787ddade63a8a9b833c5eeeeededf347f41bece8b0"

URI_aarch64_virt-win-reg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-win-reg-1.54.0-10.el10_2.alma.1.noarch.rpm;name=aarch64_virt-win-reg;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-win-reg}"
SRC_URI[aarch64_virt-win-reg.sha256sum] = "c48d668417eaca8169b16c60174ef1c213720163310c54c956891f76549e060b"

RDEPENDS:guestfs-tools = " \
 curl \
 glib2 \
 glibc \
 gnupg2 \
 json-c \
 libgcc \
 libguestfs \
 libosinfo \
 libvirt-libs \
 libxcrypt \
 libxml2 \
 ncurses-libs \
 pcre2 \
 qemu-img \
 xz \
 xz-libs \
 "
RDEPENDS:virt-win-reg = " \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Pod-Usage \
 perl-Sys-Guestfs \
 perl-hivex \
 perl-interpreter \
 perl-libintl-perl \
 perl-libs \
 "
