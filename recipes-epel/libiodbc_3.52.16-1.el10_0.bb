# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libiodbc"
PV = "3.52.16"
PR = "1.el10_0"
PACKAGES = " \
 libiodbc \
 libiodbc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libiodbc-3.52.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c160e8ad27b0a4d7896f7a7d8f17635c3663836f2c685e664a4f61579e90263"

URI_x86_64_v2_libiodbc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libiodbc-3.52.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libiodbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libiodbc}"
SRC_URI[x86_64_v2_libiodbc.sha256sum] = "79eb9ecb3a6fc6a6b65923ff0b65045f95ce63ccfa227c4720346e321018ed02"

URI_x86_64_v2_libiodbc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libiodbc-devel-3.52.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libiodbc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libiodbc-devel}"
SRC_URI[x86_64_v2_libiodbc-devel.sha256sum] = "b0df1131f930321993784fb39c856bf09b54e0da17a2b4a3f9bb2478adb6c948"

URI_aarch64_libiodbc = "${EPEL_MIRROR}/aarch64/Packages/l/libiodbc-3.52.16-1.el10_0.aarch64.rpm;name=aarch64_libiodbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libiodbc}"
SRC_URI[aarch64_libiodbc.sha256sum] = "cd905d43a60600ddd01097437a3ea0eab83b654e4f8ff49415bfb114b057793c"

URI_aarch64_libiodbc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libiodbc-devel-3.52.16-1.el10_0.aarch64.rpm;name=aarch64_libiodbc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libiodbc-devel}"
SRC_URI[aarch64_libiodbc-devel.sha256sum] = "7463c58a96a952350cc95b4de575d94bc8bb7c6ecc1ab485c5aee7e96bb93aca"

RDEPENDS:libiodbc = " \
 glibc \
 "
RDEPENDS:libiodbc-devel = " \
 bash \
 libiodbc \
 pkgconf-pkg-config \
 "
