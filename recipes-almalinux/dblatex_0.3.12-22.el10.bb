# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dblatex"
PV = "0.3.12"
PR = "22.el10"
PACKAGES = " \
 dblatex \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/dblatex-0.3.12-22.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "36e0ef2e21fddb9c7054b6949c0e78fc95b0744a2fcf1bbc5cf53ee52f380998"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dblatex-0.3.12-22.el10.noarch.rpm;name=x86_64_v2_dblatex;unpack=0"
SRC_URI[x86_64_v2_dblatex.sha256sum] = "57d01dd14b10f86d271da99997c2ebb8ff705cefece15750d7afbbc68281a7d6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dblatex-0.3.12-22.el10.noarch.rpm;name=aarch64_dblatex;unpack=0"
SRC_URI[aarch64_dblatex.sha256sum] = "57d01dd14b10f86d271da99997c2ebb8ff705cefece15750d7afbbc68281a7d6"

RDEPENDS:dblatex = " \
 docbook-dtds \
 libxslt \
 python3 \
 texlive-anysize \
 texlive-appendix \
 texlive-base \
 texlive-bibtopic \
 texlive-changebar \
 texlive-collection-fontsrecommended \
 texlive-collection-latex \
 texlive-collection-xetex \
 texlive-ec \
 texlive-fancybox \
 texlive-jknapltx \
 texlive-kpathsea \
 texlive-multirow \
 texlive-overpic \
 texlive-passivetex \
 texlive-pdfpages \
 texlive-stmaryrd \
 texlive-subfigure \
 texlive-wasysym \
 texlive-xmltex \
 "
