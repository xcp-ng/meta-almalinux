# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "policycoreutils"
PV = "3.9"
PR = "1.el10"
PACKAGES = " \
 policycoreutils \
 policycoreutils-dbus \
 policycoreutils-devel \
 policycoreutils-gui \
 policycoreutils-newrole \
 policycoreutils-python-utils \
 policycoreutils-restorecond \
 policycoreutils-sandbox \
 python3-policycoreutils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/policycoreutils-3.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d54aed0f7ac33b27a7ae3586bd9568b8ff2743c2fdea1eaae587a385fa6b859"

URI_x86_64_v2_policycoreutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/policycoreutils-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_policycoreutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils}"
SRC_URI[x86_64_v2_policycoreutils.sha256sum] = "b2f74e46159ee53dcf7a2294344ea21a600efc639572820b2815155f62c48836"

URI_x86_64_v2_policycoreutils-dbus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-dbus-3.9-1.el10.noarch.rpm;name=x86_64_v2_policycoreutils-dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-dbus}"
SRC_URI[x86_64_v2_policycoreutils-dbus.sha256sum] = "1da4e4a046850c37a8a895ede7723893aeac0aef54e2bf873191c1d1bd5a98de"

URI_x86_64_v2_policycoreutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-devel-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_policycoreutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-devel}"
SRC_URI[x86_64_v2_policycoreutils-devel.sha256sum] = "ca739959c93b469ed152671839684f767cf84f22b96e85ddc6a5e3384d2f6fcb"

URI_x86_64_v2_policycoreutils-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-gui-3.9-1.el10.noarch.rpm;name=x86_64_v2_policycoreutils-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-gui}"
SRC_URI[x86_64_v2_policycoreutils-gui.sha256sum] = "8c7f12c824362954921593a16e4adafc2b0e747805c458dad75179a02630326e"

URI_x86_64_v2_policycoreutils-newrole = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/policycoreutils-newrole-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_policycoreutils-newrole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-newrole}"
SRC_URI[x86_64_v2_policycoreutils-newrole.sha256sum] = "6b23e0eb33ce7e41d4e843f792903fed1cd91bb0493b27c87b9758fe190c3a6e"

URI_x86_64_v2_policycoreutils-python-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-python-utils-3.9-1.el10.noarch.rpm;name=x86_64_v2_policycoreutils-python-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-python-utils}"
SRC_URI[x86_64_v2_policycoreutils-python-utils.sha256sum] = "dd40ade51393a30b92199787a625982db024594849f11b3554bf11b625b3d7f5"

URI_x86_64_v2_policycoreutils-restorecond = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/policycoreutils-restorecond-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_policycoreutils-restorecond;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-restorecond}"
SRC_URI[x86_64_v2_policycoreutils-restorecond.sha256sum] = "630663321faaeae785eb7ea431d34a403bb4371fbcd036afa6dcfd4900735c9e"

URI_x86_64_v2_policycoreutils-sandbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-sandbox-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_policycoreutils-sandbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-sandbox}"
SRC_URI[x86_64_v2_policycoreutils-sandbox.sha256sum] = "51fbabc2e8464d3eb7b841b6f048136b411568ecb11be771d29746b24ea0e3ea"

URI_x86_64_v2_python3-policycoreutils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-policycoreutils-3.9-1.el10.noarch.rpm;name=x86_64_v2_python3-policycoreutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-policycoreutils}"
SRC_URI[x86_64_v2_python3-policycoreutils.sha256sum] = "3eb048796bce9f9ebb506d0d19325a5a9fa7c446068d48d89339ee9d26e17f01"

URI_aarch64_policycoreutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/policycoreutils-3.9-1.el10.aarch64.rpm;name=aarch64_policycoreutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils}"
SRC_URI[aarch64_policycoreutils.sha256sum] = "65a57f84feb55e07679f5973de4291cfc96a2ad11e8656d66150fc23e1b3c838"

URI_aarch64_policycoreutils-dbus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-dbus-3.9-1.el10.noarch.rpm;name=aarch64_policycoreutils-dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-dbus}"
SRC_URI[aarch64_policycoreutils-dbus.sha256sum] = "1da4e4a046850c37a8a895ede7723893aeac0aef54e2bf873191c1d1bd5a98de"

URI_aarch64_policycoreutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-devel-3.9-1.el10.aarch64.rpm;name=aarch64_policycoreutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-devel}"
SRC_URI[aarch64_policycoreutils-devel.sha256sum] = "4c5d6076eb8638f30cd2b8258c2697ebfdb81fa4e30ce93d7863d1b388fa049a"

URI_aarch64_policycoreutils-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-gui-3.9-1.el10.noarch.rpm;name=aarch64_policycoreutils-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-gui}"
SRC_URI[aarch64_policycoreutils-gui.sha256sum] = "8c7f12c824362954921593a16e4adafc2b0e747805c458dad75179a02630326e"

URI_aarch64_policycoreutils-newrole = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/policycoreutils-newrole-3.9-1.el10.aarch64.rpm;name=aarch64_policycoreutils-newrole;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-newrole}"
SRC_URI[aarch64_policycoreutils-newrole.sha256sum] = "f8680cba02a3229ea9ba74e908b149622d61a579e2d403bf9083982d4a4f84be"

URI_aarch64_policycoreutils-python-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-python-utils-3.9-1.el10.noarch.rpm;name=aarch64_policycoreutils-python-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-python-utils}"
SRC_URI[aarch64_policycoreutils-python-utils.sha256sum] = "dd40ade51393a30b92199787a625982db024594849f11b3554bf11b625b3d7f5"

URI_aarch64_policycoreutils-restorecond = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/policycoreutils-restorecond-3.9-1.el10.aarch64.rpm;name=aarch64_policycoreutils-restorecond;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-restorecond}"
SRC_URI[aarch64_policycoreutils-restorecond.sha256sum] = "1a5ae3d3ee409c8bf5c42d90ffb16568699547044168dbdb66e37c395709f9ab"

URI_aarch64_policycoreutils-sandbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-sandbox-3.9-1.el10.aarch64.rpm;name=aarch64_policycoreutils-sandbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-sandbox}"
SRC_URI[aarch64_policycoreutils-sandbox.sha256sum] = "41a2d49dfdcc2868fb74e30a96105495049ab097f7fe2fb5bacf6a17d41825ec"

URI_aarch64_python3-policycoreutils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-policycoreutils-3.9-1.el10.noarch.rpm;name=aarch64_python3-policycoreutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-policycoreutils}"
SRC_URI[aarch64_python3-policycoreutils.sha256sum] = "3eb048796bce9f9ebb506d0d19325a5a9fa7c446068d48d89339ee9d26e17f01"

RDEPENDS:policycoreutils = " \
 audit-libs \
 bash \
 diffutils \
 gawk \
 glibc \
 grep \
 libselinux \
 libselinux-utils \
 libsemanage \
 libsepol \
 rpm \
 sed \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:policycoreutils-dbus = " \
 polkit \
 python3 \
 python3-gobject-base \
 python3-policycoreutils \
 "
RDEPENDS:policycoreutils-devel = " \
 glibc \
 libselinux \
 make \
 policycoreutils-python-utils \
 python3 \
 python3-dnf \
 selinux-policy-devel \
 "
RDEPENDS:policycoreutils-gui = " \
 bash \
 gtk3 \
 policycoreutils-dbus \
 policycoreutils-devel \
 python3 \
 python3-gobject \
 python3-policycoreutils \
 "
RDEPENDS:policycoreutils-newrole = " \
 audit-libs \
 glibc \
 libcap-ng \
 libselinux \
 pam-libs \
 policycoreutils \
 "
RDEPENDS:policycoreutils-python-utils = " \
 python3 \
 python3-policycoreutils \
 "
RDEPENDS:policycoreutils-restorecond = " \
 bash \
 glib2 \
 glibc \
 libselinux \
 "
RDEPENDS:policycoreutils-sandbox = " \
 bash \
 glibc \
 libcap-ng \
 libselinux \
 python3 \
 python3-policycoreutils \
 rsync \
 "
RDEPENDS:python3-policycoreutils = " \
 checkpolicy \
 policycoreutils \
 python3 \
 python3-audit \
 python3-distro \
 python3-libselinux \
 python3-libsemanage \
 python3-setools \
 "
