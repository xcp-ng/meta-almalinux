# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stockfish"
PV = "17.1"
PR = "1.el10_1"
PACKAGES = " \
 stockfish \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stockfish-17.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02d77f89dd524974c43b7fb4a371dc94f3d6fb9778a9716821312748595d63d4"

URI_x86_64_v2_stockfish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stockfish-17.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stockfish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stockfish}"
SRC_URI[x86_64_v2_stockfish.sha256sum] = "41c1c15ed5d3aa853cc7c43e67ab9fc9bc727151f8e684696346d9348f8c8e74"

URI_aarch64_stockfish = "${EPEL_MIRROR}/aarch64/Packages/s/stockfish-17.1-1.el10_1.aarch64.rpm;name=aarch64_stockfish;unpack=0"
SRC_URI:append = " ${URI_aarch64_stockfish}"
SRC_URI[aarch64_stockfish.sha256sum] = "0bb6ead729526d1ac2a40577db1f4dfc17fa7bf7b345199850d017bf78e9f15c"

RDEPENDS:stockfish = " \
 glibc \
 libgcc \
 libstdc++ \
 "
