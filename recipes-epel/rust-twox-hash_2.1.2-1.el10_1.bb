# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-twox-hash"
PV = "2.1.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-twox-hash+alloc-devel \
 rust-twox-hash+default-devel \
 rust-twox-hash+random-devel \
 rust-twox-hash+serialize-devel \
 rust-twox-hash+std-devel \
 rust-twox-hash+xxhash32-devel \
 rust-twox-hash+xxhash3_128-devel \
 rust-twox-hash+xxhash3_64-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-twox-hash-2.1.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96e168fb1ae44e6876f1b4f11ce0b93baa01c840c24b7526975b9222547e2a6d"

URI_x86_64_v2_rust-twox-hash+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+alloc-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+alloc-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+alloc-devel.sha256sum] = "95d5c3b6d0a388d24866aecf0fcb98a073c336b0a606034a2d9c894f980f65c4"

URI_x86_64_v2_rust-twox-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+default-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+default-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+default-devel.sha256sum] = "b96ba4b44173358b32792d614cba2124c1567989bbc7075899d7493d9dfaf7c4"

URI_x86_64_v2_rust-twox-hash+random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+random-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+random-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+random-devel.sha256sum] = "c7afe5dfa841a1cde2f6dca20f87a4e45b6065c664ab4383d33ea59b04308b9d"

URI_x86_64_v2_rust-twox-hash+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+serialize-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+serialize-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+serialize-devel.sha256sum] = "e8f3e3a62a566af99fc2bb0fcb18bc928a9db88e002d02e23c527a8c91102799"

URI_x86_64_v2_rust-twox-hash+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+std-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+std-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+std-devel.sha256sum] = "2e35ea0c1e1a6f03ec7388c9c0004b7230f609e32820fe717cb3743da3765f90"

URI_x86_64_v2_rust-twox-hash+xxhash32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash32-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+xxhash32-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash32-devel.sha256sum] = "3bbed9f0d9f2d664baec7e6a8dbdc516dcec4e1d6ca0e7b9f582ff982f57ef12"

URI_x86_64_v2_rust-twox-hash+xxhash3_128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash3_128-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash3_128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+xxhash3_128-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash3_128-devel.sha256sum] = "8dde56cf27cee6d514f1c509b8bf30166060f971c054132c454ba437c2257856"

URI_x86_64_v2_rust-twox-hash+xxhash3_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash3_64-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash3_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+xxhash3_64-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash3_64-devel.sha256sum] = "85f2343bf94bef2b0956fba6895f33feaf59ed9ade1b7649d6725104440b8f51"

URI_x86_64_v2_rust-twox-hash+xxhash64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash64-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+xxhash64-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash64-devel.sha256sum] = "f23e6c9cadff38b4e6298b80ad2c9e603183cae1a7fea63a6f25dcbe0003c10f"

URI_x86_64_v2_rust-twox-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash-devel}"
SRC_URI[x86_64_v2_rust-twox-hash-devel.sha256sum] = "313c7bc2f4ac4f1736c9944147e3adc8ba9d4aaabd49a40e7f8dd53e05373ad5"

URI_aarch64_rust-twox-hash+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+alloc-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-twox-hash+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+alloc-devel}"
SRC_URI[aarch64_rust-twox-hash+alloc-devel.sha256sum] = "7f508bd7888156dcf20257b04e21f653a7a105589debcf38843b51a07dca7010"

URI_aarch64_rust-twox-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+default-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-twox-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+default-devel}"
SRC_URI[aarch64_rust-twox-hash+default-devel.sha256sum] = "9eb089583577393b1b8cd7f98b79fb0985a5a28e80baa97b7d842f505999de0a"

URI_aarch64_rust-twox-hash+random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+random-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-twox-hash+random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+random-devel}"
SRC_URI[aarch64_rust-twox-hash+random-devel.sha256sum] = "403ae305f3c35bd070e7c0cd5703777c73b2095e82fcdb08a19cc073e0b34b8d"

URI_aarch64_rust-twox-hash+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+serialize-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-twox-hash+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+serialize-devel}"
SRC_URI[aarch64_rust-twox-hash+serialize-devel.sha256sum] = "68397c12a27b12848cee750d8079e540b08668797a009521a3fd991ad22c078a"

URI_aarch64_rust-twox-hash+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+std-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-twox-hash+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+std-devel}"
SRC_URI[aarch64_rust-twox-hash+std-devel.sha256sum] = "b864f7346d143d18c904fd48468fabe25ede4edf11add5b687a66a33e9d56562"

URI_aarch64_rust-twox-hash+xxhash32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash32-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-twox-hash+xxhash32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+xxhash32-devel}"
SRC_URI[aarch64_rust-twox-hash+xxhash32-devel.sha256sum] = "9944718e764354fc1e80bebbd2d261286561e5a81f35ecc5930b1bf320906818"

URI_aarch64_rust-twox-hash+xxhash3_128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash3_128-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-twox-hash+xxhash3_128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+xxhash3_128-devel}"
SRC_URI[aarch64_rust-twox-hash+xxhash3_128-devel.sha256sum] = "2daa352a87f02c304b6c794fb844e9da81657c8c1bbcc2af693d5010b2a140e9"

URI_aarch64_rust-twox-hash+xxhash3_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash3_64-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-twox-hash+xxhash3_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+xxhash3_64-devel}"
SRC_URI[aarch64_rust-twox-hash+xxhash3_64-devel.sha256sum] = "2c315ec98581fabc949aa2abbdcc714be71183c86a87a3ac087a82ac1e77129a"

URI_aarch64_rust-twox-hash+xxhash64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash64-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-twox-hash+xxhash64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+xxhash64-devel}"
SRC_URI[aarch64_rust-twox-hash+xxhash64-devel.sha256sum] = "b03536b75a60daf426b66003df84c0a10cc071109d5533b13b5067df161a0957"

URI_aarch64_rust-twox-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-twox-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash-devel}"
SRC_URI[aarch64_rust-twox-hash-devel.sha256sum] = "e5e07d6e8d89731b77aada5628d8a175cb677f9f0bf7a6e20d08484dedcd03aa"

RDEPENDS:rust-twox-hash+alloc-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+default-devel = " \
 cargo \
 rust-twox-hash+random-devel \
 rust-twox-hash+std-devel \
 rust-twox-hash+xxhash32-devel \
 rust-twox-hash+xxhash3_128-devel \
 rust-twox-hash+xxhash3_64-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+random-devel = " \
 cargo \
 rust-rand+thread_rng-devel \
 rust-rand-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+serialize-devel = " \
 cargo \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+std-devel = " \
 cargo \
 rust-twox-hash+alloc-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash32-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash3_128-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash3_64-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash64-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash-devel = " \
 cargo \
 rust \
 "
