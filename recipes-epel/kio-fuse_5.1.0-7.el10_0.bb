# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-fuse"
PV = "5.1.0"
PR = "7.el10_0"
PACKAGES = " \
 kio-fuse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kio-fuse-5.1.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0aee734247c35c647658d0e81da89724895b66ac2bba98e09cafa3b1535ef0c"

URI_x86_64_v2_kio-fuse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-fuse-5.1.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-fuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-fuse}"
SRC_URI[x86_64_v2_kio-fuse.sha256sum] = "733ee2966d0d561d2a3e864bdf3f369c11af67fb8efb173c86aada814a5ac1a2"

URI_aarch64_kio-fuse = "${EPEL_MIRROR}/aarch64/Packages/k/kio-fuse-5.1.0-7.el10_0.aarch64.rpm;name=aarch64_kio-fuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-fuse}"
SRC_URI[aarch64_kio-fuse.sha256sum] = "9c243e0316f71a2c69cc1ade9387a53af578a7028ca864e6c41029b223893713"

RDEPENDS:kio-fuse = " \
 dbus-common \
 fuse3-libs \
 glibc \
 kf6-kcoreaddons \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 systemd \
 "
