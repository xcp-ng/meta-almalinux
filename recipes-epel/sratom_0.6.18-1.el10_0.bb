# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sratom"
PV = "0.6.18"
PR = "1.el10_0"
PACKAGES = " \
 sratom \
 sratom-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sratom-0.6.18-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f8340f5b92711aff4a37cde73833518bdd26c4f8a1a2e5f53648b7ddbbdc291f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sratom-0.6.18-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sratom;unpack=0"
SRC_URI[x86_64_v2_sratom.sha256sum] = "e8528c53931cd8cae35a43f4c6e4c71a4c099cf5b927208318bb15d0d9d368bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sratom-devel-0.6.18-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sratom-devel;unpack=0"
SRC_URI[x86_64_v2_sratom-devel.sha256sum] = "90d2a319609b78ed767aa295104a453f53eee80d1583205134a94b50599f39c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sratom-0.6.18-1.el10_0.aarch64.rpm;name=aarch64_sratom;unpack=0"
SRC_URI[aarch64_sratom.sha256sum] = "93d775bdf22bdbb2c1d6b49d986737a6174dd0db0c2c1aa846db401b2a0a6332"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sratom-devel-0.6.18-1.el10_0.aarch64.rpm;name=aarch64_sratom-devel;unpack=0"
SRC_URI[aarch64_sratom-devel.sha256sum] = "fc71d74957275f4403cf00c893681bafd6d6dcfc80a9ae1b91807dc069f640a8"

RDEPENDS:sratom = " \
 glibc \
 serd \
 sord \
 "
RDEPENDS:sratom-devel = " \
 lv2-devel \
 pkgconf-pkg-config \
 serd-devel \
 sord-devel \
 sratom \
 "
