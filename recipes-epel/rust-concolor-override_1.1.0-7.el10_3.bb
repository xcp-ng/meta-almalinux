# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-concolor-override"
PV = "1.1.0"
PR = "7.el10_3"
PACKAGES = " \
 rust-concolor-override+default-devel \
 rust-concolor-override-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-concolor-override-1.1.0-7.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88669befbd7738e0b36d8ee9930c8b3a9901b6a6896e8d7762463abe5611eab3"

URI_x86_64_v2_rust-concolor-override+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor-override+default-devel-1.1.0-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor-override+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor-override+default-devel}"
SRC_URI[x86_64_v2_rust-concolor-override+default-devel.sha256sum] = "ef6e796877dec8bd06f5a4aff2da61aeb067579ac6635889b1eb4165ed3077ac"

URI_x86_64_v2_rust-concolor-override-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concolor-override-devel-1.1.0-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concolor-override-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concolor-override-devel}"
SRC_URI[x86_64_v2_rust-concolor-override-devel.sha256sum] = "484c7594326b152a26754233829ae5fe7797446779d20ba95540c167705399a7"

URI_aarch64_rust-concolor-override+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor-override+default-devel-1.1.0-7.el10_3.noarch.rpm;name=aarch64_rust-concolor-override+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor-override+default-devel}"
SRC_URI[aarch64_rust-concolor-override+default-devel.sha256sum] = "f25a1398f81d19048e75cae1375ebc65aebd2a3ecf45a0b750dc206084fa1ddb"

URI_aarch64_rust-concolor-override-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concolor-override-devel-1.1.0-7.el10_3.noarch.rpm;name=aarch64_rust-concolor-override-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concolor-override-devel}"
SRC_URI[aarch64_rust-concolor-override-devel.sha256sum] = "14ee4fcbec3c9fdcffcb78482fdf4eec24228da96d49928270c8ccdc8f63a345"

RDEPENDS:rust-concolor-override+default-devel = " \
 cargo \
 rust-concolor-override-devel \
 "
RDEPENDS:rust-concolor-override-devel = " \
 cargo \
 rust \
 rust-colorchoice+default-devel \
 "
