# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gssdp"
PV = "1.6.3"
PR = "1.el10_0"
PACKAGES = " \
 gssdp \
 gssdp-devel \
 gssdp-docs \
 gssdp-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gssdp-1.6.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45022b3c59c36f5ad8df581054039f6fe85e77a8b9eff23125e28a2becc84640"

URI_x86_64_v2_gssdp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gssdp-1.6.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gssdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gssdp}"
SRC_URI[x86_64_v2_gssdp.sha256sum] = "0edfef4dd14ab7b8ddd5646a882c5426e402ecf6537db7dbdd04e744c58a7d18"

URI_x86_64_v2_gssdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gssdp-devel-1.6.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gssdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gssdp-devel}"
SRC_URI[x86_64_v2_gssdp-devel.sha256sum] = "628c912e9281ba41d0ace6f054d5ea82128f7764550a24e48862cbd8d7b865b2"

URI_x86_64_v2_gssdp-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gssdp-docs-1.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gssdp-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gssdp-docs}"
SRC_URI[x86_64_v2_gssdp-docs.sha256sum] = "5d8f7478b833f74af9133795e7aa65435547f04ef7a8b8c703ec56bb32e9654f"

URI_x86_64_v2_gssdp-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gssdp-utils-1.6.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gssdp-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gssdp-utils}"
SRC_URI[x86_64_v2_gssdp-utils.sha256sum] = "e5fae7dac803a629aa3c9e136289ab22d6d4310d4be918aa7dff8f4dffe87014"

URI_aarch64_gssdp = "${EPEL_MIRROR}/aarch64/Packages/g/gssdp-1.6.3-1.el10_0.aarch64.rpm;name=aarch64_gssdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_gssdp}"
SRC_URI[aarch64_gssdp.sha256sum] = "d9e3ac93d0a39695ee104363f8b7a004fd9da636a58a83c0c9eea690d265f185"

URI_aarch64_gssdp-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gssdp-devel-1.6.3-1.el10_0.aarch64.rpm;name=aarch64_gssdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gssdp-devel}"
SRC_URI[aarch64_gssdp-devel.sha256sum] = "431cececb20a837e796c655417462b942647ccf1d6034323185c0ed28f1df750"

URI_aarch64_gssdp-docs = "${EPEL_MIRROR}/aarch64/Packages/g/gssdp-docs-1.6.3-1.el10_0.noarch.rpm;name=aarch64_gssdp-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gssdp-docs}"
SRC_URI[aarch64_gssdp-docs.sha256sum] = "2cf1afbf9545fe8c0f505b613d0b1eb1028a36b0e0a8f38a1a1faab2627477e8"

URI_aarch64_gssdp-utils = "${EPEL_MIRROR}/aarch64/Packages/g/gssdp-utils-1.6.3-1.el10_0.aarch64.rpm;name=aarch64_gssdp-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_gssdp-utils}"
SRC_URI[aarch64_gssdp-utils.sha256sum] = "017e3818853d4a8b0a753ab368362f811aabae09afb7a79e85f528032b52cc34"

RDEPENDS:gssdp = " \
 glib2 \
 glibc \
 libsoup3 \
 "
RDEPENDS:gssdp-devel = " \
 glib2-devel \
 gssdp \
 libsoup3-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gssdp-docs = " \
 gssdp \
 "
RDEPENDS:gssdp-utils = " \
 glib2 \
 glibc \
 gssdp \
 gtk4 \
 libsoup3 \
 "
