# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Encode-JIS2K"
PV = "0.05"
PR = "9.el10_2"
PACKAGES = " \
 perl-Encode-JIS2K \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Encode-JIS2K-0.05-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47bc470dbe8f75da1e77a3c28d07a8ed6700202133ed8997eee5597535480e4f"

URI_x86_64_v2_perl-Encode-JIS2K = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Encode-JIS2K-0.05-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Encode-JIS2K;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Encode-JIS2K}"
SRC_URI[x86_64_v2_perl-Encode-JIS2K.sha256sum] = "20530eb6c77ee60966fe90d83ba4033124986363300b96c688967e8802ba94d3"

URI_aarch64_perl-Encode-JIS2K = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Encode-JIS2K-0.05-9.el10_2.aarch64.rpm;name=aarch64_perl-Encode-JIS2K;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Encode-JIS2K}"
SRC_URI[aarch64_perl-Encode-JIS2K.sha256sum] = "be2b05c20a70a4bd95d3c686fa23fa38c4e5d2124109d62bcf40d927f82ea0ab"

RDEPENDS:perl-Encode-JIS2K = " \
 glibc \
 perl-Encode \
 perl-Encode-JIS2K \
 perl-base \
 perl-libs \
 "
