# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-winnow"
PV = "0.7.13"
PR = "3.el10_0"
PACKAGES = " \
 rust-winnow+alloc-devel \
 rust-winnow+debug-devel \
 rust-winnow+default-devel \
 rust-winnow+simd-devel \
 rust-winnow+std-devel \
 rust-winnow+unstable-doc-devel \
 rust-winnow+unstable-recover-devel \
 rust-winnow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-winnow-0.7.13-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcbb8476098c548e0d29016dfcf5aa7d6e7f51e332ca452b55edf169310d24ae"

URI_x86_64_v2_rust-winnow+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+alloc-devel-0.7.13-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+alloc-devel}"
SRC_URI[x86_64_v2_rust-winnow+alloc-devel.sha256sum] = "5ae633fc3229969860bd50abb4c9f918f0009a3fd1fa90859deed0f4fb6062c5"

URI_x86_64_v2_rust-winnow+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+debug-devel-0.7.13-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+debug-devel}"
SRC_URI[x86_64_v2_rust-winnow+debug-devel.sha256sum] = "f78497ca7929fb5676be6c22d0e43abe85a042f39f1bd277cd5fdc1743ff9553"

URI_x86_64_v2_rust-winnow+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+default-devel-0.7.13-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+default-devel}"
SRC_URI[x86_64_v2_rust-winnow+default-devel.sha256sum] = "5c9b3aa595ad9f5c99a29dd0bcc8e2f11399cafc1336beb1360e75b53be7d4dc"

URI_x86_64_v2_rust-winnow+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+simd-devel-0.7.13-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+simd-devel}"
SRC_URI[x86_64_v2_rust-winnow+simd-devel.sha256sum] = "52eb1c96b08433b05f8847c91b54967d9732be9e70f572537af09690090611ac"

URI_x86_64_v2_rust-winnow+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+std-devel-0.7.13-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+std-devel}"
SRC_URI[x86_64_v2_rust-winnow+std-devel.sha256sum] = "b14be98c8f87779afd32def985e724b04bb0226e48ca2d0e505f679bbdea2d08"

URI_x86_64_v2_rust-winnow+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+unstable-doc-devel-0.7.13-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-winnow+unstable-doc-devel.sha256sum] = "3de374e5fcdefaad11dc39cc5546cc20fccfcb570ac2dd5e003144f2e5afacfc"

URI_x86_64_v2_rust-winnow+unstable-recover-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow+unstable-recover-devel-0.7.13-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow+unstable-recover-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow+unstable-recover-devel}"
SRC_URI[x86_64_v2_rust-winnow+unstable-recover-devel.sha256sum] = "00c44dd16766a80ae6c61f946dfaf435eee0f64637c89a426d5d7b8173fa7d3a"

URI_x86_64_v2_rust-winnow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow-devel-0.7.13-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow-devel}"
SRC_URI[x86_64_v2_rust-winnow-devel.sha256sum] = "13d99b7ae2f47a74ab96dee30c3471df2d18740adaf6dab9a87c8fe79381f33a"

URI_aarch64_rust-winnow+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+alloc-devel-0.7.13-3.el10_0.noarch.rpm;name=aarch64_rust-winnow+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+alloc-devel}"
SRC_URI[aarch64_rust-winnow+alloc-devel.sha256sum] = "b014e3093b04b783955ad7116c68a4db547e2095fbe25726fc78bc2695328476"

URI_aarch64_rust-winnow+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+debug-devel-0.7.13-3.el10_0.noarch.rpm;name=aarch64_rust-winnow+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+debug-devel}"
SRC_URI[aarch64_rust-winnow+debug-devel.sha256sum] = "239cab1486b98d3675f583f14b9e5ca5ed39e6204d45026a3c8bbca2f9649459"

URI_aarch64_rust-winnow+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+default-devel-0.7.13-3.el10_0.noarch.rpm;name=aarch64_rust-winnow+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+default-devel}"
SRC_URI[aarch64_rust-winnow+default-devel.sha256sum] = "c6ffc06c516890e14d022255f4b0838eae9a6bbe37ab2462ff34613ca3e7d051"

URI_aarch64_rust-winnow+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+simd-devel-0.7.13-3.el10_0.noarch.rpm;name=aarch64_rust-winnow+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+simd-devel}"
SRC_URI[aarch64_rust-winnow+simd-devel.sha256sum] = "a9236ebc085147c4649e3790ed1657c6e869847d4551335789ebb2e4f9224799"

URI_aarch64_rust-winnow+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+std-devel-0.7.13-3.el10_0.noarch.rpm;name=aarch64_rust-winnow+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+std-devel}"
SRC_URI[aarch64_rust-winnow+std-devel.sha256sum] = "b789384caab65d33da2d8853b3dfbb605788e7c7005054011f9c592479f193bc"

URI_aarch64_rust-winnow+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+unstable-doc-devel-0.7.13-3.el10_0.noarch.rpm;name=aarch64_rust-winnow+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+unstable-doc-devel}"
SRC_URI[aarch64_rust-winnow+unstable-doc-devel.sha256sum] = "29748bd7d05086defd6c77497f3e17246dfd1d4a79fe7e30ae14028e8f3a7baa"

URI_aarch64_rust-winnow+unstable-recover-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow+unstable-recover-devel-0.7.13-3.el10_0.noarch.rpm;name=aarch64_rust-winnow+unstable-recover-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow+unstable-recover-devel}"
SRC_URI[aarch64_rust-winnow+unstable-recover-devel.sha256sum] = "d4f6ed184e09201cf39ca2e20d18f7ada08b6b2eceac57b7242ee7cc545799b9"

URI_aarch64_rust-winnow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow-devel-0.7.13-3.el10_0.noarch.rpm;name=aarch64_rust-winnow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow-devel}"
SRC_URI[aarch64_rust-winnow-devel.sha256sum] = "930174542be265308590947646bf889ef95d5caee9c5ee74a856d83c7c9a0611"

RDEPENDS:rust-winnow+alloc-devel = " \
 cargo \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+debug-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-terminal_size+default-devel \
 rust-winnow+std-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+default-devel = " \
 cargo \
 rust-winnow+std-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+simd-devel = " \
 cargo \
 rust-memchr-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-winnow+alloc-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+unstable-doc-devel = " \
 cargo \
 rust-winnow+alloc-devel \
 rust-winnow+simd-devel \
 rust-winnow+std-devel \
 rust-winnow+unstable-recover-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow+unstable-recover-devel = " \
 cargo \
 rust-winnow-devel \
 "
RDEPENDS:rust-winnow-devel = " \
 cargo \
 rust \
 "
