# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc9.6"
PV = "9.6.7"
PR = "24.el10_0"
PACKAGES = " \
 ghc9.6 \
 ghc9.6-Cabal \
 ghc9.6-Cabal-devel \
 ghc9.6-Cabal-doc \
 ghc9.6-Cabal-prof \
 ghc9.6-Cabal-syntax \
 ghc9.6-Cabal-syntax-devel \
 ghc9.6-Cabal-syntax-doc \
 ghc9.6-Cabal-syntax-prof \
 ghc9.6-array \
 ghc9.6-array-devel \
 ghc9.6-array-doc \
 ghc9.6-array-prof \
 ghc9.6-base \
 ghc9.6-base-devel \
 ghc9.6-base-doc \
 ghc9.6-base-prof \
 ghc9.6-binary \
 ghc9.6-binary-devel \
 ghc9.6-binary-doc \
 ghc9.6-binary-prof \
 ghc9.6-bytestring \
 ghc9.6-bytestring-devel \
 ghc9.6-bytestring-doc \
 ghc9.6-bytestring-prof \
 ghc9.6-compiler \
 ghc9.6-compiler-default \
 ghc9.6-containers \
 ghc9.6-containers-devel \
 ghc9.6-containers-doc \
 ghc9.6-containers-prof \
 ghc9.6-deepseq \
 ghc9.6-deepseq-devel \
 ghc9.6-deepseq-doc \
 ghc9.6-deepseq-prof \
 ghc9.6-devel \
 ghc9.6-directory \
 ghc9.6-directory-devel \
 ghc9.6-directory-doc \
 ghc9.6-directory-prof \
 ghc9.6-doc \
 ghc9.6-doc-index \
 ghc9.6-exceptions \
 ghc9.6-exceptions-devel \
 ghc9.6-exceptions-doc \
 ghc9.6-exceptions-prof \
 ghc9.6-filepath \
 ghc9.6-filepath-devel \
 ghc9.6-filepath-doc \
 ghc9.6-filepath-prof \
 ghc9.6-filesystem \
 ghc9.6-ghc \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-bignum-devel \
 ghc9.6-ghc-bignum-doc \
 ghc9.6-ghc-bignum-prof \
 ghc9.6-ghc-boot \
 ghc9.6-ghc-boot-devel \
 ghc9.6-ghc-boot-doc \
 ghc9.6-ghc-boot-prof \
 ghc9.6-ghc-boot-th \
 ghc9.6-ghc-boot-th-devel \
 ghc9.6-ghc-boot-th-doc \
 ghc9.6-ghc-boot-th-prof \
 ghc9.6-ghc-compact \
 ghc9.6-ghc-compact-devel \
 ghc9.6-ghc-compact-doc \
 ghc9.6-ghc-compact-prof \
 ghc9.6-ghc-devel \
 ghc9.6-ghc-doc \
 ghc9.6-ghc-heap \
 ghc9.6-ghc-heap-devel \
 ghc9.6-ghc-heap-doc \
 ghc9.6-ghc-heap-prof \
 ghc9.6-ghc-prof \
 ghc9.6-ghci \
 ghc9.6-ghci-devel \
 ghc9.6-ghci-doc \
 ghc9.6-ghci-prof \
 ghc9.6-hadrian \
 ghc9.6-haskeline \
 ghc9.6-haskeline-devel \
 ghc9.6-haskeline-doc \
 ghc9.6-haskeline-prof \
 ghc9.6-hpc \
 ghc9.6-hpc-devel \
 ghc9.6-hpc-doc \
 ghc9.6-hpc-prof \
 ghc9.6-libiserv \
 ghc9.6-libiserv-devel \
 ghc9.6-libiserv-doc \
 ghc9.6-libiserv-prof \
 ghc9.6-manual \
 ghc9.6-mtl \
 ghc9.6-mtl-devel \
 ghc9.6-mtl-doc \
 ghc9.6-mtl-prof \
 ghc9.6-parsec \
 ghc9.6-parsec-devel \
 ghc9.6-parsec-doc \
 ghc9.6-parsec-prof \
 ghc9.6-pretty \
 ghc9.6-pretty-devel \
 ghc9.6-pretty-doc \
 ghc9.6-pretty-prof \
 ghc9.6-process \
 ghc9.6-process-devel \
 ghc9.6-process-doc \
 ghc9.6-process-prof \
 ghc9.6-prof \
 ghc9.6-stm \
 ghc9.6-stm-devel \
 ghc9.6-stm-doc \
 ghc9.6-stm-prof \
 ghc9.6-template-haskell \
 ghc9.6-template-haskell-devel \
 ghc9.6-template-haskell-doc \
 ghc9.6-template-haskell-prof \
 ghc9.6-terminfo \
 ghc9.6-terminfo-devel \
 ghc9.6-terminfo-doc \
 ghc9.6-terminfo-prof \
 ghc9.6-text \
 ghc9.6-text-devel \
 ghc9.6-text-doc \
 ghc9.6-text-prof \
 ghc9.6-time \
 ghc9.6-time-devel \
 ghc9.6-time-doc \
 ghc9.6-time-prof \
 ghc9.6-transformers \
 ghc9.6-transformers-devel \
 ghc9.6-transformers-doc \
 ghc9.6-transformers-prof \
 ghc9.6-unix \
 ghc9.6-unix-devel \
 ghc9.6-unix-doc \
 ghc9.6-unix-prof \
 ghc9.6-xhtml \
 ghc9.6-xhtml-devel \
 ghc9.6-xhtml-doc \
 ghc9.6-xhtml-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc9.6-9.6.7-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e64c69f6150b3b2de7eea37ff996840c28093af62be74ee94b37ec08c974c3be"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6;unpack=0"
SRC_URI[x86_64_v2_ghc9.6.sha256sum] = "62eb234d60e9a3ff675a8010ab622119ee2bce746e9ca222fac67ba5e03897e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-Cabal-3.10.3.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-Cabal;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-Cabal.sha256sum] = "ff7d9a23e6810f3054faccad221754632357eaf1b1d049dad61222e477c85116"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-Cabal-devel-3.10.3.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-Cabal-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-Cabal-devel.sha256sum] = "c87dddb7a2b5a498bc23f24bc04f234151a5da5591f16e750bc9ea67349d2438"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-Cabal-doc-3.10.3.0-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-Cabal-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-Cabal-doc.sha256sum] = "20884371d1bf7ef69028e0d80a26c8b4510bb844ccc8e6673d34901469cb6b48"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-Cabal-prof-3.10.3.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-Cabal-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-Cabal-prof.sha256sum] = "fea441a2b0fd9e58f3c143795df56c387c36a7d505af6b01618c08153232b487"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-Cabal-syntax-3.10.3.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-Cabal-syntax;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-Cabal-syntax.sha256sum] = "f4f2a2bdd9e5979d73cd7a65cb82778f50d250d4370dfcf2cfda6e5f220ef89b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-Cabal-syntax-devel-3.10.3.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-Cabal-syntax-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-Cabal-syntax-devel.sha256sum] = "05031a5f094516fd59789ac495c0c801c7583cddc6eea31c91b0544f5a7ad5fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-Cabal-syntax-doc-3.10.3.0-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-Cabal-syntax-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-Cabal-syntax-doc.sha256sum] = "a0f23ed9186526f29f2d176680d90588fffea3b980ad353d8aebaef9046ab477"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-Cabal-syntax-prof-3.10.3.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-Cabal-syntax-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-Cabal-syntax-prof.sha256sum] = "eb908e57f88f97f84124159ad40b86e9eee4cfc7c14f56fb3e90003ccc6fa0a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-array-0.5.8.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-array;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-array.sha256sum] = "09517a1fcae3ae21d38f304be38b61c801dab31796225d72aefb1a5b8b10f3a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-array-devel-0.5.8.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-array-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-array-devel.sha256sum] = "bbbdce7fb67c786d9ea6f6d4d60e1cb52ba6c6f0e75bf697a5eb044b5f93ebf6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-array-doc-0.5.8.0-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-array-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-array-doc.sha256sum] = "dac46b08b7a1089d75cd57e4d10efb8645057aef25d61b9272fad659b7cebc85"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-array-prof-0.5.8.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-array-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-array-prof.sha256sum] = "c2055b5c035f2278cf646e64934bfef83f2c6d77399cda5fda01e2468e9d89d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-base-4.18.3.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-base;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-base.sha256sum] = "b1ed9730b49cc00a72ec92b77369ca59136d2a046ba879ea1b46986b5006ca83"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-base-devel-4.18.3.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-base-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-base-devel.sha256sum] = "7e65cbc86f45f6a2c8e24f9f57c7c52f98a018ee57a9a619d7786e5fc7d2f0b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-base-doc-4.18.3.0-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-base-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-base-doc.sha256sum] = "9a02f038149a8d0fbd055173b76cd16a43a84d65d1d3471c13ece71dc3dc59a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-base-prof-4.18.3.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-base-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-base-prof.sha256sum] = "b1b0139af0413b50c3667e81fb3b5e0187f070443f3dcbd8bf538cd208021b4a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-binary-0.8.9.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-binary;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-binary.sha256sum] = "4b8a65dc86d635f151e3df16284a439241b935ede96411a7007d528fcfc6ff4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-binary-devel-0.8.9.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-binary-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-binary-devel.sha256sum] = "933fa64bceb84c66ba674f3c0a0aba6443fffad7775df9aedc013528061f63f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-binary-doc-0.8.9.1-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-binary-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-binary-doc.sha256sum] = "f1f81cf400975336bf91eb160f0efc57f4c362867cf876d1de2df0627d8f3dd1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-binary-prof-0.8.9.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-binary-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-binary-prof.sha256sum] = "19215a3916326285c8e47c81dada7c6a1e820b50d9f9f1119fa25b6b64527662"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-bytestring-0.11.5.4-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-bytestring;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-bytestring.sha256sum] = "cb1d9539d977aa789aed481912cf25a148c743bed67e4019f70d4a3aa550e66e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-bytestring-devel-0.11.5.4-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-bytestring-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-bytestring-devel.sha256sum] = "2b7caead4be6268fb37536f032043d99c9d30b1f8fe20b8e69d8106787d39509"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-bytestring-doc-0.11.5.4-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-bytestring-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-bytestring-doc.sha256sum] = "c918ceb54622095baf3f8ff313c5c1f57a97c041e5b31a11caf374c03f55ceee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-bytestring-prof-0.11.5.4-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-bytestring-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-bytestring-prof.sha256sum] = "7996f7eed8bdce7d58670664cb6304991bf184eeb0bc40ae274b6abff2906121"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-compiler-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-compiler;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-compiler.sha256sum] = "a5d46fc5585956322e4f9880f4ba05ab2a980d0dfb125e0ee66658e7675432b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-compiler-default-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-compiler-default;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-compiler-default.sha256sum] = "80a3e5f66ccb1c4acb444e9773bb3b277666d9c171fa7a91eb349ffdf9062ce0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-containers-0.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-containers;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-containers.sha256sum] = "d92da28224fc1feed61fb58cf37da53c5c80b6d22b4f202bfc3ab514187c5676"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-containers-devel-0.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-containers-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-containers-devel.sha256sum] = "10c0f16be86a377b0c90dadb866b96669ee6380be466d5814fa50cbc0be9bb2d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-containers-doc-0.6.7-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-containers-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-containers-doc.sha256sum] = "e3ebc333707631ccd78d65e8a7723f9a08577bc262befef7cec73bece6700046"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-containers-prof-0.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-containers-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-containers-prof.sha256sum] = "9c4dab3bc93adcb72d3ed3d096b20815fbc9dc01c2ccb401e269f196e7fb8027"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-deepseq-1.4.8.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-deepseq;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-deepseq.sha256sum] = "8c07c4f25a5a83b4681848f451ccc5f39292ecedf01f5c246e2707346d2ed274"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-deepseq-devel-1.4.8.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-deepseq-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-deepseq-devel.sha256sum] = "6ee60bdd4e1ba3cd434d50a8d5303ab83e8efdcdcf9fc59c6b1a9a1a73470850"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-deepseq-doc-1.4.8.1-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-deepseq-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-deepseq-doc.sha256sum] = "06a38846986919ef1b57d5014f1d91f3af28972f9f26741c12c029a34a672ac8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-deepseq-prof-1.4.8.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-deepseq-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-deepseq-prof.sha256sum] = "01ce0c0451f6fb7b938f260c0018de9e29bfe24d61686fa54cb60cc9f71af398"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-devel-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-devel.sha256sum] = "15a443c29a654f52ec98154ec9f28cac12758f1c35313df71e008bb5cc5e6556"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-directory-1.3.8.5-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-directory;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-directory.sha256sum] = "d7ee9df7c03caaa1296b39a1701fbb17b49ee5637b5ef2d5fa776685e2cdaf6c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-directory-devel-1.3.8.5-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-directory-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-directory-devel.sha256sum] = "284a257ea00e23e776e6c8daddaf34e545dbc553cb6f1c7b75302b6b3ff16c51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-directory-doc-1.3.8.5-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-directory-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-directory-doc.sha256sum] = "af729ad2c5cd2831e7fc65cd53ee8819c9facd964841c04ec130b8bd5a87ea56"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-directory-prof-1.3.8.5-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-directory-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-directory-prof.sha256sum] = "0cdf7e46eda9ca0d5a844829936a3c7719c8114c90f8196563c5630f0d17ac3f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-doc-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-doc.sha256sum] = "3c2ab48432febb31914276bebed646520ddbda5785c65aa6d994488b26e116a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-doc-index-9.6.7-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-doc-index;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-doc-index.sha256sum] = "7fe5865e82d47cf8afa3f21a8d148688ff344eb66fcb6041949114ddfdacdcf7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-exceptions-0.10.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-exceptions;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-exceptions.sha256sum] = "5286c37f3fda7157657879484bc2586ed737f3db52d945040dc5e81b3225f988"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-exceptions-devel-0.10.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-exceptions-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-exceptions-devel.sha256sum] = "f5b12800110dd9ac3c733c2628508dbace169d514fa5fc80f6da10f036c5b370"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-exceptions-doc-0.10.7-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-exceptions-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-exceptions-doc.sha256sum] = "bda7acbd8618fd09bc5f95aaaccb2c63fa09cfeb3579ceb5f16893fe8de60950"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-exceptions-prof-0.10.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-exceptions-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-exceptions-prof.sha256sum] = "39029f024fa288e4e6a9e86ad8d574ac7478c1f636fb5dbc1603b87450ea62fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-filepath-1.4.301.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-filepath;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-filepath.sha256sum] = "ba55a5405dbfa303d0644600a9ce6d93c22a3a91e341aef3db606d088007b77c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-filepath-devel-1.4.301.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-filepath-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-filepath-devel.sha256sum] = "5ec51288f053d755826ce6b696625184e1447c74748ab5ad77fa6b29860ac696"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-filepath-doc-1.4.301.0-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-filepath-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-filepath-doc.sha256sum] = "2a3cf911d2deae5408769445a8444d1111cc40dd8ec67e84003bf224fb8128db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-filepath-prof-1.4.301.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-filepath-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-filepath-prof.sha256sum] = "60fce437ce280c6dcb63baea0692ac29ae5ee8371379838c585ceec7e07e34b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-filesystem-9.6.7-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-filesystem;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-filesystem.sha256sum] = "feaa3e68d5f7f0bfdc38debcea5d93aca3b5a15b3376ac62998b9beb853c55aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc.sha256sum] = "b140c4ad314b0a0633d2701d18efbd6d69a973226a74fcf7933fd1356ac86e6e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-bignum-1.3-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-bignum;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-bignum.sha256sum] = "24ca09e7c6a75b485478915a577aced13f6fe3840daa7a6a2b9d67c393c7b9da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-bignum-devel-1.3-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-bignum-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-bignum-devel.sha256sum] = "9a3070a72cfd38c696d39680f75a577f87e96705f605b8d0cd021c12f609537a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-bignum-doc-1.3-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-ghc-bignum-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-bignum-doc.sha256sum] = "207429c3f6cdc0309806e6db224761504f61298f7a319cae2837da0cfb7b6d53"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-bignum-prof-1.3-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-bignum-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-bignum-prof.sha256sum] = "4a76540e661b74a114e3383be8b7f554c4097cb4311af6f2865dee19edb74211"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-boot-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-boot;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-boot.sha256sum] = "576c6e814ccc497ad6f2579d52957bbfb39ce91dd51be27a281198ea7c5b5cc5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-boot-devel-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-boot-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-boot-devel.sha256sum] = "b9b185d28ac3b2399ba588cf1db645879a4fcd2fdc18e09af6d4b221ec6624e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-boot-doc-9.6.7-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-ghc-boot-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-boot-doc.sha256sum] = "b42c4784c0d287da938574798797df0a15c5e01e58d60ff1de4850295e473de2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-boot-prof-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-boot-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-boot-prof.sha256sum] = "91a546e724d224c21f9f44564f0f6c5a56adff62792632082c09cf71c9142b0f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-boot-th-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-boot-th;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-boot-th.sha256sum] = "bd8e0dcd31e168e4a36dee1dc081a5ec7d0e8f652ab258d1aae9705050ad9776"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-boot-th-devel-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-boot-th-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-boot-th-devel.sha256sum] = "c643aed64f3f52f6889a7dae44b107168d67a7e7adf3a7154d179cbaeb930a3a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-boot-th-doc-9.6.7-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-ghc-boot-th-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-boot-th-doc.sha256sum] = "5dea963e47225c7ea97b175fe9430961d2c29800a3190d7f7201285bc2e52729"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-boot-th-prof-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-boot-th-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-boot-th-prof.sha256sum] = "50ed49ea391e636f0fe43cdc69f9efe00c0d813cbdac7484a19b996c7451472e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-compact-0.1.0.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-compact;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-compact.sha256sum] = "a85feb4d6ff5d4011182c226d864cf5b92625059205e21b9e4ce5e3c4adbe855"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-compact-devel-0.1.0.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-compact-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-compact-devel.sha256sum] = "c2c5e9a31a4537d629db646d91d7a9c0d0245abb93492d26b015b636354616a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-compact-doc-0.1.0.0-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-ghc-compact-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-compact-doc.sha256sum] = "0b599dc21832b6553ebf7b3a6d21161a92c255e0491285ffc2c2e58e6ba95248"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-compact-prof-0.1.0.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-compact-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-compact-prof.sha256sum] = "816ebfcb9fd82420d3c482299ae5e02705388a7b646fe34dfbed05962f5707e5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-devel-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-devel.sha256sum] = "0b1ca7957f94bc1898c2eb1b9f35603c3cbd05ba46fc6d518c1d6a807e355a34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-doc-9.6.7-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-ghc-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-doc.sha256sum] = "fc1343941c146839f62382517d7d99399baef7af4ee9e44914d02af166d3c301"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-heap-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-heap;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-heap.sha256sum] = "33cd0710e2f5a12e94c63aeb9338964f20981a761f97d630b400239ecaebbfa5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-heap-devel-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-heap-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-heap-devel.sha256sum] = "16dfb332787eed3630cb590a4a88c8e191ad785e3b79a4a82a47392474a99cac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-heap-doc-9.6.7-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-ghc-heap-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-heap-doc.sha256sum] = "78ffe9f29e929a31978819f92d9085537d7299a1e0fe10c8aeb9d0d6d91e55d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-heap-prof-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-heap-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-heap-prof.sha256sum] = "87f1c9208d55498f861c262c18e9324a99dac67213c92c2dd1ba70766ed3747e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghc-prof-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghc-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghc-prof.sha256sum] = "f64ecedbeab8f0c0256f887cfd7180210cb3e51df45a4b8fb93171c40c8db790"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghci-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghci;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghci.sha256sum] = "caab237eda26048a3d36897395670c447cb3390c7c26aefd9c435dff78589476"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghci-devel-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghci-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghci-devel.sha256sum] = "8a254dcc38c2f7f0802895dbfbb3435c8e27612029bc99cbc34893dba76e4a93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghci-doc-9.6.7-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-ghci-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghci-doc.sha256sum] = "698b556619e7022d1d2d79a21ce20bbc7260e0d1d57b3a3ca2a36b11795d3d06"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-ghci-prof-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-ghci-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-ghci-prof.sha256sum] = "6e46051240e4ec7a4595bbe99ba1a98a9b74fae5812afbc0bbd405aad52fe935"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-hadrian-0.1.0.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-hadrian;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-hadrian.sha256sum] = "bb8ed406c10e624d1584f21cecab1cdc271fa45db7c974567017ded9cbd66980"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-haskeline-0.8.2.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-haskeline;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-haskeline.sha256sum] = "f10835e250134d3f2ebaee3e6b73190b506b0728485beed81bbb0240b755fc4c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-haskeline-devel-0.8.2.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-haskeline-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-haskeline-devel.sha256sum] = "3ffff89b719f90fb78660f848eb04f6d227f3399a9e7eb318987ff11697f9c55"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-haskeline-doc-0.8.2.1-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-haskeline-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-haskeline-doc.sha256sum] = "461c1e71b6a879770ed42606a178b1cd941757e33df137e5b92f49068d44badc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-haskeline-prof-0.8.2.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-haskeline-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-haskeline-prof.sha256sum] = "e945827bbf601f9c739a4072bf74d31ced9d28ee8e421c246f8c5e7857813a47"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-hpc-0.6.2.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-hpc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-hpc.sha256sum] = "7d408aea3bbb525727c0985f5fde5f42a7684e74541360889f34f0d0ec348e23"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-hpc-devel-0.6.2.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-hpc-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-hpc-devel.sha256sum] = "5d646c12176efe6dea1ce489f303c95a24603d48ce1f2fe37d8a173691b7cbb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-hpc-doc-0.6.2.0-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-hpc-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-hpc-doc.sha256sum] = "a26314721070a7de9a72419ea65b92ad6e5626274292c5bca2ae4862344d9e5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-hpc-prof-0.6.2.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-hpc-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-hpc-prof.sha256sum] = "c28796e2d030818b057f3a2c30e27ecb06abc532d8e9d71c13bd6308cad26549"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-libiserv-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-libiserv;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-libiserv.sha256sum] = "7675027b9d5006d8f1369e46bd248f14503cf8d70bf82602b110f4e3e43b69e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-libiserv-devel-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-libiserv-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-libiserv-devel.sha256sum] = "718d46b2a6968ed06a148892d687ee5bae78266475f1cbc76a26f8f15fccf0fc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-libiserv-doc-9.6.7-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-libiserv-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-libiserv-doc.sha256sum] = "fd8ae7d6c1292f1c08db6ae720d295f6abfb852270de1a57c44b4968f45dc5cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-libiserv-prof-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-libiserv-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-libiserv-prof.sha256sum] = "d59dd9705d07b1df8855afbfee49963fd553176f86925bb6b48c45a752d6dff7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-manual-9.6.7-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-manual;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-manual.sha256sum] = "93bf8c1b861295f9feb59fac03f1996f02fd73c1b8286295235f9b97e7fcbcde"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-mtl-2.3.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-mtl;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-mtl.sha256sum] = "79cec001199f995c4a4f7601040f4390aba4f5a4edbfc7d765f729acc40f2cc7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-mtl-devel-2.3.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-mtl-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-mtl-devel.sha256sum] = "3a43cf61aea5b8322eab9ac9eac8924b5027195d238010b3dfb29365ecc175fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-mtl-doc-2.3.1-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-mtl-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-mtl-doc.sha256sum] = "23c0bef08893539a1b79294d74b6099bf4d0dfb28b68c60987694097bc1195a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-mtl-prof-2.3.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-mtl-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-mtl-prof.sha256sum] = "d810f236b09e57b2b38c179050adec588193c6c76bd65e9814921901827782ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-parsec-3.1.16.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-parsec;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-parsec.sha256sum] = "63e920a985c0a5f481a141bcbf1b361d4eb88770d1da4c1b6ea80c18fcd9b938"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-parsec-devel-3.1.16.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-parsec-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-parsec-devel.sha256sum] = "5f5db135fb72b93d7945d15995032c9c1a245e38efc18eb4667ed844e96b98fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-parsec-doc-3.1.16.1-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-parsec-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-parsec-doc.sha256sum] = "d1ed51f9ec3acdebb0733352f8c63dec2db3ba9dd8bab17091776e134a189915"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-parsec-prof-3.1.16.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-parsec-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-parsec-prof.sha256sum] = "bc87a447be783b86f728bab1c4c94fd99945dfca4a3d85fdd37106158fc57a2c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-pretty-1.1.3.6-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-pretty;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-pretty.sha256sum] = "ce12e65454c0ef4651f6ec3180e1048453e2718e7dca94069b0cbdb922cc6609"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-pretty-devel-1.1.3.6-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-pretty-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-pretty-devel.sha256sum] = "c6a4c898ad675c93e233e15dd710f3556203b7962a71a7555030107bb7f8d2da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-pretty-doc-1.1.3.6-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-pretty-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-pretty-doc.sha256sum] = "0f2e3bee2b60c377dd4988cd2fc386360c181aada07b858b214514f29cff98cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-pretty-prof-1.1.3.6-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-pretty-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-pretty-prof.sha256sum] = "44827a79797741d72a7209f71485a7871315e6eeb6fd4b6c88881c0885c5aec3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-process-1.6.19.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-process;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-process.sha256sum] = "832d831728d94cf2661e07ac09fc5ba017979480bf1790d0325be5aa04f95f4c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-process-devel-1.6.19.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-process-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-process-devel.sha256sum] = "923b0ef910195cbf6d42f4f34ef3723ccb9495ba83582773fba85620bfbe0bf9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-process-doc-1.6.19.0-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-process-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-process-doc.sha256sum] = "58a3f7b42ea8d77072e281b06e3686644b4934b94a5f99d64a7094d2ee9aee99"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-process-prof-1.6.19.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-process-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-process-prof.sha256sum] = "7086809c5ddeae99c7b87bf56c6e1ff9acf4f241d7eddb1bcd9d57297387b900"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-prof-9.6.7-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-prof.sha256sum] = "e42a3a89a5cd219fddb4b98f41f9cff054912b2403fdce93535aa89273b5bdaf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-stm-2.5.1.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-stm;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-stm.sha256sum] = "08759b25706630cfe0ea3131e92fe11014de62883de02536bb6591eae183de06"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-stm-devel-2.5.1.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-stm-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-stm-devel.sha256sum] = "52afc92f980fb97ea9b48dd372cfa3cfdcbc83089640804f9ab78704f849b691"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-stm-doc-2.5.1.0-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-stm-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-stm-doc.sha256sum] = "e01014545137c1dff31d0af921b4214e73a5850422602325651c572195895152"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-stm-prof-2.5.1.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-stm-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-stm-prof.sha256sum] = "f13b8688f96cf5c82bda310558d4212ecd72d8fb2b4ad84f8fef8da06a2bab34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-template-haskell-2.20.0.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-template-haskell;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-template-haskell.sha256sum] = "466b88712567636accb6d2212ca575deecc682c76eb40d76766540a879327059"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-template-haskell-devel-2.20.0.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-template-haskell-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-template-haskell-devel.sha256sum] = "eda4c7532bbfa42ca366565c34ffa34226641bd10fbde43aba230d8840acddc2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-template-haskell-doc-2.20.0.0-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-template-haskell-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-template-haskell-doc.sha256sum] = "bf202257f2d798979fca11f7b63ff3994441a72dbc33b818dcab644cf746b4f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-template-haskell-prof-2.20.0.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-template-haskell-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-template-haskell-prof.sha256sum] = "fb07d9e6671c5e01c37f2c003adf3400703484635b79b922bcecb1e745f64d9a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-terminfo-0.4.1.6-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-terminfo;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-terminfo.sha256sum] = "89cd17fb12c6ebaa2650141991fc21fdf341acae6e9baae1d0f3e120079cb5b8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-terminfo-devel-0.4.1.6-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-terminfo-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-terminfo-devel.sha256sum] = "9453b78e705c02fc642ea15e93994e89bb15a51a887c86180dbf9642ce20b36c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-terminfo-doc-0.4.1.6-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-terminfo-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-terminfo-doc.sha256sum] = "18afce58e0c574458eac374d9682a9f8f28118cf3520afdfde6b6e8fc00d008e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-terminfo-prof-0.4.1.6-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-terminfo-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-terminfo-prof.sha256sum] = "7d85f4f600d2234af5ef220a4986eab16a509d09dfbed867886bc8510e0b8bf4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-text-2.0.2-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-text;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-text.sha256sum] = "7bfeeb512cde3a636da5c2ce177b6ede3ec49e793ddd4384ee15e0125e45bb49"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-text-devel-2.0.2-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-text-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-text-devel.sha256sum] = "bd8e0e63ec9ca4bd48a7b7d705620f72ed8120e09d62fe7164f3b50a22b8830c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-text-doc-2.0.2-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-text-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-text-doc.sha256sum] = "0d1603f0a31b983b2e057bb49fa2adecacae43ef29e3b96dc31a7da9bba22f5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-text-prof-2.0.2-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-text-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-text-prof.sha256sum] = "3240e6d9b578c409a1f66c6dc380af69f4ee751503f51f76720a1a89c9bac63d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-time-1.12.2-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-time;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-time.sha256sum] = "5cc0126e639e929d1ee43ce1265b1a768f3870425ffadcc113f92d6200d2771b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-time-devel-1.12.2-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-time-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-time-devel.sha256sum] = "3f1d80efb4acc58449a8acd5f3b48e03951effe66d0e76e91843f39aa90e2158"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-time-doc-1.12.2-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-time-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-time-doc.sha256sum] = "216ec858c197c72fd73e4c7d35e58386b86ed753c5d409a360737ca293f81c63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-time-prof-1.12.2-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-time-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-time-prof.sha256sum] = "4c34f69788d36f26146751197574ef53520214b07db42ebfedc54c315d16a6fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-transformers-0.6.1.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-transformers;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-transformers.sha256sum] = "7abbe654fd30483ab9be490bf4d552784dd723f1856c6a85ee39970c13765863"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-transformers-devel-0.6.1.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-transformers-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-transformers-devel.sha256sum] = "0ecd08e916ce02598e3bd106bcb31ee2be160e2e8ae7fce08f5fba3525466aea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-transformers-doc-0.6.1.0-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-transformers-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-transformers-doc.sha256sum] = "df5350ba0023b332e0a625bb1f838cc5a48fc781e9354062b814bb637f218f50"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-transformers-prof-0.6.1.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-transformers-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-transformers-prof.sha256sum] = "046dfe702d0a29380583de6b8bb64f43a69390d20b11547ebce93c38e30c09f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-unix-2.8.6.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-unix;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-unix.sha256sum] = "27cf4b73bc2cfb6317a0930ec8120357bb8e7a6340b1d1bde79d49ce5ed17192"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-unix-devel-2.8.6.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-unix-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-unix-devel.sha256sum] = "a227e97543414dca2c7ca768091c823517cb2b1fe483d6b31080cad26a01a4c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-unix-doc-2.8.6.0-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-unix-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-unix-doc.sha256sum] = "ce883d6cb5217f29469566a74ffeb2a17047de784d8c2c1d7fe72c3645dacf8c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-unix-prof-2.8.6.0-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-unix-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-unix-prof.sha256sum] = "0250650e3d56c78d00a2c48f3b3df7f4e124640c7faef61e2afd8b54682a29cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-xhtml-3000.2.2.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-xhtml;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-xhtml.sha256sum] = "969eb5db0ec5f207ca793bf338b0764abe6ffdeea6b968b114e84a59566deef1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-xhtml-devel-3000.2.2.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-xhtml-devel;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-xhtml-devel.sha256sum] = "9f2105141ffaad1c8b03fec2b43263d263d0edcae2cc0bce798fbd227d87df5a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-xhtml-doc-3000.2.2.1-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.6-xhtml-doc;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-xhtml-doc.sha256sum] = "77aa2ecb387196a94425cb1747f864c67309091186f0e8a860fa15b69e9c61eb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.6-xhtml-prof-3000.2.2.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.6-xhtml-prof;unpack=0"
SRC_URI[x86_64_v2_ghc9.6-xhtml-prof.sha256sum] = "424ebef2df68cc545add98b1547dc6a63fd1e8fbd4fd4c73bed380fd0d2a09e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6;unpack=0"
SRC_URI[aarch64_ghc9.6.sha256sum] = "d3a3980b3a422c44b15ba44bd6bd9b3e1443f0e7200118de1fe4ce19397ca073"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-Cabal-3.10.3.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-Cabal;unpack=0"
SRC_URI[aarch64_ghc9.6-Cabal.sha256sum] = "e0b6c48bd47f70ae8a90b94c8deeb81377da3f8504f950c199a3dcc86a6e5ee6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-Cabal-devel-3.10.3.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-Cabal-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-Cabal-devel.sha256sum] = "36e47a183521d97bf3132818870a9cfce225140cd2b16da3226be576d2b35a88"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-Cabal-doc-3.10.3.0-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-Cabal-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-Cabal-doc.sha256sum] = "812e94021c42a2d54e77a60653a75ffe6ac7a9af4b953c3a546456b72a6ae776"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-Cabal-prof-3.10.3.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-Cabal-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-Cabal-prof.sha256sum] = "f14f8802b5e1b66962d3a548e17bc1c7c2982aa9d7cdefb651187278011419e0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-Cabal-syntax-3.10.3.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-Cabal-syntax;unpack=0"
SRC_URI[aarch64_ghc9.6-Cabal-syntax.sha256sum] = "87ab05881387bd50fb1549e772581e8e18f6b590ab37559f27618011e3ac2e0f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-Cabal-syntax-devel-3.10.3.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-Cabal-syntax-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-Cabal-syntax-devel.sha256sum] = "f3466910994e2c86b0c23e53ef3b954d0b7d0f3f58e62dc9042918e3d1033421"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-Cabal-syntax-doc-3.10.3.0-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-Cabal-syntax-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-Cabal-syntax-doc.sha256sum] = "b3bd2f8c8e638f97c3265f988dac1afd9c5afb76f04390c492a3f0ece618a955"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-Cabal-syntax-prof-3.10.3.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-Cabal-syntax-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-Cabal-syntax-prof.sha256sum] = "7730f57e2bd4c8e47c52d2a29c49f75765750b352da9cfbb11e7a09ddd7e97e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-array-0.5.8.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-array;unpack=0"
SRC_URI[aarch64_ghc9.6-array.sha256sum] = "4a088ed356de982656830626d93da1b149b7a3fa5abfe28ffdeac714a62281f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-array-devel-0.5.8.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-array-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-array-devel.sha256sum] = "7290101059fc887c29c2886fda289152212def99f7a002f340b41ffdeac22a0f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-array-doc-0.5.8.0-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-array-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-array-doc.sha256sum] = "a179bd80607e1d378ad76860a1bfc567a8d55b4f117f740f12e5d8c52872805c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-array-prof-0.5.8.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-array-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-array-prof.sha256sum] = "7261f0a4a264bf4bf270ad80562c9bd135d42e77f0b866dd21a01c6d0d8e5546"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-base-4.18.3.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-base;unpack=0"
SRC_URI[aarch64_ghc9.6-base.sha256sum] = "2a4af0afdc9673d518a94f9217161ecab29950562d777bb41aa8d788323ce901"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-base-devel-4.18.3.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-base-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-base-devel.sha256sum] = "452a78cb08fabc4a7862fb3a92670725022f0d3691ce1e1f4eb7d5be3af37001"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-base-doc-4.18.3.0-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-base-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-base-doc.sha256sum] = "9346347b3ee3026a1ea2447a20b3729466b546dce1f88e944b3de68faff28477"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-base-prof-4.18.3.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-base-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-base-prof.sha256sum] = "9d484753ac9a498c752a8d66a9f98a91a9be66c8d72b68fbb355a0d76e44340f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-binary-0.8.9.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-binary;unpack=0"
SRC_URI[aarch64_ghc9.6-binary.sha256sum] = "bd3a80d9d9fc2e998378d39c35c7eb4687c5d3cf4ae2ccf5d0952f15b8c886e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-binary-devel-0.8.9.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-binary-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-binary-devel.sha256sum] = "0bb64b274617302d64dce9ba9d21cafe992ac111e3af95eea8cf2c239fedfeda"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-binary-doc-0.8.9.1-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-binary-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-binary-doc.sha256sum] = "5f7e640df4f735f5523276fe7d2e974085d5dc179a42e059b4adfeca69517c64"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-binary-prof-0.8.9.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-binary-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-binary-prof.sha256sum] = "89fef598f89c959531831b9b2a5349ec9d3c40a74d636fc8deba8746e517932f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-bytestring-0.11.5.4-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-bytestring;unpack=0"
SRC_URI[aarch64_ghc9.6-bytestring.sha256sum] = "a8dc5afb791f8d76f2fef081a0a06fa00c7f93b274625a448a3881215aa857d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-bytestring-devel-0.11.5.4-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-bytestring-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-bytestring-devel.sha256sum] = "7eafec914cfc73e33183b0f0737256905f46ee5152116509d5b45469d5cdd530"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-bytestring-doc-0.11.5.4-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-bytestring-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-bytestring-doc.sha256sum] = "ba9c3d7249b6e97af25d4ddf25a945788ab61c4734e64cbc68f858b8f1149f1d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-bytestring-prof-0.11.5.4-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-bytestring-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-bytestring-prof.sha256sum] = "13c07c2796b72aa8abd50ccdd1f50af66852fae4b4115035f69eeb9da30aab24"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-compiler-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-compiler;unpack=0"
SRC_URI[aarch64_ghc9.6-compiler.sha256sum] = "3e44b6d6db95e8c453b567d8a2403eadde327209fdf03485956a998322e0ce8f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-compiler-default-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-compiler-default;unpack=0"
SRC_URI[aarch64_ghc9.6-compiler-default.sha256sum] = "1d1fd07107e74a57301794b680329f56c80d305cd60274c8ecdc68d1c19498b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-containers-0.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-containers;unpack=0"
SRC_URI[aarch64_ghc9.6-containers.sha256sum] = "52922dae73b660364e5fe878a09a540cc74052186e1f7be0157cf06a44172395"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-containers-devel-0.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-containers-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-containers-devel.sha256sum] = "094d65c76f0cf7635211a4190e3043822612e9194e785ed102c43f6a76d4e48e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-containers-doc-0.6.7-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-containers-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-containers-doc.sha256sum] = "63183eca705968f849c35c2e426c2a16213e8a1093a1485635b5662edf0eb776"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-containers-prof-0.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-containers-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-containers-prof.sha256sum] = "1d725d2e0d60fbb453d078f4e11e6ee7004d9ee1eabc15e8e0e5d9ec2cac5a5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-deepseq-1.4.8.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-deepseq;unpack=0"
SRC_URI[aarch64_ghc9.6-deepseq.sha256sum] = "69076ba99b0d735f184d652eddf5bca7e70489fca41bfca4e46f22d5479d8347"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-deepseq-devel-1.4.8.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-deepseq-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-deepseq-devel.sha256sum] = "420d35019d1b30ba5c9521385fc4175ce92207c483c3b118e318b0f5f14419c2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-deepseq-doc-1.4.8.1-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-deepseq-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-deepseq-doc.sha256sum] = "1def80981717185117e1bcffb0152156b9d122d111b5b4c8ea8bc2da1818bdeb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-deepseq-prof-1.4.8.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-deepseq-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-deepseq-prof.sha256sum] = "368ec8ec461191baf627cb2fc8ee0d2c809ebfaa0d4b69cae9cd0c3725c67139"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-devel-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-devel.sha256sum] = "b3dbfb782464c1bf849697d5b569a28c1489fc4413dce79528c43839063bae17"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-directory-1.3.8.5-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-directory;unpack=0"
SRC_URI[aarch64_ghc9.6-directory.sha256sum] = "c5359579669a1531b49325e2d7c59d71952763a10bd7614d981f40b3e2651e1a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-directory-devel-1.3.8.5-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-directory-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-directory-devel.sha256sum] = "8233263ac860cf1551743cce0e0136ebb6597d87ecf73f11cc243186697d8e8d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-directory-doc-1.3.8.5-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-directory-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-directory-doc.sha256sum] = "3e923e9dabb81c1230575cd1da4ae444ff70d5d008f82678e432edb9669c15dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-directory-prof-1.3.8.5-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-directory-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-directory-prof.sha256sum] = "5f76eea88fcb3c6f7db4d10c0fa935f9018fd53e4f8d3e6e4eb632e3588c6afb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-doc-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-doc.sha256sum] = "b3919f6b27752a072621156420301c99a6b1b40d3388f73e3a4ea0723f2a2bfb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-doc-index-9.6.7-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-doc-index;unpack=0"
SRC_URI[aarch64_ghc9.6-doc-index.sha256sum] = "4b724f8f93910c4406f54f70d24919c3cc611c0e236bd6e49361c138613f288d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-exceptions-0.10.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-exceptions;unpack=0"
SRC_URI[aarch64_ghc9.6-exceptions.sha256sum] = "5052701b7d66fa33de9ff816c51f75df197d83e5d7a99ae62b94924ce518324d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-exceptions-devel-0.10.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-exceptions-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-exceptions-devel.sha256sum] = "8cd609121ee78f703fdcfdc77b1029140de6ac3bd22eebf73bcacf2235c339df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-exceptions-doc-0.10.7-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-exceptions-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-exceptions-doc.sha256sum] = "51b0c3cf3ecee22cd9a8586a8119498c8de405ac4db07d9d0643a9d0156df8ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-exceptions-prof-0.10.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-exceptions-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-exceptions-prof.sha256sum] = "c2f51ff7eb46ab01404f9cb4ec5fad152e92f9a81e75580634a16c010d948190"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-filepath-1.4.301.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-filepath;unpack=0"
SRC_URI[aarch64_ghc9.6-filepath.sha256sum] = "17a2c68b142d83235394096157ad1fd5cf1a4dca24d22ae418490fde0525971d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-filepath-devel-1.4.301.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-filepath-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-filepath-devel.sha256sum] = "e45b33253faa727c45e2db8eb21010f46d2b617c300f4c1406fc6ce03ef6eca5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-filepath-doc-1.4.301.0-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-filepath-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-filepath-doc.sha256sum] = "9373cd607f3ff025d06742f741c4be4b61744e08f5dcc107d30c69f6f33f9900"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-filepath-prof-1.4.301.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-filepath-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-filepath-prof.sha256sum] = "0f11d2612c45a9186bd4183648937cb66c2c423b836c8920e39d941c6c7f4881"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-filesystem-9.6.7-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-filesystem;unpack=0"
SRC_URI[aarch64_ghc9.6-filesystem.sha256sum] = "a3fc40c7bdc68ad9d657b566f7ccdc7f0017066bf529c595bb5581c03b6aff20"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc.sha256sum] = "8e35bf3c2a375904f3819086ea5ff16c3c2d5fc00d57fd51c19a851d60f38f75"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-bignum-1.3-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-bignum;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-bignum.sha256sum] = "f28675aa98fb11ec15a6b08041b98827493032f7bdef5c062132276a2dd466f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-bignum-devel-1.3-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-bignum-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-bignum-devel.sha256sum] = "86f89a083040ad256718e294323736bce710e2ac35cfa6921a4a75b00422b7d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-bignum-doc-1.3-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-ghc-bignum-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-bignum-doc.sha256sum] = "3557004a3449b4274ee4fcab50b6e4148ecad52c090b8af8d7590ba2fb2509ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-bignum-prof-1.3-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-bignum-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-bignum-prof.sha256sum] = "0b24eec20271bf75019a8053a0fb174b45e08c6e1e60ea9c711d9a5bc8a18bef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-boot-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-boot;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-boot.sha256sum] = "964db1f128a7ca80f1772b95e0721020b661a5696810f3dcbb8be5fa0182581f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-boot-devel-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-boot-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-boot-devel.sha256sum] = "9a24cce869b7844727466a54a34c53dcfc013a4814daf57df625fa6bb530c9d1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-boot-doc-9.6.7-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-ghc-boot-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-boot-doc.sha256sum] = "51cf62a5a89c45221e7e1069b2c149496314db12e993e97639bb0689872c8124"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-boot-prof-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-boot-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-boot-prof.sha256sum] = "c8336908032bbaf384e031545608bcb7d05cea2c7155fa4624082b144fe2a2c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-boot-th-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-boot-th;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-boot-th.sha256sum] = "9e3854c6eda5a2122164dd5f1b0712ce7ce290e5d7794fb46359adec09ef8b48"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-boot-th-devel-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-boot-th-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-boot-th-devel.sha256sum] = "a62e494002189bbc2549cc1e822e0fa34cad48a5b70f8880cfff329e568ea332"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-boot-th-doc-9.6.7-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-ghc-boot-th-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-boot-th-doc.sha256sum] = "548687fef0b48fde1d69e50fc5a136c9a91481845eb2b8e886bfa98f35e3c327"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-boot-th-prof-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-boot-th-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-boot-th-prof.sha256sum] = "e90ac191d839335a66ee9a64bc988f6cfe2249a88a72818d39c81478cbc81794"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-compact-0.1.0.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-compact;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-compact.sha256sum] = "89889f86c33070c31e6ed731abb9b1d2fd4857053c26bc425ecbea2b4525809e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-compact-devel-0.1.0.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-compact-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-compact-devel.sha256sum] = "ff883d337dc35a9694f2ca0fbddae5745a8e874f2973be0f259b83cf9ad657b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-compact-doc-0.1.0.0-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-ghc-compact-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-compact-doc.sha256sum] = "5d9073372faf562dc9ad1744b4a9f85f81bb85e247bd81d90d3f7c2c424ecd8e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-compact-prof-0.1.0.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-compact-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-compact-prof.sha256sum] = "7e5f9fa2ca6775675373f092100afce663029692ef7fb9ff396d363f7e04edd2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-devel-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-devel.sha256sum] = "b12cccdd4f9e1b5a68950bdfea25678228cf369d2e76cd9d7c3eb6e7869b2c0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-doc-9.6.7-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-ghc-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-doc.sha256sum] = "bced8d715cd493a2ef2d04bcd057a60d475ccfa70f45ce0867005e6384004731"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-heap-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-heap;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-heap.sha256sum] = "e5a116b0450a3062da1151dc788a44300b6e915282ff88303f04bbcaf493ced7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-heap-devel-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-heap-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-heap-devel.sha256sum] = "093d4f8e6cfb46348f1f9db1e893c59623f8c405cc0fdccde89c81b0c0849086"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-heap-doc-9.6.7-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-ghc-heap-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-heap-doc.sha256sum] = "d16de082e4068a4e2dbea9994f1461008d572ea655d517c6a1ef42f84ef3c9f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-heap-prof-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-heap-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-heap-prof.sha256sum] = "25ed6759ddcc923702e233aa341919ea1988c72050decb7866b6f2083cf59d84"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghc-prof-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghc-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-ghc-prof.sha256sum] = "c87187cc449bc5b2fc6284d34718166b94bea05b281b8ee1e999228c3d67415e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghci-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghci;unpack=0"
SRC_URI[aarch64_ghc9.6-ghci.sha256sum] = "9b1a1852aa88ab85ff8ec49d6b5e266d4465c9e3a58bb2ffaa9dadc74fa92226"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghci-devel-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghci-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-ghci-devel.sha256sum] = "2003448179d51246990b7eee7f6f073e3f23a5af4b4a62482ed98ec690cf3fc0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghci-doc-9.6.7-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-ghci-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-ghci-doc.sha256sum] = "5c187fb20d229e435d8ff96bdf8e239445feaf4dffb06254576776878a5a507a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-ghci-prof-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-ghci-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-ghci-prof.sha256sum] = "2eaf5133eeb2109b60ce991a9974f7f7bbb2b6ef4f7cfa1e8ea95b7ddc709823"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-hadrian-0.1.0.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-hadrian;unpack=0"
SRC_URI[aarch64_ghc9.6-hadrian.sha256sum] = "8a6b17f8c2089ca17ab76d60a7f30f02b97925c65066d46fc68251282da723f7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-haskeline-0.8.2.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-haskeline;unpack=0"
SRC_URI[aarch64_ghc9.6-haskeline.sha256sum] = "213267638152fd9446e8d960a5731c3c7e2a1ac344db4a7c8f13927b6b010db7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-haskeline-devel-0.8.2.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-haskeline-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-haskeline-devel.sha256sum] = "3820c2f2ef0c34553994d3fb7d25eb92be190de5356f350c632b18f65d5e7540"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-haskeline-doc-0.8.2.1-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-haskeline-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-haskeline-doc.sha256sum] = "7d34a7b873614e02f0f606a7021471f562ec79f2a521fcb152658f9e15dc9ff5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-haskeline-prof-0.8.2.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-haskeline-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-haskeline-prof.sha256sum] = "c15390e6f9cbacf175bac1b9ddc8266dc48ab1cf08794d994ec68e6681906ad9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-hpc-0.6.2.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-hpc;unpack=0"
SRC_URI[aarch64_ghc9.6-hpc.sha256sum] = "0c6b59c98dc12462e220298c4b7036e185beca1d7258f693019b80c164f9dd63"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-hpc-devel-0.6.2.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-hpc-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-hpc-devel.sha256sum] = "1f13c621f1ca97fddce0da4e8910ff248709bc3e852355b11f9958953c17c32d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-hpc-doc-0.6.2.0-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-hpc-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-hpc-doc.sha256sum] = "ff9e5dcee4a431f3a886300a1340f20730742c0a34fa4025552bf0ad25041514"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-hpc-prof-0.6.2.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-hpc-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-hpc-prof.sha256sum] = "16df38bfc2cb46bc639456430ded6d7de140b99a58eed21ae603f51465dcf684"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-libiserv-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-libiserv;unpack=0"
SRC_URI[aarch64_ghc9.6-libiserv.sha256sum] = "3776f1b46b9972b1a242817a3dc202a5f2eeb9a82c2713d96254846874dd6885"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-libiserv-devel-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-libiserv-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-libiserv-devel.sha256sum] = "7493a11161fe30e344ebe6c02e4af6aa88044cefa123f08a282ef389b19016f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-libiserv-doc-9.6.7-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-libiserv-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-libiserv-doc.sha256sum] = "f35e076a0c92adf8b6a144c13edd3c28f7dcd0dc469d221217ae353a6928e110"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-libiserv-prof-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-libiserv-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-libiserv-prof.sha256sum] = "f688d6198ff09fc5e4f6f16acb32222a8db0476a38dc6ed9ac5ae946083ba5d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-manual-9.6.7-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-manual;unpack=0"
SRC_URI[aarch64_ghc9.6-manual.sha256sum] = "27f1d797e1324c3ea3fc768359364b5bcff431c80b6c44f530981ba97735d23f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-mtl-2.3.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-mtl;unpack=0"
SRC_URI[aarch64_ghc9.6-mtl.sha256sum] = "e6710b2ed631f2fc5221437797d1daecf079583c53af968567297f2e54affe78"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-mtl-devel-2.3.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-mtl-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-mtl-devel.sha256sum] = "2aae57f31f62d426b5b098486ac52d8054b2e84fa1aa531ac06fa2d5e3c7684f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-mtl-doc-2.3.1-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-mtl-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-mtl-doc.sha256sum] = "9f9af9b9f62c8a6ef78af7205993827ead876b7ca37201c3dc73737a197dcbae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-mtl-prof-2.3.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-mtl-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-mtl-prof.sha256sum] = "fea5e11eacaeedb34f2f26e5510a2e9215780106b469f27696a71d4b7cfb1ffe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-parsec-3.1.16.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-parsec;unpack=0"
SRC_URI[aarch64_ghc9.6-parsec.sha256sum] = "c857418468b9a52882143f202d99b3ba329577f65e538fbd2cf5bd38d868c32d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-parsec-devel-3.1.16.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-parsec-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-parsec-devel.sha256sum] = "d2dd3c84f8091c4333611a70f49cbb5924aa3fbe8d8b8fe0ccf21f3743c2eacc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-parsec-doc-3.1.16.1-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-parsec-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-parsec-doc.sha256sum] = "13d0e8dcb5e4f314228b55ed075afa26af10813e666238e12cf244a08148cfc4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-parsec-prof-3.1.16.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-parsec-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-parsec-prof.sha256sum] = "53448be21d390e601054c2889b2ebf3c22fca3caaba5f1d2ce4821f5141a1eee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-pretty-1.1.3.6-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-pretty;unpack=0"
SRC_URI[aarch64_ghc9.6-pretty.sha256sum] = "389bdb7b6fbc3c1aca04c2d16775664e18d3708348e5d088b4464e4398264895"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-pretty-devel-1.1.3.6-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-pretty-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-pretty-devel.sha256sum] = "c3ddf0cb6da8b0b4537a740de7f51c6c8d6c63d054e1962eea71fd520a8f692b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-pretty-doc-1.1.3.6-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-pretty-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-pretty-doc.sha256sum] = "037c0579e6b0fbbf17232cdf6b30ff88a243b3cd405c03b5b8d44fcc7d094b17"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-pretty-prof-1.1.3.6-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-pretty-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-pretty-prof.sha256sum] = "265a372564faa042459ef7bf83df00db48b884a67ff8a303beb83fbc530a814c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-process-1.6.19.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-process;unpack=0"
SRC_URI[aarch64_ghc9.6-process.sha256sum] = "c4eb4467e5c845e8629a42f1bae85d4c921932728ae584b8b60c3b49fe71b72c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-process-devel-1.6.19.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-process-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-process-devel.sha256sum] = "1aeb57183d2006e334a418ba0563a46d8ba15fb74beb70cc68f5bc0bb7120f17"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-process-doc-1.6.19.0-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-process-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-process-doc.sha256sum] = "d6f6f19c8370ed481872f7ef0afa9468b6817b1d65fd256df943e43401241bfd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-process-prof-1.6.19.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-process-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-process-prof.sha256sum] = "89b5823293349769c5a87311a959b8d6ba3d1999945c8c01d210547d80670dd5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-prof-9.6.7-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-prof.sha256sum] = "f9653f5b4fed53b1b3fde7b64e556b9b9822eadeeb59ed79f0f4feaef8e3f87b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-stm-2.5.1.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-stm;unpack=0"
SRC_URI[aarch64_ghc9.6-stm.sha256sum] = "b91360b0d1de5b77670cbcd3cec4b4b172209d07b75ee77c5de0b8c4497cf8f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-stm-devel-2.5.1.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-stm-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-stm-devel.sha256sum] = "9d82972cf95b625535c288cb37c37d3da26ab8e8cf5dc8ab5b35e55585c204fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-stm-doc-2.5.1.0-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-stm-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-stm-doc.sha256sum] = "8c894bd180cf36463500bf3f119df5be2a7d170fd1bd544d625d999f2bd80586"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-stm-prof-2.5.1.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-stm-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-stm-prof.sha256sum] = "9fddce725449d58ff44eb2dcc44cf7590d37dc5a1eedd47a5187fbdd0572f0b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-template-haskell-2.20.0.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-template-haskell;unpack=0"
SRC_URI[aarch64_ghc9.6-template-haskell.sha256sum] = "1b4bda624f8f3305b625dabea357d631d100c8e1803b75a325727e8cd34de621"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-template-haskell-devel-2.20.0.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-template-haskell-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-template-haskell-devel.sha256sum] = "6457296d069c8e9ea3ad1137af9891b185a9261cb0386997b55222493a53be5a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-template-haskell-doc-2.20.0.0-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-template-haskell-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-template-haskell-doc.sha256sum] = "f98ec492a1be25749de4c5e31ed48ac4c6f52db7512ced4549d1679ae07b3fcf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-template-haskell-prof-2.20.0.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-template-haskell-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-template-haskell-prof.sha256sum] = "46999fb6020afdb00a7204d45f73935bd935d856aeeff64e7dab400dc1684eef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-terminfo-0.4.1.6-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-terminfo;unpack=0"
SRC_URI[aarch64_ghc9.6-terminfo.sha256sum] = "3558c1ddd2dff02ea0d4712c58b2e44b72a6ecca2b80468c05688e64e2243d7b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-terminfo-devel-0.4.1.6-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-terminfo-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-terminfo-devel.sha256sum] = "c5e74c7be329259f96de8cf8d5723f7dc54180fd7a12af36184b2e6b68a7d9dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-terminfo-doc-0.4.1.6-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-terminfo-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-terminfo-doc.sha256sum] = "4412e9f312609d764b4bf08b3d61e49687bc0edfe358a17f478318cddab2b2a1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-terminfo-prof-0.4.1.6-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-terminfo-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-terminfo-prof.sha256sum] = "a0a9506c049970d90bc350b60fe4681e96724324efdc33af39aab2a7532bcc51"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-text-2.0.2-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-text;unpack=0"
SRC_URI[aarch64_ghc9.6-text.sha256sum] = "0642d285c4d27f26c40dd2d1ac9bff2c89fbcbdd1748686de87eac5d26d2b983"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-text-devel-2.0.2-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-text-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-text-devel.sha256sum] = "c3fbe1f232e57728418578703f48586a8904e3539978e5cda3870945036f9f8f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-text-doc-2.0.2-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-text-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-text-doc.sha256sum] = "92bf722f94f526a64519ed831b4450c9ab6b4079f8212010ebc6596d91aea036"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-text-prof-2.0.2-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-text-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-text-prof.sha256sum] = "f02cf1033663c84a29743ffe3a077eeba638ce375c134fb4423639caf66ed86b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-time-1.12.2-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-time;unpack=0"
SRC_URI[aarch64_ghc9.6-time.sha256sum] = "81cf0731e75c680bb39c82617eeeec117e46cd1cef601a174094c1f6b26a00a5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-time-devel-1.12.2-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-time-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-time-devel.sha256sum] = "3a640a834614afd3d8ffdd2261f1de78c81b6a8467d2349854db9f9d98fb2c90"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-time-doc-1.12.2-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-time-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-time-doc.sha256sum] = "3c36bc372816fafd42b738c9df01640256cea7849b71e5ff7c41c5c0f80b3fda"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-time-prof-1.12.2-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-time-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-time-prof.sha256sum] = "9d741ffbea355c0253ef22a6887571a7de627e5bdae782b82f99586b848610b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-transformers-0.6.1.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-transformers;unpack=0"
SRC_URI[aarch64_ghc9.6-transformers.sha256sum] = "2af69bef42412d52272bb9f3f671a13137a01fd64ebc4eca98742af4dcc30024"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-transformers-devel-0.6.1.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-transformers-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-transformers-devel.sha256sum] = "d9ef64cd06f8aa769ea183afd9388f71ddac514baa466a792bd70c51e2f7ff8e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-transformers-doc-0.6.1.0-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-transformers-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-transformers-doc.sha256sum] = "d691e85323c4ed17825f278293949c447733040ae9c1478c2ca7b5145f71c63d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-transformers-prof-0.6.1.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-transformers-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-transformers-prof.sha256sum] = "1f1547df73698570605befa24a6a26e68a38a3548b398e275c0bc659835d29ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-unix-2.8.6.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-unix;unpack=0"
SRC_URI[aarch64_ghc9.6-unix.sha256sum] = "3bd6eeb5616dd2470eab9a46e8c394f3cce6b8bab0cc4b72ae567ee3b5917ec6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-unix-devel-2.8.6.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-unix-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-unix-devel.sha256sum] = "54c6ccdb0d84f8ea97610aea76c1926e90a2c6294bb1c9bf13ac4745702ccea7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-unix-doc-2.8.6.0-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-unix-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-unix-doc.sha256sum] = "a5c882d6010c23a8f1228e0b1a5bdd4c99c1bc036a1094df788424af871d0826"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-unix-prof-2.8.6.0-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-unix-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-unix-prof.sha256sum] = "fcd826c83121aae8f37ba183e7cbf8c0597cd0cea6f7b485fe02fb535d34aec3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-xhtml-3000.2.2.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-xhtml;unpack=0"
SRC_URI[aarch64_ghc9.6-xhtml.sha256sum] = "18767a3581a1688e80aa8a24c94d2dde35b2e6c2f1ce84899ae43e290304c607"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-xhtml-devel-3000.2.2.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-xhtml-devel;unpack=0"
SRC_URI[aarch64_ghc9.6-xhtml-devel.sha256sum] = "1615e97dcdbd483fbe9c2bfb9a285db6e4e803cb0a4e947981b5ee04b159283c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-xhtml-doc-3000.2.2.1-24.el10_0.noarch.rpm;name=aarch64_ghc9.6-xhtml-doc;unpack=0"
SRC_URI[aarch64_ghc9.6-xhtml-doc.sha256sum] = "ead48428d35d160098394c7ba541f80dba87289c4bf147b969488573f48d14cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc9.6-xhtml-prof-3000.2.2.1-24.el10_0.aarch64.rpm;name=aarch64_ghc9.6-xhtml-prof;unpack=0"
SRC_URI[aarch64_ghc9.6-xhtml-prof.sha256sum] = "32612cfbec5c0d3c84f43fc2195198dc5918608f99ac843c6cb6155cc9b659f5"

RDEPENDS:ghc9.6 = " \
 ghc9.6-compiler \
 ghc9.6-devel \
 ghc9.6-ghc-boot-devel \
 ghc9.6-ghc-compact-devel \
 ghc9.6-ghc-devel \
 ghc9.6-ghc-heap-devel \
 ghc9.6-ghci-devel \
 ghc9.6-hpc-devel \
 ghc9.6-libiserv-devel \
 "
RDEPENDS:ghc9.6-Cabal = " \
 ghc9.6-Cabal-syntax \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-binary \
 ghc9.6-bytestring \
 ghc9.6-containers \
 ghc9.6-deepseq \
 ghc9.6-directory \
 ghc9.6-exceptions \
 ghc9.6-filepath \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-mtl \
 ghc9.6-parsec \
 ghc9.6-pretty \
 ghc9.6-process \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-text \
 ghc9.6-time \
 ghc9.6-transformers \
 ghc9.6-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-Cabal-devel = " \
 ghc9.6-Cabal \
 ghc9.6-Cabal-syntax-devel \
 ghc9.6-array-devel \
 ghc9.6-base-devel \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-containers-devel \
 ghc9.6-deepseq-devel \
 ghc9.6-directory-devel \
 ghc9.6-filepath-devel \
 ghc9.6-mtl-devel \
 ghc9.6-parsec-devel \
 ghc9.6-pretty-devel \
 ghc9.6-process-devel \
 ghc9.6-text-devel \
 ghc9.6-time-devel \
 ghc9.6-transformers-devel \
 ghc9.6-unix-devel \
 "
RDEPENDS:ghc9.6-Cabal-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-Cabal-prof = " \
 ghc9.6-Cabal-devel \
 ghc9.6-Cabal-syntax-prof \
 ghc9.6-array-prof \
 ghc9.6-base-prof \
 ghc9.6-bytestring-prof \
 ghc9.6-containers-prof \
 ghc9.6-deepseq-prof \
 ghc9.6-directory-prof \
 ghc9.6-filepath-prof \
 ghc9.6-mtl-prof \
 ghc9.6-parsec-prof \
 ghc9.6-pretty-prof \
 ghc9.6-process-prof \
 ghc9.6-text-prof \
 ghc9.6-time-prof \
 ghc9.6-transformers-prof \
 ghc9.6-unix-prof \
 "
RDEPENDS:ghc9.6-Cabal-syntax = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-binary \
 ghc9.6-bytestring \
 ghc9.6-containers \
 ghc9.6-deepseq \
 ghc9.6-directory \
 ghc9.6-exceptions \
 ghc9.6-filepath \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-mtl \
 ghc9.6-parsec \
 ghc9.6-pretty \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-text \
 ghc9.6-time \
 ghc9.6-transformers \
 ghc9.6-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-Cabal-syntax-devel = " \
 ghc9.6-Cabal-syntax \
 ghc9.6-array-devel \
 ghc9.6-base-devel \
 ghc9.6-binary-devel \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-containers-devel \
 ghc9.6-deepseq-devel \
 ghc9.6-directory-devel \
 ghc9.6-filepath-devel \
 ghc9.6-mtl-devel \
 ghc9.6-parsec-devel \
 ghc9.6-pretty-devel \
 ghc9.6-text-devel \
 ghc9.6-time-devel \
 ghc9.6-transformers-devel \
 ghc9.6-unix-devel \
 "
RDEPENDS:ghc9.6-Cabal-syntax-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-Cabal-syntax-prof = " \
 ghc9.6-Cabal-syntax-devel \
 ghc9.6-array-prof \
 ghc9.6-base-prof \
 ghc9.6-binary-prof \
 ghc9.6-bytestring-prof \
 ghc9.6-containers-prof \
 ghc9.6-deepseq-prof \
 ghc9.6-directory-prof \
 ghc9.6-filepath-prof \
 ghc9.6-mtl-prof \
 ghc9.6-parsec-prof \
 ghc9.6-pretty-prof \
 ghc9.6-text-prof \
 ghc9.6-time-prof \
 ghc9.6-transformers-prof \
 ghc9.6-unix-prof \
 "
RDEPENDS:ghc9.6-array = " \
 ghc9.6-base \
 ghc9.6-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-array-devel = " \
 ghc9.6-array \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 "
RDEPENDS:ghc9.6-array-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-array-prof = " \
 ghc9.6-array-devel \
 ghc9.6-base-prof \
 "
RDEPENDS:ghc9.6-base = " \
 ghc9.6-ghc-bignum \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.6-base-devel = " \
 ghc9.6-base \
 ghc9.6-compiler \
 ghc9.6-ghc-bignum-devel \
 gmp-devel \
 libffi-devel \
 "
RDEPENDS:ghc9.6-base-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-base-prof = " \
 ghc9.6-base-devel \
 ghc9.6-ghc-bignum-prof \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.6-binary = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-bytestring \
 ghc9.6-containers \
 ghc9.6-deepseq \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-pretty \
 ghc9.6-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-binary-devel = " \
 ghc9.6-array-devel \
 ghc9.6-base-devel \
 ghc9.6-binary \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-containers-devel \
 "
RDEPENDS:ghc9.6-binary-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-binary-prof = " \
 ghc9.6-array-prof \
 ghc9.6-base-prof \
 ghc9.6-binary-devel \
 ghc9.6-bytestring-prof \
 ghc9.6-containers-prof \
 "
RDEPENDS:ghc9.6-bytestring = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-deepseq \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-pretty \
 ghc9.6-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-bytestring-devel = " \
 ghc9.6-base-devel \
 ghc9.6-bytestring \
 ghc9.6-compiler \
 ghc9.6-deepseq-devel \
 ghc9.6-template-haskell-devel \
 "
RDEPENDS:ghc9.6-bytestring-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-bytestring-prof = " \
 ghc9.6-base-prof \
 ghc9.6-bytestring-devel \
 ghc9.6-deepseq-prof \
 ghc9.6-template-haskell-prof \
 "
RDEPENDS:ghc9.6-compiler = " \
 bash \
 binutils \
 gcc \
 ghc9.6-Cabal \
 ghc9.6-Cabal-syntax \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-base-devel \
 ghc9.6-binary \
 ghc9.6-bytestring \
 ghc9.6-containers \
 ghc9.6-deepseq \
 ghc9.6-directory \
 ghc9.6-exceptions \
 ghc9.6-filepath \
 ghc9.6-filesystem \
 ghc9.6-ghc \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot \
 ghc9.6-ghc-boot-th \
 ghc9.6-ghc-heap \
 ghc9.6-ghci \
 ghc9.6-haskeline \
 ghc9.6-hpc \
 ghc9.6-libiserv \
 ghc9.6-mtl \
 ghc9.6-parsec \
 ghc9.6-pretty \
 ghc9.6-process \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-terminfo \
 ghc9.6-text \
 ghc9.6-time \
 ghc9.6-transformers \
 ghc9.6-unix \
 ghc9.6-xhtml \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 "
RDEPENDS:ghc9.6-compiler-default = " \
 bash \
 ghc9.6-compiler \
 "
RDEPENDS:ghc9.6-containers = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-deepseq \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-pretty \
 ghc9.6-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-containers-devel = " \
 ghc9.6-array-devel \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-containers \
 ghc9.6-deepseq-devel \
 ghc9.6-template-haskell-devel \
 "
RDEPENDS:ghc9.6-containers-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-containers-prof = " \
 ghc9.6-array-prof \
 ghc9.6-base-prof \
 ghc9.6-containers-devel \
 ghc9.6-deepseq-prof \
 ghc9.6-template-haskell-prof \
 "
RDEPENDS:ghc9.6-deepseq = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-deepseq-devel = " \
 ghc9.6-array-devel \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-deepseq \
 "
RDEPENDS:ghc9.6-deepseq-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-deepseq-prof = " \
 ghc9.6-array-prof \
 ghc9.6-base-prof \
 ghc9.6-deepseq-devel \
 "
RDEPENDS:ghc9.6-devel = " \
 ghc9.6-Cabal-devel \
 ghc9.6-Cabal-syntax-devel \
 ghc9.6-array-devel \
 ghc9.6-base-devel \
 ghc9.6-binary-devel \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-containers-devel \
 ghc9.6-deepseq-devel \
 ghc9.6-directory-devel \
 ghc9.6-exceptions-devel \
 ghc9.6-filepath-devel \
 ghc9.6-ghc-boot-th-devel \
 ghc9.6-haskeline-devel \
 ghc9.6-mtl-devel \
 ghc9.6-parsec-devel \
 ghc9.6-pretty-devel \
 ghc9.6-process-devel \
 ghc9.6-stm-devel \
 ghc9.6-template-haskell-devel \
 ghc9.6-terminfo-devel \
 ghc9.6-text-devel \
 ghc9.6-time-devel \
 ghc9.6-transformers-devel \
 ghc9.6-unix-devel \
 ghc9.6-xhtml-devel \
 "
RDEPENDS:ghc9.6-directory = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-bytestring \
 ghc9.6-deepseq \
 ghc9.6-exceptions \
 ghc9.6-filepath \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-mtl \
 ghc9.6-pretty \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-time \
 ghc9.6-transformers \
 ghc9.6-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-directory-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-directory \
 ghc9.6-filepath-devel \
 ghc9.6-time-devel \
 ghc9.6-unix-devel \
 "
RDEPENDS:ghc9.6-directory-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-directory-prof = " \
 ghc9.6-base-prof \
 ghc9.6-directory-devel \
 ghc9.6-filepath-prof \
 ghc9.6-time-prof \
 ghc9.6-unix-prof \
 "
RDEPENDS:ghc9.6-doc = " \
 "
RDEPENDS:ghc9.6-doc-index = " \
 ghc9.6-compiler \
 "
RDEPENDS:ghc9.6-exceptions = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-deepseq \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-mtl \
 ghc9.6-pretty \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-exceptions-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-exceptions \
 ghc9.6-mtl-devel \
 ghc9.6-stm-devel \
 ghc9.6-template-haskell-devel \
 ghc9.6-transformers-devel \
 "
RDEPENDS:ghc9.6-exceptions-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-exceptions-prof = " \
 ghc9.6-base-prof \
 ghc9.6-exceptions-devel \
 ghc9.6-mtl-prof \
 ghc9.6-stm-prof \
 ghc9.6-template-haskell-prof \
 ghc9.6-transformers-prof \
 "
RDEPENDS:ghc9.6-filepath = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-bytestring \
 ghc9.6-deepseq \
 ghc9.6-exceptions \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-mtl \
 ghc9.6-pretty \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-filepath-devel = " \
 ghc9.6-base-devel \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-deepseq-devel \
 ghc9.6-exceptions-devel \
 ghc9.6-filepath \
 ghc9.6-template-haskell-devel \
 "
RDEPENDS:ghc9.6-filepath-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-filepath-prof = " \
 ghc9.6-base-prof \
 ghc9.6-bytestring-prof \
 ghc9.6-deepseq-prof \
 ghc9.6-exceptions-prof \
 ghc9.6-filepath-devel \
 ghc9.6-template-haskell-prof \
 "
RDEPENDS:ghc9.6-filesystem = " \
 "
RDEPENDS:ghc9.6-ghc = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-binary \
 ghc9.6-bytestring \
 ghc9.6-containers \
 ghc9.6-deepseq \
 ghc9.6-directory \
 ghc9.6-exceptions \
 ghc9.6-filepath \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot \
 ghc9.6-ghc-boot-th \
 ghc9.6-ghc-heap \
 ghc9.6-ghci \
 ghc9.6-hpc \
 ghc9.6-mtl \
 ghc9.6-pretty \
 ghc9.6-process \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-time \
 ghc9.6-transformers \
 ghc9.6-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-ghc-bignum = " \
 ghc9.6-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-ghc-bignum-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-ghc-bignum \
 "
RDEPENDS:ghc9.6-ghc-bignum-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-ghc-bignum-prof = " \
 ghc9.6-base-prof \
 ghc9.6-ghc-bignum-devel \
 "
RDEPENDS:ghc9.6-ghc-boot = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-binary \
 ghc9.6-bytestring \
 ghc9.6-containers \
 ghc9.6-deepseq \
 ghc9.6-directory \
 ghc9.6-exceptions \
 ghc9.6-filepath \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-mtl \
 ghc9.6-pretty \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-time \
 ghc9.6-transformers \
 ghc9.6-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-ghc-boot-devel = " \
 ghc9.6-base-devel \
 ghc9.6-binary-devel \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-containers-devel \
 ghc9.6-deepseq-devel \
 ghc9.6-directory-devel \
 ghc9.6-filepath-devel \
 ghc9.6-ghc-boot \
 ghc9.6-ghc-boot-th-devel \
 ghc9.6-unix-devel \
 "
RDEPENDS:ghc9.6-ghc-boot-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-ghc-boot-prof = " \
 ghc9.6-base-prof \
 ghc9.6-binary-prof \
 ghc9.6-bytestring-prof \
 ghc9.6-containers-prof \
 ghc9.6-deepseq-prof \
 ghc9.6-directory-prof \
 ghc9.6-filepath-prof \
 ghc9.6-ghc-boot-devel \
 ghc9.6-ghc-boot-th-prof \
 ghc9.6-unix-prof \
 "
RDEPENDS:ghc9.6-ghc-boot-th = " \
 ghc9.6-base \
 ghc9.6-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-ghc-boot-th-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-ghc-boot-th \
 "
RDEPENDS:ghc9.6-ghc-boot-th-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-ghc-boot-th-prof = " \
 ghc9.6-base-prof \
 ghc9.6-ghc-boot-th-devel \
 "
RDEPENDS:ghc9.6-ghc-compact = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-bytestring \
 ghc9.6-deepseq \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-pretty \
 ghc9.6-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-ghc-compact-devel = " \
 ghc9.6-base-devel \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-ghc-compact \
 "
RDEPENDS:ghc9.6-ghc-compact-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-ghc-compact-prof = " \
 ghc9.6-base-prof \
 ghc9.6-bytestring-prof \
 ghc9.6-ghc-compact-devel \
 "
RDEPENDS:ghc9.6-ghc-devel = " \
 ghc9.6-array-devel \
 ghc9.6-base-devel \
 ghc9.6-binary-devel \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-containers-devel \
 ghc9.6-deepseq-devel \
 ghc9.6-directory-devel \
 ghc9.6-exceptions-devel \
 ghc9.6-filepath-devel \
 ghc9.6-ghc \
 ghc9.6-ghc-boot-devel \
 ghc9.6-ghc-heap-devel \
 ghc9.6-ghci-devel \
 ghc9.6-hpc-devel \
 ghc9.6-process-devel \
 ghc9.6-stm-devel \
 ghc9.6-template-haskell-devel \
 ghc9.6-time-devel \
 ghc9.6-transformers-devel \
 ghc9.6-unix-devel \
 "
RDEPENDS:ghc9.6-ghc-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-ghc-heap = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-containers \
 ghc9.6-deepseq \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-pretty \
 ghc9.6-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-ghc-heap-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-containers-devel \
 ghc9.6-ghc-heap \
 "
RDEPENDS:ghc9.6-ghc-heap-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-ghc-heap-prof = " \
 ghc9.6-base-prof \
 ghc9.6-containers-prof \
 ghc9.6-ghc-heap-devel \
 "
RDEPENDS:ghc9.6-ghc-prof = " \
 ghc9.6-array-prof \
 ghc9.6-base-prof \
 ghc9.6-binary-prof \
 ghc9.6-bytestring-prof \
 ghc9.6-containers-prof \
 ghc9.6-deepseq-prof \
 ghc9.6-directory-prof \
 ghc9.6-exceptions-prof \
 ghc9.6-filepath-prof \
 ghc9.6-ghc-boot-prof \
 ghc9.6-ghc-devel \
 ghc9.6-ghc-heap-prof \
 ghc9.6-ghci-prof \
 ghc9.6-hpc-prof \
 ghc9.6-process-prof \
 ghc9.6-stm-prof \
 ghc9.6-template-haskell-prof \
 ghc9.6-time-prof \
 ghc9.6-transformers-prof \
 ghc9.6-unix-prof \
 "
RDEPENDS:ghc9.6-ghci = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-binary \
 ghc9.6-bytestring \
 ghc9.6-containers \
 ghc9.6-deepseq \
 ghc9.6-directory \
 ghc9.6-exceptions \
 ghc9.6-filepath \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot \
 ghc9.6-ghc-boot-th \
 ghc9.6-ghc-heap \
 ghc9.6-mtl \
 ghc9.6-pretty \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-time \
 ghc9.6-transformers \
 ghc9.6-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-ghci-devel = " \
 ghc9.6-array-devel \
 ghc9.6-base-devel \
 ghc9.6-binary-devel \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-containers-devel \
 ghc9.6-deepseq-devel \
 ghc9.6-filepath-devel \
 ghc9.6-ghc-boot-devel \
 ghc9.6-ghc-heap-devel \
 ghc9.6-ghci \
 ghc9.6-template-haskell-devel \
 ghc9.6-transformers-devel \
 ghc9.6-unix-devel \
 "
RDEPENDS:ghc9.6-ghci-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-ghci-prof = " \
 ghc9.6-array-prof \
 ghc9.6-base-prof \
 ghc9.6-binary-prof \
 ghc9.6-bytestring-prof \
 ghc9.6-containers-prof \
 ghc9.6-deepseq-prof \
 ghc9.6-filepath-prof \
 ghc9.6-ghc-boot-prof \
 ghc9.6-ghc-heap-prof \
 ghc9.6-ghci-devel \
 ghc9.6-template-haskell-prof \
 ghc9.6-transformers-prof \
 ghc9.6-unix-prof \
 "
RDEPENDS:ghc9.6-hadrian = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.6-haskeline = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-bytestring \
 ghc9.6-containers \
 ghc9.6-deepseq \
 ghc9.6-directory \
 ghc9.6-exceptions \
 ghc9.6-filepath \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-mtl \
 ghc9.6-pretty \
 ghc9.6-process \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-terminfo \
 ghc9.6-time \
 ghc9.6-transformers \
 ghc9.6-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.6-haskeline-devel = " \
 ghc9.6-base-devel \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-containers-devel \
 ghc9.6-directory-devel \
 ghc9.6-exceptions-devel \
 ghc9.6-filepath-devel \
 ghc9.6-haskeline \
 ghc9.6-process-devel \
 ghc9.6-stm-devel \
 ghc9.6-terminfo-devel \
 ghc9.6-transformers-devel \
 ghc9.6-unix-devel \
 "
RDEPENDS:ghc9.6-haskeline-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-haskeline-prof = " \
 ghc9.6-base-prof \
 ghc9.6-bytestring-prof \
 ghc9.6-containers-prof \
 ghc9.6-directory-prof \
 ghc9.6-exceptions-prof \
 ghc9.6-filepath-prof \
 ghc9.6-haskeline-devel \
 ghc9.6-process-prof \
 ghc9.6-stm-prof \
 ghc9.6-terminfo-prof \
 ghc9.6-transformers-prof \
 ghc9.6-unix-prof \
 "
RDEPENDS:ghc9.6-hpc = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-bytestring \
 ghc9.6-containers \
 ghc9.6-deepseq \
 ghc9.6-directory \
 ghc9.6-exceptions \
 ghc9.6-filepath \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-mtl \
 ghc9.6-pretty \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-time \
 ghc9.6-transformers \
 ghc9.6-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-hpc-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-containers-devel \
 ghc9.6-deepseq-devel \
 ghc9.6-directory-devel \
 ghc9.6-filepath-devel \
 ghc9.6-hpc \
 ghc9.6-time-devel \
 "
RDEPENDS:ghc9.6-hpc-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-hpc-prof = " \
 ghc9.6-base-prof \
 ghc9.6-containers-prof \
 ghc9.6-deepseq-prof \
 ghc9.6-directory-prof \
 ghc9.6-filepath-prof \
 ghc9.6-hpc-devel \
 ghc9.6-time-prof \
 "
RDEPENDS:ghc9.6-libiserv = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-binary \
 ghc9.6-bytestring \
 ghc9.6-containers \
 ghc9.6-deepseq \
 ghc9.6-directory \
 ghc9.6-exceptions \
 ghc9.6-filepath \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot \
 ghc9.6-ghc-boot-th \
 ghc9.6-ghc-heap \
 ghc9.6-ghci \
 ghc9.6-mtl \
 ghc9.6-pretty \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-time \
 ghc9.6-transformers \
 ghc9.6-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-libiserv-devel = " \
 ghc9.6-base-devel \
 ghc9.6-binary-devel \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-containers-devel \
 ghc9.6-deepseq-devel \
 ghc9.6-ghci-devel \
 ghc9.6-libiserv \
 ghc9.6-unix-devel \
 "
RDEPENDS:ghc9.6-libiserv-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-libiserv-prof = " \
 ghc9.6-base-prof \
 ghc9.6-binary-prof \
 ghc9.6-bytestring-prof \
 ghc9.6-containers-prof \
 ghc9.6-deepseq-prof \
 ghc9.6-ghci-prof \
 ghc9.6-libiserv-devel \
 ghc9.6-unix-prof \
 "
RDEPENDS:ghc9.6-manual = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-mtl = " \
 ghc9.6-base \
 ghc9.6-ghc-bignum \
 ghc9.6-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-mtl-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-mtl \
 ghc9.6-transformers-devel \
 "
RDEPENDS:ghc9.6-mtl-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-mtl-prof = " \
 ghc9.6-base-prof \
 ghc9.6-mtl-devel \
 ghc9.6-transformers-prof \
 "
RDEPENDS:ghc9.6-parsec = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-binary \
 ghc9.6-bytestring \
 ghc9.6-containers \
 ghc9.6-deepseq \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-mtl \
 ghc9.6-pretty \
 ghc9.6-template-haskell \
 ghc9.6-text \
 ghc9.6-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-parsec-devel = " \
 ghc9.6-base-devel \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-mtl-devel \
 ghc9.6-parsec \
 ghc9.6-text-devel \
 "
RDEPENDS:ghc9.6-parsec-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-parsec-prof = " \
 ghc9.6-base-prof \
 ghc9.6-bytestring-prof \
 ghc9.6-mtl-prof \
 ghc9.6-parsec-devel \
 ghc9.6-text-prof \
 "
RDEPENDS:ghc9.6-pretty = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-deepseq \
 ghc9.6-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-pretty-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-deepseq-devel \
 ghc9.6-pretty \
 "
RDEPENDS:ghc9.6-pretty-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-pretty-prof = " \
 ghc9.6-base-prof \
 ghc9.6-deepseq-prof \
 ghc9.6-pretty-devel \
 "
RDEPENDS:ghc9.6-process = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-bytestring \
 ghc9.6-deepseq \
 ghc9.6-directory \
 ghc9.6-exceptions \
 ghc9.6-filepath \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-mtl \
 ghc9.6-pretty \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-time \
 ghc9.6-transformers \
 ghc9.6-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-process-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-deepseq-devel \
 ghc9.6-directory-devel \
 ghc9.6-filepath-devel \
 ghc9.6-process \
 ghc9.6-unix-devel \
 "
RDEPENDS:ghc9.6-process-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-process-prof = " \
 ghc9.6-base-prof \
 ghc9.6-deepseq-prof \
 ghc9.6-directory-prof \
 ghc9.6-filepath-prof \
 ghc9.6-process-devel \
 ghc9.6-unix-prof \
 "
RDEPENDS:ghc9.6-prof = " \
 ghc9.6-compiler \
 "
RDEPENDS:ghc9.6-stm = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-stm-devel = " \
 ghc9.6-array-devel \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-stm \
 "
RDEPENDS:ghc9.6-stm-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-stm-prof = " \
 ghc9.6-array-prof \
 ghc9.6-base-prof \
 ghc9.6-stm-devel \
 "
RDEPENDS:ghc9.6-template-haskell = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-deepseq \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-template-haskell-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-ghc-boot-th-devel \
 ghc9.6-pretty-devel \
 ghc9.6-template-haskell \
 "
RDEPENDS:ghc9.6-template-haskell-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-template-haskell-prof = " \
 ghc9.6-base-prof \
 ghc9.6-ghc-boot-th-prof \
 ghc9.6-pretty-prof \
 ghc9.6-template-haskell-devel \
 "
RDEPENDS:ghc9.6-terminfo = " \
 ghc9.6-base \
 ghc9.6-ghc-bignum \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.6-terminfo-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-terminfo \
 ncurses-devel \
 "
RDEPENDS:ghc9.6-terminfo-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-terminfo-prof = " \
 ghc9.6-base-prof \
 ghc9.6-terminfo-devel \
 "
RDEPENDS:ghc9.6-text = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-binary \
 ghc9.6-bytestring \
 ghc9.6-containers \
 ghc9.6-deepseq \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-pretty \
 ghc9.6-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-text-devel = " \
 ghc9.6-array-devel \
 ghc9.6-base-devel \
 ghc9.6-binary-devel \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-deepseq-devel \
 ghc9.6-template-haskell-devel \
 ghc9.6-text \
 "
RDEPENDS:ghc9.6-text-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-text-prof = " \
 ghc9.6-array-prof \
 ghc9.6-base-prof \
 ghc9.6-binary-prof \
 ghc9.6-bytestring-prof \
 ghc9.6-deepseq-prof \
 ghc9.6-template-haskell-prof \
 ghc9.6-text-devel \
 "
RDEPENDS:ghc9.6-time = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-deepseq \
 ghc9.6-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-time-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-deepseq-devel \
 ghc9.6-time \
 "
RDEPENDS:ghc9.6-time-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-time-prof = " \
 ghc9.6-base-prof \
 ghc9.6-deepseq-prof \
 ghc9.6-time-devel \
 "
RDEPENDS:ghc9.6-transformers = " \
 ghc9.6-base \
 ghc9.6-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-transformers-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-transformers \
 "
RDEPENDS:ghc9.6-transformers-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-transformers-prof = " \
 ghc9.6-base-prof \
 ghc9.6-transformers-devel \
 "
RDEPENDS:ghc9.6-unix = " \
 ghc9.6-array \
 ghc9.6-base \
 ghc9.6-bytestring \
 ghc9.6-deepseq \
 ghc9.6-exceptions \
 ghc9.6-filepath \
 ghc9.6-ghc-bignum \
 ghc9.6-ghc-boot-th \
 ghc9.6-mtl \
 ghc9.6-pretty \
 ghc9.6-stm \
 ghc9.6-template-haskell \
 ghc9.6-time \
 ghc9.6-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-unix-devel = " \
 ghc9.6-base-devel \
 ghc9.6-bytestring-devel \
 ghc9.6-compiler \
 ghc9.6-filepath-devel \
 ghc9.6-time-devel \
 ghc9.6-unix \
 "
RDEPENDS:ghc9.6-unix-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-unix-prof = " \
 ghc9.6-base-prof \
 ghc9.6-bytestring-prof \
 ghc9.6-filepath-prof \
 ghc9.6-time-prof \
 ghc9.6-unix-devel \
 "
RDEPENDS:ghc9.6-xhtml = " \
 ghc9.6-base \
 ghc9.6-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.6-xhtml-devel = " \
 ghc9.6-base-devel \
 ghc9.6-compiler \
 ghc9.6-xhtml \
 "
RDEPENDS:ghc9.6-xhtml-doc = " \
 ghc9.6-filesystem \
 "
RDEPENDS:ghc9.6-xhtml-prof = " \
 ghc9.6-base-prof \
 ghc9.6-xhtml-devel \
 "
