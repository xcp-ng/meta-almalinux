# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "foomuuri"
PV = "0.28"
PR = "1.el10_0"
PACKAGES = " \
 foomuuri \
 foomuuri-firewalld \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/foomuuri-0.28-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eae9cff4f801522c72b22ff5cc09fec3ce429437bbbf80835be013f4c9b4eb04"

URI_x86_64_v2_foomuuri = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foomuuri-0.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_foomuuri;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foomuuri}"
SRC_URI[x86_64_v2_foomuuri.sha256sum] = "26e09f6ec2dd21a8e3dcaf10d1ae1c8c2d0995469c5a19f19c93181f87cacbd3"

URI_x86_64_v2_foomuuri-firewalld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foomuuri-firewalld-0.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_foomuuri-firewalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foomuuri-firewalld}"
SRC_URI[x86_64_v2_foomuuri-firewalld.sha256sum] = "dab759215e4a6013cf560d0f8a5c2d88cd5c678cd7eca457b51651a329de0a0a"

URI_aarch64_foomuuri = "${EPEL_MIRROR}/aarch64/Packages/f/foomuuri-0.28-1.el10_0.noarch.rpm;name=aarch64_foomuuri;unpack=0"
SRC_URI:append = " ${URI_aarch64_foomuuri}"
SRC_URI[aarch64_foomuuri.sha256sum] = "8f2181f91470b267d33d0afa04b8dea5345408b7163b8e39f658f1b188bdc804"

URI_aarch64_foomuuri-firewalld = "${EPEL_MIRROR}/aarch64/Packages/f/foomuuri-firewalld-0.28-1.el10_0.noarch.rpm;name=aarch64_foomuuri-firewalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_foomuuri-firewalld}"
SRC_URI[aarch64_foomuuri-firewalld.sha256sum] = "3249ac932ec876cacfd8ed1f1e7a440f3c5fe3fc710f64a99ca54216227ce218"

RDEPENDS:foomuuri = " \
 bash \
 nftables \
 python3 \
 python3-dbus \
 python3-gobject \
 python3-systemd \
 systemd \
 "
RDEPENDS:foomuuri-firewalld = " \
 foomuuri \
 "
