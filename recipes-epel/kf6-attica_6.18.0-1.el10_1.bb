# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-attica"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-attica \
 kf6-attica-devel \
 kf6-attica-doc \
 kf6-attica-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-attica-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "438e271695dde06269579f29696d27068ed06d70df240d226898fe2b54b720c2"

URI_x86_64_v2_kf6-attica = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-attica;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica}"
SRC_URI[x86_64_v2_kf6-attica.sha256sum] = "7d755933a19bc66418954f15ec832c0c5b6885fb3672d743a6a257d61277b9d9"

URI_x86_64_v2_kf6-attica-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-attica-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica-devel}"
SRC_URI[x86_64_v2_kf6-attica-devel.sha256sum] = "a48870668c325c1ff6fb8a8d290d6e338a6eb24533463ade27b82f39e252712c"

URI_x86_64_v2_kf6-attica-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-attica-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica-doc}"
SRC_URI[x86_64_v2_kf6-attica-doc.sha256sum] = "404da82d53d7a643b04e77f1e962eb93eda12b96b5252a64863ebcd7694609d5"

URI_x86_64_v2_kf6-attica-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-attica-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica-html}"
SRC_URI[x86_64_v2_kf6-attica-html.sha256sum] = "2834d881e92b34097c2d70c49fcdd8c34c1aa759ff4a74e5407e1d11a6c6f8f3"

URI_aarch64_kf6-attica = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-attica;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica}"
SRC_URI[aarch64_kf6-attica.sha256sum] = "e09d5a11f5a665ea56be701bb502f66da042e7b26929dc8fc1948c0b93380e65"

URI_aarch64_kf6-attica-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-attica-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica-devel}"
SRC_URI[aarch64_kf6-attica-devel.sha256sum] = "f4b03ffeb711a19fa62cdd1dc6b29fcd08e0d0eeef1691e1c64fd0e54bdcb383"

URI_aarch64_kf6-attica-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-attica-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica-doc}"
SRC_URI[aarch64_kf6-attica-doc.sha256sum] = "d0350a3c764d3387797c62791e304d155a4b1e0476b7915996da52c09c5a575f"

URI_aarch64_kf6-attica-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-attica-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica-html}"
SRC_URI[aarch64_kf6-attica-html.sha256sum] = "649d8b954dfbf2e71a805e33edd55d9251a195821c0d3eea3db9600ad8b810b4"

RDEPENDS:kf6-attica = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-attica-devel = " \
 cmake-filesystem \
 kf6-attica \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-attica-doc = " \
 "
RDEPENDS:kf6-attica-html = " \
 "
