# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "superlu_dist"
PE = "1"
PV = "8.2.0"
PR = "10.el10_1"
PACKAGES = " \
 superlu_dist-doc \
 superlu_dist-mpich \
 superlu_dist-mpich-devel \
 superlu_dist-openmpi \
 superlu_dist-openmpi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/superlu_dist-8.2.0-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f63ad675541ba19acc36a105e785332ed49bf9bc6a7a672adcda41fef42d27a"

URI_x86_64_v2_superlu_dist-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-doc-8.2.0-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_superlu_dist-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-doc}"
SRC_URI[x86_64_v2_superlu_dist-doc.sha256sum] = "6f61bce4d1bc41697e8b42f0d56e91e4438193c3d506b7145b918a5d3ac58d21"

URI_x86_64_v2_superlu_dist-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-mpich-8.2.0-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_superlu_dist-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-mpich}"
SRC_URI[x86_64_v2_superlu_dist-mpich.sha256sum] = "df1a8d6d991ac1f657060131941f379fd57a2924f113a68199c86f71c7a8a523"

URI_x86_64_v2_superlu_dist-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-mpich-devel-8.2.0-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_superlu_dist-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-mpich-devel}"
SRC_URI[x86_64_v2_superlu_dist-mpich-devel.sha256sum] = "33569fcb4729f15229d6280f9df43bd1305cd63fa8263071ed6c291ff3c8834e"

URI_x86_64_v2_superlu_dist-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-openmpi-8.2.0-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_superlu_dist-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-openmpi}"
SRC_URI[x86_64_v2_superlu_dist-openmpi.sha256sum] = "f25af0a2f69785c2c89be67c5c9721bb4611c08ca2a3e59c1b8fdf187cc92a1c"

URI_x86_64_v2_superlu_dist-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-openmpi-devel-8.2.0-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_superlu_dist-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-openmpi-devel}"
SRC_URI[x86_64_v2_superlu_dist-openmpi-devel.sha256sum] = "a7da4ea1f31d74755a11767ee0cd9bd213c8b4517fb61ff8924bd76282e45cfd"

URI_aarch64_superlu_dist-doc = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-doc-8.2.0-10.el10_1.noarch.rpm;name=aarch64_superlu_dist-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-doc}"
SRC_URI[aarch64_superlu_dist-doc.sha256sum] = "eab63025220671f89a7b6416b9863f903bff8c546f613bd7b47e014e69e7ce6f"

URI_aarch64_superlu_dist-mpich = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-mpich-8.2.0-10.el10_1.aarch64.rpm;name=aarch64_superlu_dist-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-mpich}"
SRC_URI[aarch64_superlu_dist-mpich.sha256sum] = "bda2011d6ab9b2825009341b3f943a1cfa01f9bb92a9e09b3cddef3eb4b17378"

URI_aarch64_superlu_dist-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-mpich-devel-8.2.0-10.el10_1.aarch64.rpm;name=aarch64_superlu_dist-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-mpich-devel}"
SRC_URI[aarch64_superlu_dist-mpich-devel.sha256sum] = "f961c600129581e7dbc5beb03dc2511ca6a2737ae093b48bd89145ef98d499e0"

URI_aarch64_superlu_dist-openmpi = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-openmpi-8.2.0-10.el10_1.aarch64.rpm;name=aarch64_superlu_dist-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-openmpi}"
SRC_URI[aarch64_superlu_dist-openmpi.sha256sum] = "487b0309ac3d8c957675c3120510fb85b02f93f7ed6136bcc4ec3beccd0126be"

URI_aarch64_superlu_dist-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-openmpi-devel-8.2.0-10.el10_1.aarch64.rpm;name=aarch64_superlu_dist-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-openmpi-devel}"
SRC_URI[aarch64_superlu_dist-openmpi-devel.sha256sum] = "e849628754994788207f869303e4936a3ea60b138e30d1847ed5843f4b16462e"

RDEPENDS:superlu_dist-doc = " \
 "
RDEPENDS:superlu_dist-mpich = " \
 flexiblas-netlib \
 gcc-gfortran \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 metis \
 mpich \
 ptscotch-mpich \
 "
RDEPENDS:superlu_dist-mpich-devel = " \
 mpich-devel \
 ptscotch-mpich-devel \
 ptscotch-mpich-devel-parmetis \
 superlu_dist-mpich \
 "
RDEPENDS:superlu_dist-openmpi = " \
 flexiblas-netlib \
 gcc-gfortran \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 metis \
 openmpi \
 ptscotch-openmpi \
 "
RDEPENDS:superlu_dist-openmpi-devel = " \
 openmpi-devel \
 superlu_dist-openmpi \
 "
