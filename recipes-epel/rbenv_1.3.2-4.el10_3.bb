# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rbenv"
PV = "1.3.2"
PR = "4.el10_3"
PACKAGES = " \
 rbenv \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rbenv-1.3.2-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b58ff9ba5eaec4c5575961a72df06139d7c921bc0c8ed7f54ce55c4397c4ddcd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rbenv-1.3.2-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rbenv;unpack=0"
SRC_URI[x86_64_v2_rbenv.sha256sum] = "28927bd4d36d2437a0180af4c072a404187b104cf2316a0f92527419aca4a2bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rbenv-1.3.2-4.el10_3.noarch.rpm;name=aarch64_rbenv;unpack=0"
SRC_URI[aarch64_rbenv.sha256sum] = "324aaf744129603cad2653b592e4706c6a6775715871f3d4efda3c2d1c37b7b8"

RDEPENDS:rbenv = " \
 bash \
 gawk \
 "
