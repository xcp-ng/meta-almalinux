# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtserialbus"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtserialbus \
 qt5-qtserialbus-devel \
 qt5-qtserialbus-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtserialbus-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d49a8abb2b7f85d0e607bfcd350d4c05bc23c2ebc2fca02f08ab64a39b1a5cbc"

URI_x86_64_v2_qt5-qtserialbus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialbus-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialbus}"
SRC_URI[x86_64_v2_qt5-qtserialbus.sha256sum] = "1396753c1ac7957b7a14d7737ab95396467b4f5e3baac75d5a66893e671d2b54"

URI_x86_64_v2_qt5-qtserialbus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialbus-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialbus-devel}"
SRC_URI[x86_64_v2_qt5-qtserialbus-devel.sha256sum] = "943d55863f6af0fe5fce7f1eda3b95379a769f86eef539563b32107145959d04"

URI_x86_64_v2_qt5-qtserialbus-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialbus-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialbus-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialbus-examples}"
SRC_URI[x86_64_v2_qt5-qtserialbus-examples.sha256sum] = "f6e75f5773e22531868cdfa19e7acfd0ee55b04c99efa52fe8299ae1ebeb80aa"

URI_aarch64_qt5-qtserialbus = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialbus-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtserialbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialbus}"
SRC_URI[aarch64_qt5-qtserialbus.sha256sum] = "28d80db1d226afc66dfa452b1b818d0c484f07ded285ce510e4cea00fbf2db15"

URI_aarch64_qt5-qtserialbus-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialbus-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtserialbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialbus-devel}"
SRC_URI[aarch64_qt5-qtserialbus-devel.sha256sum] = "3e8ac70cd4af75d4457e859481ee0c72dea1bd4efefe5860d46e16ef328d7358"

URI_aarch64_qt5-qtserialbus-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialbus-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtserialbus-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialbus-examples}"
SRC_URI[aarch64_qt5-qtserialbus-examples.sha256sum] = "f7c618adf2a6684129180ff847c81ca1fefb48f89980dc4f836c5ecbd758abd7"

RDEPENDS:qt5-qtserialbus = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtserialport \
 "
RDEPENDS:qt5-qtserialbus-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtserialbus \
 "
RDEPENDS:qt5-qtserialbus-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtserialbus \
 qt5-qtserialport \
 "
