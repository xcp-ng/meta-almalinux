# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-directories"
PV = "6.0.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-directories+default-devel \
 rust-directories-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-directories-6.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ede535da65d2a9976915aecaff0c2525d774e84f20a37381b25bc91dd91ae4a"

URI_x86_64_v2_rust-directories+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-directories+default-devel-6.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-directories+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-directories+default-devel}"
SRC_URI[x86_64_v2_rust-directories+default-devel.sha256sum] = "473f283c37231404ad4c2a48a09699ebcba5b73a1333d81a6e132925ca0503e1"

URI_x86_64_v2_rust-directories-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-directories-devel-6.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-directories-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-directories-devel}"
SRC_URI[x86_64_v2_rust-directories-devel.sha256sum] = "bd9c7f6406c97c4494477ed5ba32e790fa4ae052dcc8e5473370919a99a97330"

URI_aarch64_rust-directories+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-directories+default-devel-6.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-directories+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-directories+default-devel}"
SRC_URI[aarch64_rust-directories+default-devel.sha256sum] = "b0c98d99f1d18d347510ef28a76b8acc449a1302369de5aa5b98f517113701c5"

URI_aarch64_rust-directories-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-directories-devel-6.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-directories-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-directories-devel}"
SRC_URI[aarch64_rust-directories-devel.sha256sum] = "018fd726e2dcd355708696d3bac73954449dc4e8cf835dcfa2a23cf07d384453"

RDEPENDS:rust-directories+default-devel = " \
 cargo \
 rust-directories-devel \
 "
RDEPENDS:rust-directories-devel = " \
 cargo \
 rust-dirs-sys+default-devel \
 "
