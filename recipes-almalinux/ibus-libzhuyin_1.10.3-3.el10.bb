# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus-libzhuyin"
PV = "1.10.3"
PR = "3.el10"
PACKAGES = " \
 ibus-libzhuyin \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ibus-libzhuyin-1.10.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7bd44b4ebb3feda7e8700beda76eae6b22cfed9b2773ad36c7f455e0ce770a8"

URI_x86_64_v2_ibus-libzhuyin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-libzhuyin-1.10.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-libzhuyin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-libzhuyin}"
SRC_URI[x86_64_v2_ibus-libzhuyin.sha256sum] = "6724db3b581b30418038cb4d4d135af05c9cb9ee56642877905aea4afb572c7b"

URI_aarch64_ibus-libzhuyin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-libzhuyin-1.10.3-3.el10.aarch64.rpm;name=aarch64_ibus-libzhuyin;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-libzhuyin}"
SRC_URI[aarch64_ibus-libzhuyin.sha256sum] = "d7b87089a8563adafe421dc697f2556c639a2c6f31182af226c99e85ca2b4e14"

RDEPENDS:ibus-libzhuyin = " \
 bash \
 glib2 \
 glibc \
 ibus \
 ibus-libs \
 libgcc \
 libstdc++ \
 libzhuyin \
 "
