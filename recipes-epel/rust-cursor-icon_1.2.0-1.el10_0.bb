# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursor-icon"
PV = "1.2.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-cursor-icon+alloc-devel \
 rust-cursor-icon+default-devel \
 rust-cursor-icon+serde-devel \
 rust-cursor-icon+std-devel \
 rust-cursor-icon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursor-icon-1.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9edf56033f6428ca9515f0a2811be97c67c24bb5a2009d767c87481bbe01739"

URI_x86_64_v2_rust-cursor-icon+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursor-icon+alloc-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursor-icon+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursor-icon+alloc-devel}"
SRC_URI[x86_64_v2_rust-cursor-icon+alloc-devel.sha256sum] = "bd545fd23843cb45b68da63401e2e991ba48e7fb05381ca05eea619e44f919fe"

URI_x86_64_v2_rust-cursor-icon+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursor-icon+default-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursor-icon+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursor-icon+default-devel}"
SRC_URI[x86_64_v2_rust-cursor-icon+default-devel.sha256sum] = "6dbeb7258e287f7c24cb365b2c0caccc2146e0c8e368c3291176f7951751ea6e"

URI_x86_64_v2_rust-cursor-icon+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursor-icon+serde-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursor-icon+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursor-icon+serde-devel}"
SRC_URI[x86_64_v2_rust-cursor-icon+serde-devel.sha256sum] = "7503881dcfba929004ca229ea67bf5c20ec29ce580a016b7b68c3e99627a85d7"

URI_x86_64_v2_rust-cursor-icon+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursor-icon+std-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursor-icon+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursor-icon+std-devel}"
SRC_URI[x86_64_v2_rust-cursor-icon+std-devel.sha256sum] = "63d4dd649ffeb9c1680dc5d1a5fdf895e0cc95c7add3666642c70e1cfdd0fdca"

URI_x86_64_v2_rust-cursor-icon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursor-icon-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursor-icon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursor-icon-devel}"
SRC_URI[x86_64_v2_rust-cursor-icon-devel.sha256sum] = "344292f3332ee3840141fb2cef933f271f16acc00b8fcc76a4e7f8a2d1c80d9f"

URI_aarch64_rust-cursor-icon+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursor-icon+alloc-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-cursor-icon+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursor-icon+alloc-devel}"
SRC_URI[aarch64_rust-cursor-icon+alloc-devel.sha256sum] = "131855d3d7a535a3930991ae36e9d3382b2db76af6d756f2c2136888ce909b61"

URI_aarch64_rust-cursor-icon+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursor-icon+default-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-cursor-icon+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursor-icon+default-devel}"
SRC_URI[aarch64_rust-cursor-icon+default-devel.sha256sum] = "63abac71735fb0ff4313c59c71f17c301e413e3b47585ebea10f359d83ba793d"

URI_aarch64_rust-cursor-icon+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursor-icon+serde-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-cursor-icon+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursor-icon+serde-devel}"
SRC_URI[aarch64_rust-cursor-icon+serde-devel.sha256sum] = "a495be6f6389eeba392c5bd0247131c03340900b97a928c06dc1ed662a73a509"

URI_aarch64_rust-cursor-icon+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursor-icon+std-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-cursor-icon+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursor-icon+std-devel}"
SRC_URI[aarch64_rust-cursor-icon+std-devel.sha256sum] = "01f5773eb5475fd0a75df71b2054e3cbbe5c9aed2ef749c7d4e4ce3222693361"

URI_aarch64_rust-cursor-icon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursor-icon-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-cursor-icon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursor-icon-devel}"
SRC_URI[aarch64_rust-cursor-icon-devel.sha256sum] = "46610dbc213014fecaa8b1a47bfc038198bb0e442cda2cd584c1b54090d98281"

RDEPENDS:rust-cursor-icon+alloc-devel = " \
 cargo \
 rust-cursor-icon-devel \
 "
RDEPENDS:rust-cursor-icon+default-devel = " \
 cargo \
 rust-cursor-icon+std-devel \
 rust-cursor-icon-devel \
 "
RDEPENDS:rust-cursor-icon+serde-devel = " \
 cargo \
 rust-cursor-icon-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-cursor-icon+std-devel = " \
 cargo \
 rust-cursor-icon+alloc-devel \
 rust-cursor-icon-devel \
 "
RDEPENDS:rust-cursor-icon-devel = " \
 cargo \
 rust \
 "
