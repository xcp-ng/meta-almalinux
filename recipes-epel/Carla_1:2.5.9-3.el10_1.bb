# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "Carla"
PE = "1"
PV = "2.5.9"
PR = "3.el10_1"
PACKAGES = " \
 Carla \
 Carla-devel \
 Carla-vst \
 lv2-carla \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/Carla-2.5.9-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd51ecdce75924553eb68c3a270d599c5c6a36c4546b19ad47cbf1936b32998a"

URI_x86_64_v2_Carla = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/Carla-2.5.9-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_Carla;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_Carla}"
SRC_URI[x86_64_v2_Carla.sha256sum] = "566cd055bf8dfe0ec3b4248715926b6b3a18587c7e13dc9e4679695f445a6d36"

URI_x86_64_v2_Carla-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/Carla-devel-2.5.9-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_Carla-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_Carla-devel}"
SRC_URI[x86_64_v2_Carla-devel.sha256sum] = "419b440cb7e250fda08f0abe5a9aa49b7294261150b70a0577b40d4feb5b9a6f"

URI_x86_64_v2_Carla-vst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/Carla-vst-2.5.9-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_Carla-vst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_Carla-vst}"
SRC_URI[x86_64_v2_Carla-vst.sha256sum] = "04bf8f5858331c7c6f7c2ff3a786ce1fb6c276725acb2231816e583218e8b61f"

URI_x86_64_v2_lv2-carla = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lv2-carla-2.5.9-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lv2-carla;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lv2-carla}"
SRC_URI[x86_64_v2_lv2-carla.sha256sum] = "9a6a204dab777efeb70a83312a68a43bfd0fb45d194894ef77bad12878ab9eff"

URI_aarch64_Carla = "${EPEL_MIRROR}/aarch64/Packages/c/Carla-2.5.9-3.el10_1.aarch64.rpm;name=aarch64_Carla;unpack=0"
SRC_URI:append = " ${URI_aarch64_Carla}"
SRC_URI[aarch64_Carla.sha256sum] = "3a87349ca8ce0fa933bfca6ac82931f42cbac8da31073c8cdb3a07b4e29e9fc7"

URI_aarch64_Carla-devel = "${EPEL_MIRROR}/aarch64/Packages/c/Carla-devel-2.5.9-3.el10_1.aarch64.rpm;name=aarch64_Carla-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_Carla-devel}"
SRC_URI[aarch64_Carla-devel.sha256sum] = "9ff95ec8a28e2cee7e58571bc5c34e704ca7eb462c3d6367a4a235d8c5e9cc63"

URI_aarch64_Carla-vst = "${EPEL_MIRROR}/aarch64/Packages/c/Carla-vst-2.5.9-3.el10_1.aarch64.rpm;name=aarch64_Carla-vst;unpack=0"
SRC_URI:append = " ${URI_aarch64_Carla-vst}"
SRC_URI[aarch64_Carla-vst.sha256sum] = "4a74079cfb81ea4bda0f3d513e5abe5915153a61be677055fcef896c4c2fdbb5"

URI_aarch64_lv2-carla = "${EPEL_MIRROR}/aarch64/Packages/l/lv2-carla-2.5.9-3.el10_1.aarch64.rpm;name=aarch64_lv2-carla;unpack=0"
SRC_URI:append = " ${URI_aarch64_lv2-carla}"
SRC_URI[aarch64_lv2-carla.sha256sum] = "f1667f358c186f142b06d47ab672a9b75a482c8cbfb964dd285334b622330c74"

RDEPENDS:Carla = " \
 a2jmidid \
 alsa-lib \
 bash \
 fluidsynth-libs \
 freetype \
 glibc \
 hicolor-icon-theme \
 libX11 \
 libgcc \
 libglvnd-glx \
 liblo \
 libsndfile \
 libstdc++ \
 pulseaudio-libs \
 python3 \
 python3-pyliblo3 \
 python3-qt5 \
 qt5-qtbase \
 qt5-qtbase-gui \
 shared-mime-info \
 "
RDEPENDS:Carla-devel = " \
 Carla \
 pkgconf-pkg-config \
 "
RDEPENDS:Carla-vst = " \
 Carla \
 fluidsynth-libs \
 freetype \
 glibc \
 libX11 \
 libgcc \
 libglvnd-glx \
 liblo \
 libsndfile \
 libstdc++ \
 "
RDEPENDS:lv2-carla = " \
 Carla \
 fluidsynth-libs \
 freetype \
 glibc \
 libX11 \
 libgcc \
 libglvnd-glx \
 liblo \
 libsndfile \
 libstdc++ \
 "
