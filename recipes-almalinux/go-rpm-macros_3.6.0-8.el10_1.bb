# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-rpm-macros"
PV = "3.6.0"
PR = "8.el10_1"
PACKAGES = " \
 go-filesystem \
 go-rpm-macros \
 go-rpm-templates \
 go-srpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/go-rpm-macros-3.6.0-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6de375517637b62facf7befacbd24bbc9c1b1316a4335ebb284c82079a09e872"

URI_x86_64_v2_go-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-filesystem-3.6.0-8.el10_1.x86_64_v2.rpm;name=x86_64_v2_go-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-filesystem}"
SRC_URI[x86_64_v2_go-filesystem.sha256sum] = "3d01abf19645453ffec1a83d80a49e1c112f9acf65604814abc4724a08d1c936"

URI_x86_64_v2_go-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-rpm-macros-3.6.0-8.el10_1.x86_64_v2.rpm;name=x86_64_v2_go-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-rpm-macros}"
SRC_URI[x86_64_v2_go-rpm-macros.sha256sum] = "cf9042a14afb0e12af4a0689350197d013cc9d509715c4871f29c148ee414567"

URI_x86_64_v2_go-rpm-templates = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-rpm-templates-3.6.0-8.el10_1.x86_64_v2.rpm;name=x86_64_v2_go-rpm-templates;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-rpm-templates}"
SRC_URI[x86_64_v2_go-rpm-templates.sha256sum] = "d8c8382d30d804b3ba60f61bc193098486a46513eed1085c653c9514580da9d2"

URI_x86_64_v2_go-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-srpm-macros-3.6.0-8.el10_1.noarch.rpm;name=x86_64_v2_go-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-srpm-macros}"
SRC_URI[x86_64_v2_go-srpm-macros.sha256sum] = "aece88f82fcf24e15aec8de9ca3718e766d872195d82443ac3469dd306a04756"

URI_aarch64_go-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-filesystem-3.6.0-8.el10_1.aarch64.rpm;name=aarch64_go-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-filesystem}"
SRC_URI[aarch64_go-filesystem.sha256sum] = "83f64e0441aff68a0b663cb244d864028650556ec3e2bd36ec65fe5865352b98"

URI_aarch64_go-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-rpm-macros-3.6.0-8.el10_1.aarch64.rpm;name=aarch64_go-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-rpm-macros}"
SRC_URI[aarch64_go-rpm-macros.sha256sum] = "4fd04d1a47423c9328ac3391f1682c9aefd5d8504f3fb4b7057a44a5704226fe"

URI_aarch64_go-rpm-templates = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-rpm-templates-3.6.0-8.el10_1.aarch64.rpm;name=aarch64_go-rpm-templates;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-rpm-templates}"
SRC_URI[aarch64_go-rpm-templates.sha256sum] = "9d58e1eca1c4d6d89d716e5e1a469b6980e827d752ca8d0986f026a20038f317"

URI_aarch64_go-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-srpm-macros-3.6.0-8.el10_1.noarch.rpm;name=aarch64_go-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-srpm-macros}"
SRC_URI[aarch64_go-srpm-macros.sha256sum] = "aece88f82fcf24e15aec8de9ca3718e766d872195d82443ac3469dd306a04756"

RDEPENDS:go-filesystem = " \
 "
RDEPENDS:go-rpm-macros = " \
 bash \
 glibc \
 go-filesystem \
 go-srpm-macros \
 golang \
 python3 \
 "
RDEPENDS:go-rpm-templates = " \
 go-rpm-macros \
 "
RDEPENDS:go-srpm-macros = " \
 redhat-rpm-config \
 "
