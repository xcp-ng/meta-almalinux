# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-packetline"
PV = "0.20.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-packetline+async-io-devel \
 rust-gix-packetline+blocking-io-devel \
 rust-gix-packetline+default-devel \
 rust-gix-packetline+document-features-devel \
 rust-gix-packetline+futures-lite-devel \
 rust-gix-packetline+serde-devel \
 rust-gix-packetline-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-packetline-0.20.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11a41e17224f90b1f27f0112825e7e87c7697ed9eed07ae1219fe45bb5a26f93"

URI_x86_64_v2_rust-gix-packetline+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+async-io-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+async-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+async-io-devel.sha256sum] = "6f0fe7411e074aab8f110393a859b5541294be982b82c2171447ae3d5865b5a7"

URI_x86_64_v2_rust-gix-packetline+blocking-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+blocking-io-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+blocking-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+blocking-io-devel.sha256sum] = "c4aae593acc2aa80523501cc1969a369c7e3098d49c7c6359b1280bfdc27ccec"

URI_x86_64_v2_rust-gix-packetline+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+default-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+default-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+default-devel.sha256sum] = "94704554481df358427ddd636c20535a1d3b91632c897f110f8cdb70555b97aa"

URI_x86_64_v2_rust-gix-packetline+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+document-features-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+document-features-devel.sha256sum] = "79140ef15f91f266286827f6530fcac46268d0cbdd821a3e2ad75f1fe326b281"

URI_x86_64_v2_rust-gix-packetline+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+futures-lite-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+futures-lite-devel.sha256sum] = "681d5d8bafcb700a620b98546d9b61e5f63f07f40c8f346e8efdf3d60ce11994"

URI_x86_64_v2_rust-gix-packetline+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+serde-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+serde-devel.sha256sum] = "0965d65e360040e3bfc18d57a998ae748d64cfdf05ecf42985978f26e0141406"

URI_x86_64_v2_rust-gix-packetline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-devel.sha256sum] = "74c0478ae91c1ffe29818d091e7bca0d5a4e66fe2d93108c414111de04771d77"

URI_aarch64_rust-gix-packetline+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+async-io-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-packetline+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+async-io-devel}"
SRC_URI[aarch64_rust-gix-packetline+async-io-devel.sha256sum] = "1be8e1efa12f2151b1eddd7571bdc386c48b3473744db379b57aa38c2ee2d22d"

URI_aarch64_rust-gix-packetline+blocking-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+blocking-io-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-packetline+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+blocking-io-devel}"
SRC_URI[aarch64_rust-gix-packetline+blocking-io-devel.sha256sum] = "16c6a9dfc0d7503bb5e7f5c37fa0db1bb2c9ecb45719939c46dfc24840a87d33"

URI_aarch64_rust-gix-packetline+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+default-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-packetline+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+default-devel}"
SRC_URI[aarch64_rust-gix-packetline+default-devel.sha256sum] = "3217eb57159df08207c2820bbb77dd0ccdb925bf3dd914f468c957b4f6abff89"

URI_aarch64_rust-gix-packetline+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+document-features-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-packetline+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+document-features-devel}"
SRC_URI[aarch64_rust-gix-packetline+document-features-devel.sha256sum] = "5400741057151eb67fc1c961706f6f804c662f506020225f94b8855d2d06e483"

URI_aarch64_rust-gix-packetline+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+futures-lite-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-packetline+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+futures-lite-devel}"
SRC_URI[aarch64_rust-gix-packetline+futures-lite-devel.sha256sum] = "c8b6a722bffc4c35aa2d497d919dbbcb249ee9f40fd75c396d9ced80aac30be1"

URI_aarch64_rust-gix-packetline+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+serde-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-packetline+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+serde-devel}"
SRC_URI[aarch64_rust-gix-packetline+serde-devel.sha256sum] = "d93827cf9a898bc4c1d0c8e9ef50f023af1ce1b16d37c0222c3289a6239674a8"

URI_aarch64_rust-gix-packetline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-packetline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-devel}"
SRC_URI[aarch64_rust-gix-packetline-devel.sha256sum] = "6ea59c5d54bb5f0498e62cca7a211d48fca2bea7bb3166a286a891a68187ba68"

RDEPENDS:rust-gix-packetline+async-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-gix-packetline+futures-lite-devel \
 rust-gix-packetline-devel \
 rust-pin-project-lite+default-devel \
 "
RDEPENDS:rust-gix-packetline+blocking-io-devel = " \
 cargo \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+default-devel = " \
 cargo \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+futures-lite-devel = " \
 cargo \
 rust-futures-lite+default-devel \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-faster-hex+serde-devel \
 rust-gix-packetline-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-packetline-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-faster-hex+std-devel \
 rust-faster-hex-devel \
 rust-gix-trace+default-devel \
 rust-thiserror+default-devel \
 "
