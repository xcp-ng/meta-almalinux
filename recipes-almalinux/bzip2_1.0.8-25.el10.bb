# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bzip2"
PV = "1.0.8"
PR = "25.el10"
PACKAGES = " \
 bzip2 \
 bzip2-devel \
 bzip2-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/bzip2-1.0.8-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1e562378f9f7202184fb62c19174a0eee83777391f6d78166ed20a759682972"

URI_x86_64_v2_bzip2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bzip2-1.0.8-25.el10.x86_64_v2.rpm;name=x86_64_v2_bzip2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip2}"
SRC_URI[x86_64_v2_bzip2.sha256sum] = "85da6062c8bff69fe8eaae120ba2fa6831eaf4f5ba214158b4ab510db18adf3f"

URI_x86_64_v2_bzip2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bzip2-devel-1.0.8-25.el10.x86_64_v2.rpm;name=x86_64_v2_bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip2-devel}"
SRC_URI[x86_64_v2_bzip2-devel.sha256sum] = "e77661d2c70cdd1c11158ec995aa2ae390ffd728fab4ec3e1141f72a2ca11fde"

URI_x86_64_v2_bzip2-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bzip2-libs-1.0.8-25.el10.x86_64_v2.rpm;name=x86_64_v2_bzip2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip2-libs}"
SRC_URI[x86_64_v2_bzip2-libs.sha256sum] = "aa03374c786a4929fee2f59dd53d08078acd3309f69d92887f4c7b83fe731f6c"

URI_aarch64_bzip2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bzip2-1.0.8-25.el10.aarch64.rpm;name=aarch64_bzip2;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip2}"
SRC_URI[aarch64_bzip2.sha256sum] = "92ae5c99fa1c0593eabae0f1462e439b5746a87deaf9349468cb434ad218caab"

URI_aarch64_bzip2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bzip2-devel-1.0.8-25.el10.aarch64.rpm;name=aarch64_bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip2-devel}"
SRC_URI[aarch64_bzip2-devel.sha256sum] = "4910b3d68c15910e82b93315b46149b1ba19c60831a704d6f5a853e8f584793b"

URI_aarch64_bzip2-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bzip2-libs-1.0.8-25.el10.aarch64.rpm;name=aarch64_bzip2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip2-libs}"
SRC_URI[aarch64_bzip2-libs.sha256sum] = "ccb52190fce4dd0321bd622551c83f5b94c97ce1dedbfa5f87a7effd554c8f6a"

RDEPENDS:bzip2 = " \
 bash \
 bzip2-libs \
 glibc \
 "
RDEPENDS:bzip2-devel = " \
 bzip2-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:bzip2-libs = " \
 glibc \
 "
