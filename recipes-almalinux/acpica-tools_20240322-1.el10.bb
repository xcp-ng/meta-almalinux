# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "acpica-tools"
PV = "20240322"
PR = "1.el10"
PACKAGES = " \
 acpica-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/acpica-tools-20240322-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e95c1bf7cd1b02ceeac8103eccdbaf706846674e89104d4da3920d1677b6401e"

URI_x86_64_v2_acpica-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/acpica-tools-20240322-1.el10.x86_64_v2.rpm;name=x86_64_v2_acpica-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_acpica-tools}"
SRC_URI[x86_64_v2_acpica-tools.sha256sum] = "7f5bcf3a8fe0f0246b5a618f31f054c24297a5397d04722a27d35d224d7422ab"

URI_aarch64_acpica-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/acpica-tools-20240322-1.el10.aarch64.rpm;name=aarch64_acpica-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_acpica-tools}"
SRC_URI[aarch64_acpica-tools.sha256sum] = "87de53ad38c7c9503c27510b381b14680a4c8a87634d048148f6a7997421c885"

RDEPENDS:acpica-tools = " \
 bash \
 glibc \
 "
