# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_collections"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_collections+alloc-devel \
 rust-icu_collections+databake-devel \
 rust-icu_collections+default-devel \
 rust-icu_collections+serde-devel \
 rust-icu_collections-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_collections-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f3ba2fd6641c746ba48e5b5fe09d621c3d277397865f8f87873e843034d04c7"

URI_x86_64_v2_rust-icu_collections+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+alloc-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+alloc-devel.sha256sum] = "becb153ea84b331ad7c4b138b9c8bedc743179ee48389862b2ff885a563a5984"

URI_x86_64_v2_rust-icu_collections+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+databake-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+databake-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+databake-devel.sha256sum] = "a1d2527593239f30e46e0375908a226d612005d96e8bc6efda73379f89794786"

URI_x86_64_v2_rust-icu_collections+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+default-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+default-devel.sha256sum] = "da00851f3fce54a57bae3b562426e9c3687004db1aa19a3dacfe072b4080c74a"

URI_x86_64_v2_rust-icu_collections+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+serde-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+serde-devel.sha256sum] = "b93cf8b2a7f281514c8cc26dcb734982bf0d8f6f67604121b1987eeeb159594d"

URI_x86_64_v2_rust-icu_collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections-devel}"
SRC_URI[x86_64_v2_rust-icu_collections-devel.sha256sum] = "5b5de2d0553bd94956e62f991a70e0455753f8d2a118a6e72c43eeb6eb46b002"

URI_aarch64_rust-icu_collections+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+alloc-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_collections+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+alloc-devel}"
SRC_URI[aarch64_rust-icu_collections+alloc-devel.sha256sum] = "e7c04bba2aa00791ca4451b26e1f39c8554ed53c717f2310f27c851fe954f509"

URI_aarch64_rust-icu_collections+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+databake-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_collections+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+databake-devel}"
SRC_URI[aarch64_rust-icu_collections+databake-devel.sha256sum] = "a6efd1a6eb7a387ea65796588dd3cb4e698524bd3394abfec87fbb366ca397ea"

URI_aarch64_rust-icu_collections+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+default-devel}"
SRC_URI[aarch64_rust-icu_collections+default-devel.sha256sum] = "0bc096e2d7009a7348f6f22ab93f57579e772823b80d4ba06734603a35dbceef"

URI_aarch64_rust-icu_collections+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+serde-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_collections+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+serde-devel}"
SRC_URI[aarch64_rust-icu_collections+serde-devel.sha256sum] = "1b45d2fff69249abbd80d1b02343eed24f1ec5e8e9e7dcfa65b3b42eb2b015e8"

URI_aarch64_rust-icu_collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections-devel}"
SRC_URI[aarch64_rust-icu_collections-devel.sha256sum] = "58f607373d889d58e8699eddff7a3ada5c4daa276c7911dafa9c52efed0f9f2a"

RDEPENDS:rust-icu_collections+alloc-devel = " \
 cargo \
 rust-icu_collections-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+alloc-devel \
 "
RDEPENDS:rust-icu_collections+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_collections+default-devel = " \
 cargo \
 rust-icu_collections-devel \
 "
RDEPENDS:rust-icu_collections+serde-devel = " \
 cargo \
 rust-icu_collections+alloc-devel \
 rust-icu_collections-devel \
 rust-potential_utf+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_collections-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-potential_utf+zerovec-devel \
 rust-potential_utf-devel \
 rust-utf8_iter-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 rust-zerovec+derive-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
