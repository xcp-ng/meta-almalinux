# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_metadata0.15"
PV = "0.15.4"
PR = "5.el10_1"
PACKAGES = " \
 rust-cargo_metadata0.15+builder-devel \
 rust-cargo_metadata0.15+default-devel \
 rust-cargo_metadata0.15+derive_builder-devel \
 rust-cargo_metadata0.15-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_metadata0.15-0.15.4-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d55a0fc4fb33dffc022eba53f3230aa6d82eb10a6e89d1639fd0f307999cef9"

URI_x86_64_v2_rust-cargo_metadata0.15+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.15+builder-devel-0.15.4-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.15+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.15+builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.15+builder-devel.sha256sum] = "44cdade7c10665c8e4bf6fc2d497de8f47b4bacd567aa408c85c8a7685363cc6"

URI_x86_64_v2_rust-cargo_metadata0.15+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.15+default-devel-0.15.4-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.15+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.15+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.15+default-devel.sha256sum] = "c6f563c3686cb53ae8f25fa0f50f8852e6803ea507e0925a0d1a3dbd9581cff9"

URI_x86_64_v2_rust-cargo_metadata0.15+derive_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.15+derive_builder-devel-0.15.4-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.15+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.15+derive_builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.15+derive_builder-devel.sha256sum] = "8c587d4302957823e498364dccbb5d58c44818cb69b4f6adfbd83d48e742728a"

URI_x86_64_v2_rust-cargo_metadata0.15-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.15-devel-0.15.4-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.15-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.15-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.15-devel.sha256sum] = "f8a8365b32c2bbcc3b1516916cfcbc18172f7eebaf08286bbb63a4806909152c"

URI_aarch64_rust-cargo_metadata0.15+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.15+builder-devel-0.15.4-5.el10_1.noarch.rpm;name=aarch64_rust-cargo_metadata0.15+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.15+builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.15+builder-devel.sha256sum] = "2ff287f4ba49b1eddd32382e25a076cc0b2ab651fcd93c4114b172470f372f8e"

URI_aarch64_rust-cargo_metadata0.15+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.15+default-devel-0.15.4-5.el10_1.noarch.rpm;name=aarch64_rust-cargo_metadata0.15+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.15+default-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.15+default-devel.sha256sum] = "66ea560d5015bafba9156b732248d80657a1bfd08c2a3bca2c3307c154722aec"

URI_aarch64_rust-cargo_metadata0.15+derive_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.15+derive_builder-devel-0.15.4-5.el10_1.noarch.rpm;name=aarch64_rust-cargo_metadata0.15+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.15+derive_builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.15+derive_builder-devel.sha256sum] = "21f7e3aacb451cb07421d751d109854adfb3bb46d7f55375a35bf547da0b5d3b"

URI_aarch64_rust-cargo_metadata0.15-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.15-devel-0.15.4-5.el10_1.noarch.rpm;name=aarch64_rust-cargo_metadata0.15-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.15-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.15-devel.sha256sum] = "168db6c0f627080ef6b7ecd2f1f5858acffcb275b3147576a2844e13c2533499"

RDEPENDS:rust-cargo_metadata0.15+builder-devel = " \
 cargo \
 rust-cargo_metadata0.15+derive_builder-devel \
 rust-cargo_metadata0.15-devel \
 "
RDEPENDS:rust-cargo_metadata0.15+default-devel = " \
 cargo \
 rust-cargo_metadata0.15-devel \
 "
RDEPENDS:rust-cargo_metadata0.15+derive_builder-devel = " \
 cargo \
 rust-cargo_metadata0.15-devel \
 rust-derive_builder+default-devel \
 "
RDEPENDS:rust-cargo_metadata0.15-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-camino+serde1-devel \
 rust-cargo-platform0.1+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-thiserror1+default-devel \
 "
