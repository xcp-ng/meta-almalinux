# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ambient-id"
PV = "0.0.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-ambient-id+astral-reqwest-middleware-devel \
 rust-ambient-id+default-devel \
 rust-ambient-id+native-tls-devel \
 rust-ambient-id+reqwest-middleware-devel \
 rust-ambient-id+rustls-devel \
 rust-ambient-id-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ambient-id-0.0.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab9bb69f3a9cccafd7683b6f65a2652a8fb9370b4fb18395ada3c82c8e062288"

URI_x86_64_v2_rust-ambient-id+astral-reqwest-middleware-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-id+astral-reqwest-middleware-devel-0.0.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-id+astral-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ambient-id+astral-reqwest-middleware-devel}"
SRC_URI[x86_64_v2_rust-ambient-id+astral-reqwest-middleware-devel.sha256sum] = "01756e2d12de2b933881e30db2b0cf57274e129ccd434273b4b398aa892c84a7"

URI_x86_64_v2_rust-ambient-id+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-id+default-devel-0.0.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-id+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ambient-id+default-devel}"
SRC_URI[x86_64_v2_rust-ambient-id+default-devel.sha256sum] = "e622638a7c587e71a97751d6779647dda2efa9e58556dbac040dd10de877056d"

URI_x86_64_v2_rust-ambient-id+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-id+native-tls-devel-0.0.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-id+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ambient-id+native-tls-devel}"
SRC_URI[x86_64_v2_rust-ambient-id+native-tls-devel.sha256sum] = "86347b47e27ff6c427499a866cfc5821e3f5a00fb541932065f92d7f0e82e495"

URI_x86_64_v2_rust-ambient-id+reqwest-middleware-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-id+reqwest-middleware-devel-0.0.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-id+reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ambient-id+reqwest-middleware-devel}"
SRC_URI[x86_64_v2_rust-ambient-id+reqwest-middleware-devel.sha256sum] = "7272dd43b245d598cced3dad351f78f149eeb0c6d482566b52b6a288761959fe"

URI_x86_64_v2_rust-ambient-id+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-id+rustls-devel-0.0.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-id+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ambient-id+rustls-devel}"
SRC_URI[x86_64_v2_rust-ambient-id+rustls-devel.sha256sum] = "3fd67cdc4f140c41a0b7eae983fe360b4ad7eb1e8034a6eabfbd3b0a6a2ad448"

URI_x86_64_v2_rust-ambient-id-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-id-devel-0.0.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-id-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ambient-id-devel}"
SRC_URI[x86_64_v2_rust-ambient-id-devel.sha256sum] = "fa9181099488c689770bb672035536da3df51d45ae1dbde7d7285ff92aeeaa85"

URI_aarch64_rust-ambient-id+astral-reqwest-middleware-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-id+astral-reqwest-middleware-devel-0.0.10-1.el10_2.noarch.rpm;name=aarch64_rust-ambient-id+astral-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ambient-id+astral-reqwest-middleware-devel}"
SRC_URI[aarch64_rust-ambient-id+astral-reqwest-middleware-devel.sha256sum] = "dfee8131722243562bf2a837738e27e2a7226d085569fc8c0811f1c71401f192"

URI_aarch64_rust-ambient-id+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-id+default-devel-0.0.10-1.el10_2.noarch.rpm;name=aarch64_rust-ambient-id+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ambient-id+default-devel}"
SRC_URI[aarch64_rust-ambient-id+default-devel.sha256sum] = "ba4a9b8b12ef025f67c8bd462402a53b0332b815716b10bae85b188c1793c085"

URI_aarch64_rust-ambient-id+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-id+native-tls-devel-0.0.10-1.el10_2.noarch.rpm;name=aarch64_rust-ambient-id+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ambient-id+native-tls-devel}"
SRC_URI[aarch64_rust-ambient-id+native-tls-devel.sha256sum] = "610ba2e70cf380af55a2f4e9636436406ed495beb5e89162e6dea7e96cbd7e5f"

URI_aarch64_rust-ambient-id+reqwest-middleware-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-id+reqwest-middleware-devel-0.0.10-1.el10_2.noarch.rpm;name=aarch64_rust-ambient-id+reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ambient-id+reqwest-middleware-devel}"
SRC_URI[aarch64_rust-ambient-id+reqwest-middleware-devel.sha256sum] = "11ec6b3a69fb3f2b1c40079658c5aac5cbcbdf92371b9321f836c8fd3b8bca53"

URI_aarch64_rust-ambient-id+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-id+rustls-devel-0.0.10-1.el10_2.noarch.rpm;name=aarch64_rust-ambient-id+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ambient-id+rustls-devel}"
SRC_URI[aarch64_rust-ambient-id+rustls-devel.sha256sum] = "6cfa649e80eb34f53782fc1f77616aa1861901c3b5a1a946f840a6dd32531879"

URI_aarch64_rust-ambient-id-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-id-devel-0.0.10-1.el10_2.noarch.rpm;name=aarch64_rust-ambient-id-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ambient-id-devel}"
SRC_URI[aarch64_rust-ambient-id-devel.sha256sum] = "e89644e2fdd9e6465e257f6976f4f7e88eaab00d276621e09dc3cbf87b6bc5ec"

RDEPENDS:rust-ambient-id+astral-reqwest-middleware-devel = " \
 cargo \
 rust-ambient-id-devel \
 rust-astral-reqwest-middleware+default-devel \
 "
RDEPENDS:rust-ambient-id+default-devel = " \
 cargo \
 rust-ambient-id+reqwest-middleware-devel \
 rust-ambient-id+rustls-devel \
 rust-ambient-id-devel \
 "
RDEPENDS:rust-ambient-id+native-tls-devel = " \
 cargo \
 rust-ambient-id-devel \
 rust-reqwest0.12+native-tls-devel \
 "
RDEPENDS:rust-ambient-id+reqwest-middleware-devel = " \
 cargo \
 rust-ambient-id-devel \
 rust-reqwest-middleware0.4+default-devel \
 "
RDEPENDS:rust-ambient-id+rustls-devel = " \
 cargo \
 rust-ambient-id-devel \
 rust-reqwest0.12+rustls-tls-devel \
 rust-reqwest0.12+rustls-tls-native-roots-devel \
 "
RDEPENDS:rust-ambient-id-devel = " \
 cargo \
 rust-reqwest0.12+deflate-devel \
 rust-reqwest0.12+gzip-devel \
 rust-reqwest0.12+http2-devel \
 rust-reqwest0.12+json-devel \
 rust-reqwest0.12-devel \
 rust-secrecy+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 "
