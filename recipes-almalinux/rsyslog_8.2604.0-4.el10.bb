# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rsyslog"
PV = "8.2604.0"
PR = "4.el10"
PACKAGES = " \
 rsyslog \
 rsyslog-crypto \
 rsyslog-doc \
 rsyslog-elasticsearch \
 rsyslog-gnutls \
 rsyslog-gssapi \
 rsyslog-kafka \
 rsyslog-mmaudit \
 rsyslog-mmfields \
 rsyslog-mmjsonparse \
 rsyslog-mmkubernetes \
 rsyslog-mmnormalize \
 rsyslog-mmsnmptrapd \
 rsyslog-mysql \
 rsyslog-omamqp1 \
 rsyslog-openssl \
 rsyslog-pgsql \
 rsyslog-relp \
 rsyslog-snmp \
 rsyslog-udpspoof \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rsyslog-8.2604.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "982119730f57e71e39785ac481ad169971634471de2b3c2bac345890404cb81a"

URI_x86_64_v2_rsyslog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog}"
SRC_URI[x86_64_v2_rsyslog.sha256sum] = "ec826361014bf2a37d14563a4655a87a90701e3076f412c2b3854eeeae68b0b5"
RPROVIDES:rsyslog:x86_64_v2 = "virtual/syslog"

URI_x86_64_v2_rsyslog-crypto = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-crypto-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-crypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-crypto}"
SRC_URI[x86_64_v2_rsyslog-crypto.sha256sum] = "33fc73048110d61283912176eef8eb8cbd7f37822892a8c0050bef9c37b0fb5b"

URI_x86_64_v2_rsyslog-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-doc-8.2604.0-4.el10.noarch.rpm;name=x86_64_v2_rsyslog-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-doc}"
SRC_URI[x86_64_v2_rsyslog-doc.sha256sum] = "910ef3ef3fb7b7b8d36e46ab124980817dae579d96ec9fb5c940c64d0f4c54be"

URI_x86_64_v2_rsyslog-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-elasticsearch-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-elasticsearch}"
SRC_URI[x86_64_v2_rsyslog-elasticsearch.sha256sum] = "7a7af034205b64233b00380efce118ce94522c93a6211a1f8f4d78ba1ee549db"

URI_x86_64_v2_rsyslog-gnutls = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-gnutls-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-gnutls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-gnutls}"
SRC_URI[x86_64_v2_rsyslog-gnutls.sha256sum] = "c293b4efd117ceb71c17dfbd80bff20b13c1f7e17409776530b4451ba9ea1ee6"

URI_x86_64_v2_rsyslog-gssapi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-gssapi-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-gssapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-gssapi}"
SRC_URI[x86_64_v2_rsyslog-gssapi.sha256sum] = "a93415a8287d173f17b8b68849cfba4e96b88675040e8c3c4144cad9b440049f"

URI_x86_64_v2_rsyslog-kafka = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-kafka-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-kafka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-kafka}"
SRC_URI[x86_64_v2_rsyslog-kafka.sha256sum] = "180de36a2bbd7b4e6f1577a65f461e1de75076313b49940dcd5a6f5b13071fba"

URI_x86_64_v2_rsyslog-mmaudit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmaudit-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmaudit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmaudit}"
SRC_URI[x86_64_v2_rsyslog-mmaudit.sha256sum] = "e529da5bf819865cc836b1073ea06a31ed7bba7473706ab3711c2b49b6805f7a"

URI_x86_64_v2_rsyslog-mmfields = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmfields-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmfields;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmfields}"
SRC_URI[x86_64_v2_rsyslog-mmfields.sha256sum] = "91d696d4984af02312194947fda7a2c22b79497b1aa93a8945ad25e565fdff69"

URI_x86_64_v2_rsyslog-mmjsonparse = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmjsonparse-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmjsonparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmjsonparse}"
SRC_URI[x86_64_v2_rsyslog-mmjsonparse.sha256sum] = "8360bd3ab8c9dfba02b19d0715d32edf63327a06badf811ed386577338ee56d4"

URI_x86_64_v2_rsyslog-mmkubernetes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmkubernetes-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmkubernetes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmkubernetes}"
SRC_URI[x86_64_v2_rsyslog-mmkubernetes.sha256sum] = "6a644994fdace3224e8dd0b86f463fcbec23312e3ab0ea7af8d25d0715a10b9c"

URI_x86_64_v2_rsyslog-mmnormalize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmnormalize-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmnormalize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmnormalize}"
SRC_URI[x86_64_v2_rsyslog-mmnormalize.sha256sum] = "918962c305f377c12f6350b15b696f483e09dd79d924e1f90a8c8ac7000ff459"

URI_x86_64_v2_rsyslog-mmsnmptrapd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmsnmptrapd-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmsnmptrapd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmsnmptrapd}"
SRC_URI[x86_64_v2_rsyslog-mmsnmptrapd.sha256sum] = "7c4d13c4fc32da5eaa26ffa1d22327720838bcca49e8db53735311f2b5bd866f"

URI_x86_64_v2_rsyslog-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mysql-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mysql}"
SRC_URI[x86_64_v2_rsyslog-mysql.sha256sum] = "2c51f6a4321d25fe5608d1d546825446c23f3e927ccee5730a5149323a1c5c85"

URI_x86_64_v2_rsyslog-omamqp1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-omamqp1-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-omamqp1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-omamqp1}"
SRC_URI[x86_64_v2_rsyslog-omamqp1.sha256sum] = "c15ac59f536d43ff274bde05e6b34a80c2d0aa6bae1b4933ef9cd10186a6b75d"

URI_x86_64_v2_rsyslog-openssl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-openssl-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-openssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-openssl}"
SRC_URI[x86_64_v2_rsyslog-openssl.sha256sum] = "512c9ff3ee68876c5ab717c0d87316f0cfb2ea2ae1bc8719f3769a76f6f2e99b"

URI_x86_64_v2_rsyslog-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-pgsql-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-pgsql}"
SRC_URI[x86_64_v2_rsyslog-pgsql.sha256sum] = "a7c5f83698f2fbdecbafa08ebd578c7443f843673d88c9e60f67bd55e8c7953d"

URI_x86_64_v2_rsyslog-relp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-relp-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-relp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-relp}"
SRC_URI[x86_64_v2_rsyslog-relp.sha256sum] = "fc9917edb9de6c9ce9df8028d282cca738176874ecbeebe566e4a83fa4ecded8"

URI_x86_64_v2_rsyslog-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-snmp-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-snmp}"
SRC_URI[x86_64_v2_rsyslog-snmp.sha256sum] = "caecda245666f869cbe75d6faf0021d63820f50c85867db05380832ea50b3707"

URI_x86_64_v2_rsyslog-udpspoof = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-udpspoof-8.2604.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-udpspoof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-udpspoof}"
SRC_URI[x86_64_v2_rsyslog-udpspoof.sha256sum] = "d89d09b83732494c3cdcc9773a9bd2229f1481737c5a7e6ff81c12c786bae048"

URI_aarch64_rsyslog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog}"
SRC_URI[aarch64_rsyslog.sha256sum] = "a79a750bbd92180b08270a71c58a746f57c42c9c03d786e15f50937f0cf36792"
RPROVIDES:rsyslog:aarch64 = "virtual/syslog"

URI_aarch64_rsyslog-crypto = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-crypto-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-crypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-crypto}"
SRC_URI[aarch64_rsyslog-crypto.sha256sum] = "6d0b0d16c199845943478f9c12c6cae145ab26209ebae03772a72183b40f15c3"

URI_aarch64_rsyslog-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-doc-8.2604.0-4.el10.noarch.rpm;name=aarch64_rsyslog-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-doc}"
SRC_URI[aarch64_rsyslog-doc.sha256sum] = "910ef3ef3fb7b7b8d36e46ab124980817dae579d96ec9fb5c940c64d0f4c54be"

URI_aarch64_rsyslog-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-elasticsearch-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-elasticsearch}"
SRC_URI[aarch64_rsyslog-elasticsearch.sha256sum] = "fd7a0f3ee045deb2c88c9c2243412af4d7c6a093878e894542805f09652b6949"

URI_aarch64_rsyslog-gnutls = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-gnutls-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-gnutls;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-gnutls}"
SRC_URI[aarch64_rsyslog-gnutls.sha256sum] = "0d9d751a7d721aa23a4bb535910a07db74957141e2d36b52a666146cba3cbd13"

URI_aarch64_rsyslog-gssapi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-gssapi-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-gssapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-gssapi}"
SRC_URI[aarch64_rsyslog-gssapi.sha256sum] = "22f8de85745d7f2c1bd478d33ecb1c015b8c020a12f7fbd7bd54dd5fd88fe2a9"

URI_aarch64_rsyslog-kafka = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-kafka-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-kafka;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-kafka}"
SRC_URI[aarch64_rsyslog-kafka.sha256sum] = "703354cf2d01059598b351060a196fd7ce53733dfba70f4df481c7466b495c92"

URI_aarch64_rsyslog-mmaudit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmaudit-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-mmaudit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmaudit}"
SRC_URI[aarch64_rsyslog-mmaudit.sha256sum] = "0c9a99a10434b75687c50261d210312ef3eaaf4c29a1aac7ce0c09e371eb438d"

URI_aarch64_rsyslog-mmfields = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmfields-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-mmfields;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmfields}"
SRC_URI[aarch64_rsyslog-mmfields.sha256sum] = "93cf7c8f05fab3c1e21db156de2c35dfc9c10a365194a1e11d73b17d5d621763"

URI_aarch64_rsyslog-mmjsonparse = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmjsonparse-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-mmjsonparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmjsonparse}"
SRC_URI[aarch64_rsyslog-mmjsonparse.sha256sum] = "153991c52e2724e9c5a8caea2019660379040f6d95d3bfc1d658263b848a84f0"

URI_aarch64_rsyslog-mmkubernetes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmkubernetes-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-mmkubernetes;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmkubernetes}"
SRC_URI[aarch64_rsyslog-mmkubernetes.sha256sum] = "e49f5b4790e83c95ac18a769bef3e0bb1e29abc24e68f8e7a4ab3342b397d370"

URI_aarch64_rsyslog-mmnormalize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmnormalize-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-mmnormalize;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmnormalize}"
SRC_URI[aarch64_rsyslog-mmnormalize.sha256sum] = "20c28309ee66baa0e76e723347915b1a7ad9b7b986794fa5010f376f3d1c31ce"

URI_aarch64_rsyslog-mmsnmptrapd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmsnmptrapd-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-mmsnmptrapd;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmsnmptrapd}"
SRC_URI[aarch64_rsyslog-mmsnmptrapd.sha256sum] = "dff479767054c3c74f18847283ba19b8acf00640b9ba178bbb6857211741cd26"

URI_aarch64_rsyslog-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mysql-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mysql}"
SRC_URI[aarch64_rsyslog-mysql.sha256sum] = "38652565b861209b3b1419b265d0b359591188fbd9617093b6bb57eee20ea8e4"

URI_aarch64_rsyslog-omamqp1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-omamqp1-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-omamqp1;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-omamqp1}"
SRC_URI[aarch64_rsyslog-omamqp1.sha256sum] = "8e3499e394c1ac6e08db587b82c6a1caa521e80d035d521795d980cf35beb021"

URI_aarch64_rsyslog-openssl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-openssl-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-openssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-openssl}"
SRC_URI[aarch64_rsyslog-openssl.sha256sum] = "cdec0a39e71f2044844881286979ac1232da6a30b7e17c734e92f7d526912804"

URI_aarch64_rsyslog-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-pgsql-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-pgsql}"
SRC_URI[aarch64_rsyslog-pgsql.sha256sum] = "198f37f7150f9946bfbaccbd796021ddd9d9ed15dc81899c914784bc3385400e"

URI_aarch64_rsyslog-relp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-relp-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-relp;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-relp}"
SRC_URI[aarch64_rsyslog-relp.sha256sum] = "f1cca720da7248656be177b4dcafbf54ef3453cc8fc37f005d2f4f40d68d1709"

URI_aarch64_rsyslog-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-snmp-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-snmp}"
SRC_URI[aarch64_rsyslog-snmp.sha256sum] = "9b4fac4580ba3f50720c04dc68651574faf84ccda3ee20c0d38d625434b2529c"

URI_aarch64_rsyslog-udpspoof = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-udpspoof-8.2604.0-4.el10.aarch64.rpm;name=aarch64_rsyslog-udpspoof;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-udpspoof}"
SRC_URI[aarch64_rsyslog-udpspoof.sha256sum] = "1759057deb827ab7c99f4004c6ac6b7698215da1bcfa22f30cea8284bc804bdc"

RDEPENDS:rsyslog = " \
 bash \
 glibc \
 libcap-ng \
 libestr \
 libfastjson \
 libgcc \
 libuuid \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:rsyslog-crypto = " \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-doc = " \
 "
RDEPENDS:rsyslog-elasticsearch = " \
 glibc \
 libcap-ng \
 rsyslog \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:rsyslog-gnutls = " \
 glibc \
 gnutls \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-gssapi = " \
 glibc \
 krb5-libs \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-kafka = " \
 glibc \
 libcap-ng \
 librdkafka \
 rsyslog \
 "
RDEPENDS:rsyslog-mmaudit = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mmfields = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mmjsonparse = " \
 glibc \
 libcap-ng \
 libfastjson \
 rsyslog \
 "
RDEPENDS:rsyslog-mmkubernetes = " \
 glibc \
 libcap-ng \
 libfastjson \
 liblognorm \
 rsyslog \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:rsyslog-mmnormalize = " \
 glibc \
 libcap-ng \
 libfastjson \
 liblognorm \
 rsyslog \
 "
RDEPENDS:rsyslog-mmsnmptrapd = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mysql = " \
 glibc \
 mariadb-connector-c \
 rsyslog \
 "
RDEPENDS:rsyslog-omamqp1 = " \
 cyrus-sasl-lib \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-openssl = " \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-pgsql = " \
 glibc \
 libcap-ng \
 libpq \
 rsyslog \
 "
RDEPENDS:rsyslog-relp = " \
 glibc \
 libcap-ng \
 librelp \
 rsyslog \
 "
RDEPENDS:rsyslog-snmp = " \
 glibc \
 libcap-ng \
 net-snmp-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-udpspoof = " \
 glibc \
 libcap-ng \
 libnet \
 rsyslog \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/syslog"

PROVIDES:append:aarch64 = " rpm/virtual/syslog"
