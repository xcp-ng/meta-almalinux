# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-swiftclient"
PV = "4.10.0"
PR = "1.el10_2"
PACKAGES = " \
 python-swiftclient-doc \
 python3-swiftclient \
 python3-swiftclient+keystone \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-swiftclient-4.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8cbe5a7d6032335fd2633db1f01f68f16580e8880274a8b900ee40362dccc6e"

URI_x86_64_v2_python-swiftclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-swiftclient-doc-4.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-swiftclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-swiftclient-doc}"
SRC_URI[x86_64_v2_python-swiftclient-doc.sha256sum] = "1eba2671a574cd7f8eceb853067eea3d69194af94dc1eb4d8e6ad7ce7b01bee3"

URI_x86_64_v2_python3-swiftclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-swiftclient-4.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-swiftclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-swiftclient}"
SRC_URI[x86_64_v2_python3-swiftclient.sha256sum] = "4d3f6a2cc3de9cba281e7778456245dc76f8dc64c53069cc790c2de0a5fd0109"

URI_x86_64_v2_python3-swiftclient+keystone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-swiftclient+keystone-4.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-swiftclient+keystone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-swiftclient+keystone}"
SRC_URI[x86_64_v2_python3-swiftclient+keystone.sha256sum] = "334476a56d48e6fc3701f3c334395af296a8c85c11a3df33a4e28a40195037ed"

URI_aarch64_python-swiftclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-swiftclient-doc-4.10.0-1.el10_2.noarch.rpm;name=aarch64_python-swiftclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-swiftclient-doc}"
SRC_URI[aarch64_python-swiftclient-doc.sha256sum] = "e90eac5ff74562b68b0548ba97acea014be1abb3c58cac83477be277245888bf"

URI_aarch64_python3-swiftclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-swiftclient-4.10.0-1.el10_2.noarch.rpm;name=aarch64_python3-swiftclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-swiftclient}"
SRC_URI[aarch64_python3-swiftclient.sha256sum] = "181b0392088ec8dd342ad5dad0b5fd4c1f62ccef6ad84e376c3b42c1030c6cac"

URI_aarch64_python3-swiftclient+keystone = "${EPEL_MIRROR}/aarch64/Packages/p/python3-swiftclient+keystone-4.10.0-1.el10_2.noarch.rpm;name=aarch64_python3-swiftclient+keystone;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-swiftclient+keystone}"
SRC_URI[aarch64_python3-swiftclient+keystone.sha256sum] = "09625777b0a964854084b52e569c5c74751948d1c96fa4fa9f81bae7773c593b"

RDEPENDS:python-swiftclient-doc = " \
 "
RDEPENDS:python3-swiftclient = " \
 python3 \
 python3-requests \
 python3-swiftclient+keystone \
 "
RDEPENDS:python3-swiftclient+keystone = " \
 python3 \
 python3-keystoneclient \
 python3-swiftclient \
 "
