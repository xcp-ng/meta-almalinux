# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-path"
PV = "0.12.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-path+default-devel \
 rust-gix-path-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-path-0.12.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e35ed357727896e4e81ffcbb5d8919b5eb75134ceaee7a4cfc2d3624a3c2bb1"

URI_x86_64_v2_rust-gix-path+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-path+default-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-path+default-devel}"
SRC_URI[x86_64_v2_rust-gix-path+default-devel.sha256sum] = "1bb490b3f7bb2a0dc1378b8cb0e3af4ea0b81e889e649ff68992b8de3b2fd6d8"

URI_x86_64_v2_rust-gix-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-path-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-path-devel}"
SRC_URI[x86_64_v2_rust-gix-path-devel.sha256sum] = "f1c1f5b9d3a36aa1aeabf8d79b87213de0e94814280612702d482ef41fb1264c"

URI_aarch64_rust-gix-path+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-path+default-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-path+default-devel}"
SRC_URI[aarch64_rust-gix-path+default-devel.sha256sum] = "b60efd4f39371d82491117a7517fd5a1d4c4ccf32ed2c072b765d514d987e74c"

URI_aarch64_rust-gix-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-path-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-path-devel}"
SRC_URI[aarch64_rust-gix-path-devel.sha256sum] = "542e9928a92156eb0ff95404aae88fd219184b22794c1e9b87c00b947f21e928"

RDEPENDS:rust-gix-path+default-devel = " \
 cargo \
 rust-gix-path-devel \
 "
RDEPENDS:rust-gix-path-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-trace+default-devel \
 rust-gix-validate+default-devel \
 rust-thiserror+default-devel \
 "
