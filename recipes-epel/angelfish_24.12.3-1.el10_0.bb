# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "angelfish"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 angelfish \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/angelfish-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ff72488d6571606a750fd55995a1c392339b35a74ec7c4b5e72e56e05c32821"

URI_x86_64_v2_angelfish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/angelfish-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_angelfish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_angelfish}"
SRC_URI[x86_64_v2_angelfish.sha256sum] = "a390f1d46a5089c2ad0a752922eb39c196c685f9d3c4dc45d113e9d9a411fd4f"

URI_aarch64_angelfish = "${EPEL_MIRROR}/aarch64/Packages/a/angelfish-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_angelfish;unpack=0"
SRC_URI:append = " ${URI_aarch64_angelfish}"
SRC_URI[aarch64_angelfish.sha256sum] = "5a574f90b6376c0e4c9961d6d3aa64cac392d02c5f9c4a366a3582ae1ccf93d4"

RDEPENDS:angelfish = " \
 futuresql-qt6 \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kwindowsystem \
 kf6-purpose \
 kf6-qqc2-desktop-style \
 libgcc \
 libstdc++ \
 qcoro-qt6 \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 qt6-qtwebengine \
 "
