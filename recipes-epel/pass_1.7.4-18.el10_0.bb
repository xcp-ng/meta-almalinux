# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pass"
PV = "1.7.4"
PR = "18.el10_0"
PACKAGES = " \
 pass \
 passmenu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pass-1.7.4-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e89a419c0721f464a4cccc20a60c72f25814121c9eec6472cbd2abcc6c6e5c49"

URI_x86_64_v2_pass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pass-1.7.4-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pass}"
SRC_URI[x86_64_v2_pass.sha256sum] = "c0eb760ff8a384b30c4acbc79073424cc97f0276e9f8861c319800df169555ba"

URI_x86_64_v2_passmenu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/passmenu-1.7.4-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_passmenu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_passmenu}"
SRC_URI[x86_64_v2_passmenu.sha256sum] = "a5c5a69254f689feb5069c720bc7f982ea44d1917a05ba16b28533b92a1002d3"

URI_aarch64_pass = "${EPEL_MIRROR}/aarch64/Packages/p/pass-1.7.4-18.el10_0.noarch.rpm;name=aarch64_pass;unpack=0"
SRC_URI:append = " ${URI_aarch64_pass}"
SRC_URI[aarch64_pass.sha256sum] = "2b34cc509f7c3787d40dbd8aec3e718e80217ebd86aaf67d9e0c1ecdecc23680"

URI_aarch64_passmenu = "${EPEL_MIRROR}/aarch64/Packages/p/passmenu-1.7.4-18.el10_0.noarch.rpm;name=aarch64_passmenu;unpack=0"
SRC_URI:append = " ${URI_aarch64_passmenu}"
SRC_URI[aarch64_passmenu.sha256sum] = "ec6e1e3563ab69fad21f427414a22df841504f3e52c52f00ff1838054d23e2ed"

RDEPENDS:pass = " \
 bash \
 git-core \
 gnupg2 \
 qrencode \
 tree \
 "
RDEPENDS:passmenu = " \
 bash \
 pass \
 "
