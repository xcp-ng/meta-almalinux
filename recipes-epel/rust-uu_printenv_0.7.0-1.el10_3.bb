# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_printenv"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_printenv+default-devel \
 rust-uu_printenv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_printenv-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcf56a23abdde2b57c60280633278c4d3c41c66dd9dd939424636fffe15a86b9"

URI_x86_64_v2_rust-uu_printenv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_printenv+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_printenv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_printenv+default-devel}"
SRC_URI[x86_64_v2_rust-uu_printenv+default-devel.sha256sum] = "bea460f2215b1a74c6540a37d2b3c65903b7cdc96129037701978591aa8a2b6a"

URI_x86_64_v2_rust-uu_printenv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_printenv-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_printenv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_printenv-devel}"
SRC_URI[x86_64_v2_rust-uu_printenv-devel.sha256sum] = "c68c87f46dd8de69a46e9e6ce55faf2f89bde0854852c9660a3f676fc1ebfae8"

URI_aarch64_rust-uu_printenv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_printenv+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_printenv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_printenv+default-devel}"
SRC_URI[aarch64_rust-uu_printenv+default-devel.sha256sum] = "44ecf8fe5dae3f042d16f2b52e487fb2e397cb8d59199d73b26de526a1b2fb27"

URI_aarch64_rust-uu_printenv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_printenv-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_printenv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_printenv-devel}"
SRC_URI[aarch64_rust-uu_printenv-devel.sha256sum] = "58173772d271b534c15267a503afda878f93bbbba98630bbf6ea047ebf4eabc4"

RDEPENDS:rust-uu_printenv+default-devel = " \
 cargo \
 rust-uu_printenv-devel \
 "
RDEPENDS:rust-uu_printenv-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 "
