# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libz-rs-sys"
PV = "0.6.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-libz-rs-sys+c-allocator-devel \
 rust-libz-rs-sys+custom-prefix-devel \
 rust-libz-rs-sys+default-devel \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys+gz-devel \
 rust-libz-rs-sys+rust-allocator-devel \
 rust-libz-rs-sys+semver-prefix-devel \
 rust-libz-rs-sys+std-devel \
 rust-libz-rs-sys+testing-prefix-devel \
 rust-libz-rs-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libz-rs-sys-0.6.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc0f73da7a42fa8d679933d6646dbbb375fc254d308fc91f34aa6b30b1c6f594"

URI_x86_64_v2_rust-libz-rs-sys+c-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+c-allocator-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+c-allocator-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+c-allocator-devel.sha256sum] = "07ac0c56e081b42f68652ac7119023482bd4e9cd75e9ac425afe75f4b273ba94"

URI_x86_64_v2_rust-libz-rs-sys+custom-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+custom-prefix-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+custom-prefix-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+custom-prefix-devel.sha256sum] = "5d5f0e3b9c968b02298bb1de9c70c904baa979e76bc18c97508d0f2bcbe30eaf"

URI_x86_64_v2_rust-libz-rs-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+default-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+default-devel.sha256sum] = "31f8c62777afbb50abeb48b6863220a10864af92451a3cbcc5c71ce907a44642"

URI_x86_64_v2_rust-libz-rs-sys+export-symbols-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+export-symbols-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+export-symbols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+export-symbols-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+export-symbols-devel.sha256sum] = "cfd2570cb558b2a8ddd308e1b2b360e3e8ea2218b9ffe8eb52b58ad6c7a45d7d"

URI_x86_64_v2_rust-libz-rs-sys+gz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+gz-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+gz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+gz-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+gz-devel.sha256sum] = "c7332706dbdd171c449d83a086a447fb8a772aba09dcf8a22fb786566d796d50"

URI_x86_64_v2_rust-libz-rs-sys+rust-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+rust-allocator-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+rust-allocator-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+rust-allocator-devel.sha256sum] = "dc5cdefe50bf0cd8d926546f4cd1fc1f175e7a8f3264b4d89df9f89c7bb95c46"

URI_x86_64_v2_rust-libz-rs-sys+semver-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+semver-prefix-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+semver-prefix-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+semver-prefix-devel.sha256sum] = "7b22a610942047e5b5b3c3eb34cd5cd479e1079d9e0e9bc6b5825e2f34ddd19c"

URI_x86_64_v2_rust-libz-rs-sys+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+std-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+std-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+std-devel.sha256sum] = "99f0530fa8111e12b2af79189cb1429b7e86ef45e486d5cc8082c4bbfc9445a2"

URI_x86_64_v2_rust-libz-rs-sys+testing-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+testing-prefix-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+testing-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+testing-prefix-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+testing-prefix-devel.sha256sum] = "71bd8f27c101ddea4e6af8798affa74568d8e1d41fd6bc9157761224d2e1b75f"

URI_x86_64_v2_rust-libz-rs-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys-devel-0.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys-devel.sha256sum] = "90aed932affd5511a4dc1f3428285f2e8862bd763ca81d096a7f826687a18d0e"

URI_aarch64_rust-libz-rs-sys+c-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+c-allocator-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+c-allocator-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+c-allocator-devel.sha256sum] = "9eaae4d75ac84bf9ecfc04e688233a0b132f61633c2f5adea9af5dfd1ec3886f"

URI_aarch64_rust-libz-rs-sys+custom-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+custom-prefix-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+custom-prefix-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+custom-prefix-devel.sha256sum] = "41641edb397f8bee2b1524774a709d5de121b8945aaf432fea1675007cff2eb5"

URI_aarch64_rust-libz-rs-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+default-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+default-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+default-devel.sha256sum] = "6e1afc8b98266b8799b8bd97001ed8ec127922483d925d2a8938e17060535fd1"

URI_aarch64_rust-libz-rs-sys+export-symbols-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+export-symbols-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+export-symbols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+export-symbols-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+export-symbols-devel.sha256sum] = "9bf778ffae596728393beef5e3ba44a4b631ea3daf626d49dedd42703bb9c0f7"

URI_aarch64_rust-libz-rs-sys+gz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+gz-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+gz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+gz-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+gz-devel.sha256sum] = "4dece54e2cfbe163f55783841855ae60c0b4522650fefe5362f8ccf10eb623c8"

URI_aarch64_rust-libz-rs-sys+rust-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+rust-allocator-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+rust-allocator-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+rust-allocator-devel.sha256sum] = "17c6f9070eec8c86df6d7377da1ee49d48cdf625647d9afafb479b5a1a314b2a"

URI_aarch64_rust-libz-rs-sys+semver-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+semver-prefix-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+semver-prefix-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+semver-prefix-devel.sha256sum] = "4eb45d58473fb19a545be51f0f4d8dae8980d2100fb28f9df546f6ba3e2136b2"

URI_aarch64_rust-libz-rs-sys+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+std-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+std-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+std-devel.sha256sum] = "5ba68fdfdb7afebbabda4e28e46f45391b579cb076823b8b85ab2bca752b3628"

URI_aarch64_rust-libz-rs-sys+testing-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+testing-prefix-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+testing-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+testing-prefix-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+testing-prefix-devel.sha256sum] = "8ed6ced650f5415ae97506081a97dbd4f167c58493655cbfa25edb13fd844cb9"

URI_aarch64_rust-libz-rs-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys-devel-0.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys-devel}"
SRC_URI[aarch64_rust-libz-rs-sys-devel.sha256sum] = "09404fbf105a4149b2b1234e3f35ac371a8c4a28fe233ef1e3cf833ab4fac636"

RDEPENDS:rust-libz-rs-sys+c-allocator-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+c-allocator-devel \
 "
RDEPENDS:rust-libz-rs-sys+custom-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+default-devel = " \
 cargo \
 rust-libz-rs-sys+rust-allocator-devel \
 rust-libz-rs-sys+std-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+export-symbols-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+gz-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+rust-allocator-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+rust-allocator-devel \
 "
RDEPENDS:rust-libz-rs-sys+semver-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+std-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+std-devel \
 "
RDEPENDS:rust-libz-rs-sys+testing-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys-devel = " \
 cargo \
 rust \
 rust-zlib-rs+__internal-api-devel \
 rust-zlib-rs-devel \
 "
