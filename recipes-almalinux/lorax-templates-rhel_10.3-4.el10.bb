# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lorax-templates-rhel"
PV = "10.3"
PR = "4.el10"
PACKAGES = " \
 lorax-templates-almalinux \
 lorax-templates-rhel \
 lorax-templates-rhel-64k \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lorax-templates-rhel-10.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "92bfebf49bfad29bfd005346f8608257c111dc66f865d89614ebce35b936fd44"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-almalinux-10.3-4.el10.noarch.rpm;name=x86_64_v2_lorax-templates-almalinux;unpack=0"
SRC_URI[x86_64_v2_lorax-templates-almalinux.sha256sum] = "f8dde38b51be8a6183fe7f53c05e37a20de2351229e7f907602b4ad5f6a04ee0"
RPROVIDES:lorax-templates-almalinux:append:x86_64_v2 = " virtual/lorax-templates"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-rhel-10.3-4.el10.noarch.rpm;name=x86_64_v2_lorax-templates-rhel;unpack=0"
SRC_URI[x86_64_v2_lorax-templates-rhel.sha256sum] = "b19bcc0cea4672849af55f9a39585ea7a6c1094c26693f54e1d8e9c9dee683c5"
RPROVIDES:lorax-templates-rhel:append:x86_64_v2 = " virtual/lorax-templates"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-rhel-64k-10.3-4.el10.noarch.rpm;name=x86_64_v2_lorax-templates-rhel-64k;unpack=0"
SRC_URI[x86_64_v2_lorax-templates-rhel-64k.sha256sum] = "71519e60d8858272c22fe824c03dc8e3597243604542ea4132bf7c8f757d6756"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-almalinux-10.3-4.el10.noarch.rpm;name=aarch64_lorax-templates-almalinux;unpack=0"
SRC_URI[aarch64_lorax-templates-almalinux.sha256sum] = "f8dde38b51be8a6183fe7f53c05e37a20de2351229e7f907602b4ad5f6a04ee0"
RPROVIDES:lorax-templates-almalinux:append:aarch64 = " virtual/lorax-templates"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-rhel-10.3-4.el10.noarch.rpm;name=aarch64_lorax-templates-rhel;unpack=0"
SRC_URI[aarch64_lorax-templates-rhel.sha256sum] = "b19bcc0cea4672849af55f9a39585ea7a6c1094c26693f54e1d8e9c9dee683c5"
RPROVIDES:lorax-templates-rhel:append:aarch64 = " virtual/lorax-templates"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-rhel-64k-10.3-4.el10.noarch.rpm;name=aarch64_lorax-templates-rhel-64k;unpack=0"
SRC_URI[aarch64_lorax-templates-rhel-64k.sha256sum] = "71519e60d8858272c22fe824c03dc8e3597243604542ea4132bf7c8f757d6756"

RDEPENDS:lorax-templates-almalinux = " \
 lorax \
 "
RDEPENDS:lorax-templates-rhel = " \
 lorax \
 "
RDEPENDS:lorax-templates-rhel-64k = " \
 lorax \
 "
