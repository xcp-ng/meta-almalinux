# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glib2"
PV = "2.80.4"
PR = "4.el10_0.7"
PACKAGES = " \
 glib2 \
 glib2-devel \
 glib2-doc \
 glib2-static \
 glib2-tests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/glib2-2.80.4-4.el10_0.7.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d3273efe113eac1d1a00483da796ce56a8fe487213eede258d62e45c79222520"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glib2-2.80.4-4.el10_0.7.x86_64_v2.rpm;name=x86_64_v2_glib2;unpack=0"
SRC_URI[x86_64_v2_glib2.sha256sum] = "4457f0dad1fb7970f725d059653f97d3b0116ab39b7f79b1360bb019277a6fc0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glib2-devel-2.80.4-4.el10_0.7.x86_64_v2.rpm;name=x86_64_v2_glib2-devel;unpack=0"
SRC_URI[x86_64_v2_glib2-devel.sha256sum] = "d1505585c85fad3f19e2736201db6d9884c9c390656d6279c56110b0961ffb6e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glib2-doc-2.80.4-4.el10_0.7.x86_64_v2.rpm;name=x86_64_v2_glib2-doc;unpack=0"
SRC_URI[x86_64_v2_glib2-doc.sha256sum] = "072314903415fb2902f8a2986e371b01b8389d6398754f97418a53d17f1fabdf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glib2-static-2.80.4-4.el10_0.7.x86_64_v2.rpm;name=x86_64_v2_glib2-static;unpack=0"
SRC_URI[x86_64_v2_glib2-static.sha256sum] = "2c7df95ea30f45846d798f173dfcc94c3790cc3dbbe0a4ad4cb4bb2fa6111de3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glib2-tests-2.80.4-4.el10_0.7.x86_64_v2.rpm;name=x86_64_v2_glib2-tests;unpack=0"
SRC_URI[x86_64_v2_glib2-tests.sha256sum] = "f609c548c3a38b0d9bb08d77e4a349f5a4dbca15e0d7e87f08b8992763d40621"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glib2-2.80.4-4.el10_0.7.aarch64.rpm;name=aarch64_glib2;unpack=0"
SRC_URI[aarch64_glib2.sha256sum] = "10df6501a2145f9f94451214fc510b1c77fd8f29ab9b8c3ac69380da5661656d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glib2-devel-2.80.4-4.el10_0.7.aarch64.rpm;name=aarch64_glib2-devel;unpack=0"
SRC_URI[aarch64_glib2-devel.sha256sum] = "4d32ea5ce42d20a56ba8d95c2abc5f90b7a18d51ef0f97f46b1a6a577c5ad2c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glib2-doc-2.80.4-4.el10_0.7.aarch64.rpm;name=aarch64_glib2-doc;unpack=0"
SRC_URI[aarch64_glib2-doc.sha256sum] = "ad9be73823ea101dc990763e70d27830161a5538b6f46cc619732f784c357d36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glib2-static-2.80.4-4.el10_0.7.aarch64.rpm;name=aarch64_glib2-static;unpack=0"
SRC_URI[aarch64_glib2-static.sha256sum] = "928719a92118d3b80fff31a56786ca740fed05433b4c045b07b2f7ca2454cdc5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glib2-tests-2.80.4-4.el10_0.7.aarch64.rpm;name=aarch64_glib2-tests;unpack=0"
SRC_URI[aarch64_glib2-tests.sha256sum] = "34e948529f3eb5f5fcb2b9473fb2c66cfca70f44c5c8e3e5630e69a8a4dea023"

RDEPENDS:glib2:x86_64_v2 = " \
 bash \
 glibc \
 gnutls \
 libffi \
 libmount \
 libselinux \
 pcre2 \
 zlib-ng-compat \
"
RDEPENDS:glib2:aarch64 = " \
 bash \
 glibc \
 gnutls \
 libffi \
 libgcc \
 libmount \
 libselinux \
 pcre2 \
 zlib-ng-compat \
"
RDEPENDS:glib2-devel = " \
 bash \
 elfutils-libelf \
 glib2 \
 glib2-devel \
 glibc \
 libffi \
 libffi-devel \
 libmount-devel \
 libselinux-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 python3 \
 python3-packaging \
 sysprof-capture-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:glib2-doc = " \
 glib2 \
 "
RDEPENDS:glib2-static = " \
 glib2-devel \
 pcre2-static \
 sysprof-capture-devel \
 "
RDEPENDS:glib2-tests = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 pcre2 \
 python3 \
 "
