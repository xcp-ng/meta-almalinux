# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-CIDR"
PV = "0.27"
PR = "1.el10_3"
PACKAGES = " \
 perl-Net-CIDR \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-CIDR-0.27-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16c5a682db357004863b65af6a23ee4d7f152b973a6ee3b09b526791bb835e0c"

URI_x86_64_v2_perl-Net-CIDR = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-CIDR-0.27-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-CIDR;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-CIDR}"
SRC_URI[x86_64_v2_perl-Net-CIDR.sha256sum] = "c4605cdc8ffd5c8aac05bbf2cb629bbefcb330ee45cd6cb170e7b6fabadc6110"

URI_aarch64_perl-Net-CIDR = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-CIDR-0.27-1.el10_3.noarch.rpm;name=aarch64_perl-Net-CIDR;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-CIDR}"
SRC_URI[aarch64_perl-Net-CIDR.sha256sum] = "4b3e8159668490361d3d2dfac304326dff59e37feaeaef5ecc6d6ac277a3c815"

RDEPENDS:perl-Net-CIDR = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
