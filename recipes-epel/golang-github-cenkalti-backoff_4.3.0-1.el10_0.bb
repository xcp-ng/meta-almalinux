# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-cenkalti-backoff"
PV = "4.3.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-cenkalti-backoff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-cenkalti-backoff-4.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c333b8ecba3a63939543e3cc5fb5b5edf43e9f1e86f84bdd85abc871628a031"

URI_x86_64_v2_golang-github-cenkalti-backoff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-cenkalti-backoff-devel-4.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-cenkalti-backoff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-cenkalti-backoff-devel}"
SRC_URI[x86_64_v2_golang-github-cenkalti-backoff-devel.sha256sum] = "da40673d37718ace3e797cfc4fdb2e62d9e47fd8bce68e6f036761d034b08d20"

URI_aarch64_golang-github-cenkalti-backoff-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-cenkalti-backoff-devel-4.3.0-1.el10_0.noarch.rpm;name=aarch64_golang-github-cenkalti-backoff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-cenkalti-backoff-devel}"
SRC_URI[aarch64_golang-github-cenkalti-backoff-devel.sha256sum] = "45d99b7b5f8b3d8f278a1145441be408465e65d9dc0e3da4a36428567d81d875"

RDEPENDS:golang-github-cenkalti-backoff-devel = " \
 go-filesystem \
 "
