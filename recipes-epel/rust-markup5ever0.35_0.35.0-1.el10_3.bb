# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-markup5ever0.35"
PV = "0.35.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-markup5ever0.35+default-devel \
 rust-markup5ever0.35-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-markup5ever0.35-0.35.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d021bec7debf1cec390ce6cf1939314e1b0219da3409b36dd63d8feb26e4262"

URI_x86_64_v2_rust-markup5ever0.35+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever0.35+default-devel-0.35.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever0.35+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever0.35+default-devel}"
SRC_URI[x86_64_v2_rust-markup5ever0.35+default-devel.sha256sum] = "50c194c07337008bb16a6ffd95dced7f76457671544f0db255a49f25f1ba2d22"

URI_x86_64_v2_rust-markup5ever0.35-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever0.35-devel-0.35.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever0.35-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever0.35-devel}"
SRC_URI[x86_64_v2_rust-markup5ever0.35-devel.sha256sum] = "d6fe01fee76520a4d40ebfab6240f30d446ff15d84b3bde4642f33096bf5fa16"

URI_aarch64_rust-markup5ever0.35+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever0.35+default-devel-0.35.0-1.el10_3.noarch.rpm;name=aarch64_rust-markup5ever0.35+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever0.35+default-devel}"
SRC_URI[aarch64_rust-markup5ever0.35+default-devel.sha256sum] = "e44b0bfc1de2c705562470f5947075153b1e1541ca48eb0506db0c269d77f172"

URI_aarch64_rust-markup5ever0.35-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever0.35-devel-0.35.0-1.el10_3.noarch.rpm;name=aarch64_rust-markup5ever0.35-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever0.35-devel}"
SRC_URI[aarch64_rust-markup5ever0.35-devel.sha256sum] = "c89a1f4769f9d3940ef54321e3a4266cd466db6eb085a7faa3dc1bd4354c0e14"

RDEPENDS:rust-markup5ever0.35+default-devel = " \
 cargo \
 rust-markup5ever0.35-devel \
 "
RDEPENDS:rust-markup5ever0.35-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-tendril0.4+default-devel \
 rust-web_atoms0.1+default-devel \
 "
