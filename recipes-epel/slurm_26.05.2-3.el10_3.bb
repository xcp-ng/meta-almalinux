# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "slurm"
PV = "26.05.2"
PR = "3.el10_3"
PACKAGES = " \
 slurm \
 slurm-contribs \
 slurm-devel \
 slurm-doc \
 slurm-gui \
 slurm-libs \
 slurm-nss_slurm \
 slurm-openlava \
 slurm-pam_slurm \
 slurm-perlapi \
 slurm-sackd \
 slurm-slurmctld \
 slurm-slurmd \
 slurm-slurmdbd \
 slurm-slurmrestd \
 slurm-torque \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/slurm-26.05.2-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fe6ba6d61bbbe92f743cb7291a159270869e7f69e0ebeb33f91f086e16ee514"

URI_x86_64_v2_slurm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm}"
SRC_URI[x86_64_v2_slurm.sha256sum] = "43b8473c0e6d07e8678e309f1ce4415062004663da83cdd9ca1bc5311bbd4d1c"

URI_x86_64_v2_slurm-contribs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-contribs-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-contribs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-contribs}"
SRC_URI[x86_64_v2_slurm-contribs.sha256sum] = "d1a2a3fe2a5f57e0ddc00b6b1387c8596d6a543b504df084bd776e35f374316a"

URI_x86_64_v2_slurm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-devel-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-devel}"
SRC_URI[x86_64_v2_slurm-devel.sha256sum] = "29bc235b9ab31a3e6208c3cccd4facd2c1344ffdcf1c52bb2ec0b71ff3ec7dcb"

URI_x86_64_v2_slurm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-doc-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-doc}"
SRC_URI[x86_64_v2_slurm-doc.sha256sum] = "dcc927ef377b620ddd1bbaf0e6db458803b6a0cc92cc5158cbb5056a58a7510f"

URI_x86_64_v2_slurm-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-gui-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-gui}"
SRC_URI[x86_64_v2_slurm-gui.sha256sum] = "4cc64b42a3daa105e860def0c3caa283331064e6446ab7abf497d894913a7949"

URI_x86_64_v2_slurm-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-libs-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-libs}"
SRC_URI[x86_64_v2_slurm-libs.sha256sum] = "a568f2cba68d2849c5a181b90ac6bd1b0be6012bbedd5e57422cf1f62fd25f93"

URI_x86_64_v2_slurm-nss_slurm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-nss_slurm-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-nss_slurm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-nss_slurm}"
SRC_URI[x86_64_v2_slurm-nss_slurm.sha256sum] = "e74e4666912a44176eaea65396bc455543acbc212d39e9f6bdf087461ca16d25"

URI_x86_64_v2_slurm-openlava = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-openlava-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-openlava;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-openlava}"
SRC_URI[x86_64_v2_slurm-openlava.sha256sum] = "1969da051c4c4c5f6414ca23f6d831ff1756e6bcd255a5b6961ec1d5aad29ebc"

URI_x86_64_v2_slurm-pam_slurm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-pam_slurm-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-pam_slurm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-pam_slurm}"
SRC_URI[x86_64_v2_slurm-pam_slurm.sha256sum] = "4cf9d6f6a0b142ebf252ba3f1fce1ddb63256d19107a6476d9901d4fc5f15692"

URI_x86_64_v2_slurm-perlapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-perlapi-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-perlapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-perlapi}"
SRC_URI[x86_64_v2_slurm-perlapi.sha256sum] = "3bfd53b0a2b4a09c88d0a05279520585accd6a202ac7f4b21ec816f8413322b4"
RPROVIDES:slurm-perlapi:x86_64_v2 = "virtual/perl_Slurm_"

URI_x86_64_v2_slurm-sackd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-sackd-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-sackd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-sackd}"
SRC_URI[x86_64_v2_slurm-sackd.sha256sum] = "501a1bd816f9317d1379722f2576871af6d1ab6fa0c4df39665ff17f4798ad87"

URI_x86_64_v2_slurm-slurmctld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-slurmctld-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-slurmctld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-slurmctld}"
SRC_URI[x86_64_v2_slurm-slurmctld.sha256sum] = "37f48072147e5a0424113f6f0f02a0016cd4c925288bdf2a2a6ea51dd623571d"

URI_x86_64_v2_slurm-slurmd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-slurmd-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-slurmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-slurmd}"
SRC_URI[x86_64_v2_slurm-slurmd.sha256sum] = "f8b55d16c1c69313a6dfb14c75c70bbe6dfea874d3873770df54bc4c2e197d0f"

URI_x86_64_v2_slurm-slurmdbd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-slurmdbd-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-slurmdbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-slurmdbd}"
SRC_URI[x86_64_v2_slurm-slurmdbd.sha256sum] = "c7013567a32384ce3a1041b7a74d9a5d99863e382a16b3c68ffe9342d068acb9"

URI_x86_64_v2_slurm-slurmrestd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-slurmrestd-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-slurmrestd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-slurmrestd}"
SRC_URI[x86_64_v2_slurm-slurmrestd.sha256sum] = "51d5ee7f9830c9f5953fce50d36cff5d224efd6d2ed025da334e3d58b835ba64"

URI_x86_64_v2_slurm-torque = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-torque-26.05.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-torque;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slurm-torque}"
SRC_URI[x86_64_v2_slurm-torque.sha256sum] = "3b8c77121ea769999d4295fe30f0f6130a7e64c3ad8229b00d241b42846a663f"

URI_aarch64_slurm = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm}"
SRC_URI[aarch64_slurm.sha256sum] = "5ed879136941cdd20c22d2246dc6d22aec38449ca7960f3354a5bf3dda3db3e3"

URI_aarch64_slurm-contribs = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-contribs-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-contribs;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-contribs}"
SRC_URI[aarch64_slurm-contribs.sha256sum] = "0668907b7c8923a18d5de671c917aff087bb970f6e49c22b508675ab24e9b017"

URI_aarch64_slurm-devel = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-devel-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-devel}"
SRC_URI[aarch64_slurm-devel.sha256sum] = "c538cd9b306e4e53e62e2699765856d1d3c69fba3d32a65f1fb6b0a0e47a3808"

URI_aarch64_slurm-doc = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-doc-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-doc}"
SRC_URI[aarch64_slurm-doc.sha256sum] = "8c665820782f34f01dbaf05376ebf9f2c9c9c900f7948e09949742bf8bc96344"

URI_aarch64_slurm-gui = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-gui-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-gui}"
SRC_URI[aarch64_slurm-gui.sha256sum] = "aa875b7cbf34b1986d188fd08c2d82112d30afa68de1ff1cee976675c32cdc20"

URI_aarch64_slurm-libs = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-libs-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-libs}"
SRC_URI[aarch64_slurm-libs.sha256sum] = "df0a1db74c292f7778f97b1834d86b158b9f7a0f6980ec26944cf1ee635ce999"

URI_aarch64_slurm-nss_slurm = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-nss_slurm-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-nss_slurm;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-nss_slurm}"
SRC_URI[aarch64_slurm-nss_slurm.sha256sum] = "acfd93a0c9f54c51e87ca09d00c414fef2da547b9b2496e55a02237671a12605"

URI_aarch64_slurm-openlava = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-openlava-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-openlava;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-openlava}"
SRC_URI[aarch64_slurm-openlava.sha256sum] = "587b177903cfc6dbdf2add80b0a71d7686b84070ab6be024cf56968b1570654b"

URI_aarch64_slurm-pam_slurm = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-pam_slurm-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-pam_slurm;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-pam_slurm}"
SRC_URI[aarch64_slurm-pam_slurm.sha256sum] = "77a72c8799c9547de7efe8afc203368f375d9215f6c19aaa0f496c17d2ff9876"

URI_aarch64_slurm-perlapi = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-perlapi-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-perlapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-perlapi}"
SRC_URI[aarch64_slurm-perlapi.sha256sum] = "1a664cb26a5088570cc59248c9f2e707bf1a5af7f0adc15c4f7b8cf4bf03151a"
RPROVIDES:slurm-perlapi:aarch64 = "virtual/perl_Slurm_"

URI_aarch64_slurm-sackd = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-sackd-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-sackd;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-sackd}"
SRC_URI[aarch64_slurm-sackd.sha256sum] = "0a6c6b909ff091e66f81395bdc0a54264a6aabb73118a54801772570874a347a"

URI_aarch64_slurm-slurmctld = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-slurmctld-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-slurmctld;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-slurmctld}"
SRC_URI[aarch64_slurm-slurmctld.sha256sum] = "60b130b28f4cc359ed1a7749e936c0f485f211f38183451a667bcd0e74554107"

URI_aarch64_slurm-slurmd = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-slurmd-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-slurmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-slurmd}"
SRC_URI[aarch64_slurm-slurmd.sha256sum] = "1738018dbab90ac9aa7b955ec1e868ff9073d0e18c30b1b0585782aa3fdc0740"

URI_aarch64_slurm-slurmdbd = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-slurmdbd-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-slurmdbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-slurmdbd}"
SRC_URI[aarch64_slurm-slurmdbd.sha256sum] = "01679e975bee7587feaab21233959ac97d6271d079c9f0b1fc7e0025f963500e"

URI_aarch64_slurm-slurmrestd = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-slurmrestd-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-slurmrestd;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-slurmrestd}"
SRC_URI[aarch64_slurm-slurmrestd.sha256sum] = "53c239b3ecae65abf068de23d0ff64c90b4bb690c09f3f86db2b5adaff95f103"

URI_aarch64_slurm-torque = "${EPEL_MIRROR}/aarch64/Packages/s/slurm-torque-26.05.2-3.el10_3.aarch64.rpm;name=aarch64_slurm-torque;unpack=0"
SRC_URI:append = " ${URI_aarch64_slurm-torque}"
SRC_URI[aarch64_slurm-torque.sha256sum] = "e1697cb78ec85e633bf90c70505f338ea3621242fdd22047af74f40a9587e394"

RDEPENDS:slurm = " \
 bash \
 dbus-libs \
 freeipmi \
 glibc \
 hdf5 \
 hwloc-libs \
 infiniband-diags \
 json-c \
 libaec \
 libibumad \
 libjwt \
 librdkafka \
 libyaml \
 llhttp \
 lua-libs \
 lz4-libs \
 mariadb-connector-c \
 munge \
 munge-libs \
 numactl-libs \
 pmix \
 readline \
 s-nail \
 slurm-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:slurm-contribs = " \
 bash \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-POSIX \
 perl-Sys-Hostname \
 perl-autouse \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-podlators \
 slurm-perlapi \
 virtual/perl_Slurm_ \
 "
RDEPENDS:slurm-devel = " \
 slurm-libs \
 "
RDEPENDS:slurm-doc = " \
 "
RDEPENDS:slurm-gui = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 slurm \
 slurm-libs \
 "
RDEPENDS:slurm-libs = " \
 glibc \
 "
RDEPENDS:slurm-nss_slurm = " \
 glibc \
 slurm-libs \
 "
RDEPENDS:slurm-openlava = " \
 perl-FindBin \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Switch \
 perl-autouse \
 perl-interpreter \
 perl-lib \
 perl-libs \
 slurm-perlapi \
 virtual/perl_Slurm_ \
 "
RDEPENDS:slurm-pam_slurm = " \
 glibc \
 slurm-libs \
 "
RDEPENDS:slurm-perlapi = " \
 glibc \
 perl-AutoLoader \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 slurm-libs \
 "
RDEPENDS:slurm-sackd = " \
 glibc \
 slurm \
 slurm-libs \
 "
RDEPENDS:slurm-slurmctld = " \
 bash \
 glibc \
 slurm \
 slurm-libs \
 "
RDEPENDS:slurm-slurmd = " \
 bash \
 glibc \
 hwloc-libs \
 pam-libs \
 slurm \
 slurm-libs \
 "
RDEPENDS:slurm-slurmdbd = " \
 bash \
 glibc \
 mariadb-connector-c \
 slurm \
 slurm-libs \
 "
RDEPENDS:slurm-slurmrestd = " \
 glibc \
 slurm \
 slurm-libs \
 "
RDEPENDS:slurm-torque = " \
 glibc \
 perl-English \
 perl-File-Basename \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-POSIX \
 perl-autouse \
 perl-interpreter \
 perl-lib \
 perl-libs \
 slurm \
 slurm-perlapi \
 virtual/perl_Slurm_ \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/perl_Slurm_"

PROVIDES:append:aarch64 = " rpm/virtual/perl_Slurm_"
