# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "edflib"
PV = "1.26"
PR = "3.el10_0"
PACKAGES = " \
 edflib \
 edflib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/edflib-1.26-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b8548263edcae98cf4442b14caa59d0bbe67e50783485adcec2b8d5e047f4c2"

URI_x86_64_v2_edflib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/edflib-1.26-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_edflib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edflib}"
SRC_URI[x86_64_v2_edflib.sha256sum] = "71eff1c9885c107bf558fd84dc2f1388124c54a919bdc4c1961f471e66e8b174"

URI_x86_64_v2_edflib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/edflib-devel-1.26-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_edflib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edflib-devel}"
SRC_URI[x86_64_v2_edflib-devel.sha256sum] = "83ed82aca811b00ab0c9bbf9e08c3abaed30ce1b840af43c8aba508a4c7d70e8"

URI_aarch64_edflib = "${EPEL_MIRROR}/aarch64/Packages/e/edflib-1.26-3.el10_0.aarch64.rpm;name=aarch64_edflib;unpack=0"
SRC_URI:append = " ${URI_aarch64_edflib}"
SRC_URI[aarch64_edflib.sha256sum] = "cd39ce88087bbacc8a7b58f36d2046483c02dc933f9d13a8094d498524a4dc9b"

URI_aarch64_edflib-devel = "${EPEL_MIRROR}/aarch64/Packages/e/edflib-devel-1.26-3.el10_0.aarch64.rpm;name=aarch64_edflib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_edflib-devel}"
SRC_URI[aarch64_edflib-devel.sha256sum] = "286c184576676778e4f708bda500fd22c3c0c4a92d9833e3ce5693fc66bd2b80"

RDEPENDS:edflib = " \
 glibc \
 "
RDEPENDS:edflib-devel = " \
 edflib \
 "
