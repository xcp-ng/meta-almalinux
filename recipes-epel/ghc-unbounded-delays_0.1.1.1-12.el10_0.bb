# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-unbounded-delays"
PV = "0.1.1.1"
PR = "12.el10_0"
PACKAGES = " \
 ghc-unbounded-delays \
 ghc-unbounded-delays-devel \
 ghc-unbounded-delays-doc \
 ghc-unbounded-delays-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-unbounded-delays-0.1.1.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdb42d8f475aa2567f1e847b761b87cacdff4c26dee6172bae17d02581519a69"

URI_x86_64_v2_ghc-unbounded-delays = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unbounded-delays-0.1.1.1-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unbounded-delays;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unbounded-delays}"
SRC_URI[x86_64_v2_ghc-unbounded-delays.sha256sum] = "bdcc963048f77f91707be7da9902932afd7880eab9acdbbe9349d3f223acdbe1"

URI_x86_64_v2_ghc-unbounded-delays-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unbounded-delays-devel-0.1.1.1-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unbounded-delays-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unbounded-delays-devel}"
SRC_URI[x86_64_v2_ghc-unbounded-delays-devel.sha256sum] = "bb4ccc448f3610b605a7e9141264cf0afb69c753e6e39344ca30e8aa98f0c9bc"

URI_x86_64_v2_ghc-unbounded-delays-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unbounded-delays-doc-0.1.1.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-unbounded-delays-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unbounded-delays-doc}"
SRC_URI[x86_64_v2_ghc-unbounded-delays-doc.sha256sum] = "f9358f7373e7cdd2e0d3d59db5429694809ae3c5bdfce443c25ac90ef61cb9c6"

URI_x86_64_v2_ghc-unbounded-delays-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unbounded-delays-prof-0.1.1.1-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unbounded-delays-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unbounded-delays-prof}"
SRC_URI[x86_64_v2_ghc-unbounded-delays-prof.sha256sum] = "a4128bd67611c8fec247f6730eead4e8768051354b90ec543d4ce258ab5cbea9"

URI_aarch64_ghc-unbounded-delays = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unbounded-delays-0.1.1.1-12.el10_0.aarch64.rpm;name=aarch64_ghc-unbounded-delays;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unbounded-delays}"
SRC_URI[aarch64_ghc-unbounded-delays.sha256sum] = "9a094a61987e96f7081ac45ab77d8d5b3a04910e37be126db1bcc7b398da1f66"

URI_aarch64_ghc-unbounded-delays-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unbounded-delays-devel-0.1.1.1-12.el10_0.aarch64.rpm;name=aarch64_ghc-unbounded-delays-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unbounded-delays-devel}"
SRC_URI[aarch64_ghc-unbounded-delays-devel.sha256sum] = "6c6cc4c2844d0a3c98333a8d56b8c4015c3346f74e17f3035738f0d0f8b34bb7"

URI_aarch64_ghc-unbounded-delays-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unbounded-delays-doc-0.1.1.1-12.el10_0.noarch.rpm;name=aarch64_ghc-unbounded-delays-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unbounded-delays-doc}"
SRC_URI[aarch64_ghc-unbounded-delays-doc.sha256sum] = "6e3f1c459d84c83989130a89c41d70d590dc9c178e0feb2afe8cc6fa9794e3ed"

URI_aarch64_ghc-unbounded-delays-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unbounded-delays-prof-0.1.1.1-12.el10_0.aarch64.rpm;name=aarch64_ghc-unbounded-delays-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unbounded-delays-prof}"
SRC_URI[aarch64_ghc-unbounded-delays-prof.sha256sum] = "88a85ea8a20d57d0e6625c02fa25c563296f3daa5e293df19f13f2b7d4866d70"

RDEPENDS:ghc-unbounded-delays = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-unbounded-delays-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-unbounded-delays \
 "
RDEPENDS:ghc-unbounded-delays-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-unbounded-delays-prof = " \
 ghc-base-prof \
 ghc-unbounded-delays-devel \
 "
