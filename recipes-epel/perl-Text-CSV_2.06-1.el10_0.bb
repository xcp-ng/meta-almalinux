# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-CSV"
PV = "2.06"
PR = "1.el10_0"
PACKAGES = " \
 perl-Text-CSV \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-CSV-2.06-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd9138570c031a38b39ad7d8650d70abedcf16697517b4b0a880587c55117ee7"

URI_x86_64_v2_perl-Text-CSV = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-CSV-2.06-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-CSV;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-CSV}"
SRC_URI[x86_64_v2_perl-Text-CSV.sha256sum] = "9921c0badb118ec63622e58d5d51f02d75bf47adb3c6d99ac8fe0fbe09d5e618"

URI_aarch64_perl-Text-CSV = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-CSV-2.06-1.el10_0.noarch.rpm;name=aarch64_perl-Text-CSV;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-CSV}"
SRC_URI[aarch64_perl-Text-CSV.sha256sum] = "e7f094ff0ed8b77f010ad243695b96f8e3df03abb6cc4168c137e5cbee07c26b"

RDEPENDS:perl-Text-CSV = " \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-libs \
 perl-overload \
 perl-vars \
 "
