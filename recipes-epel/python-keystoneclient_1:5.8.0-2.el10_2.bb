# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-keystoneclient"
PE = "1"
PV = "5.8.0"
PR = "2.el10_2"
PACKAGES = " \
 python-keystoneclient-doc \
 python3-keystoneclient \
 python3-keystoneclient-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-keystoneclient-5.8.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c4c7a0082a77db50b15ba970a33455b456ddb7b6c2ce0e1ab07aac52d374022"

URI_x86_64_v2_python-keystoneclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-keystoneclient-doc-5.8.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-keystoneclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-keystoneclient-doc}"
SRC_URI[x86_64_v2_python-keystoneclient-doc.sha256sum] = "2f562163dd9c39d5b9650118f85c5bf43a0e0642cdf8a2a157311def2b111303"

URI_x86_64_v2_python3-keystoneclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneclient-5.8.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneclient}"
SRC_URI[x86_64_v2_python3-keystoneclient.sha256sum] = "e526d3f3507d92cecfa7754880461b4819d4c3385cb335159485ba193453cde6"

URI_x86_64_v2_python3-keystoneclient-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneclient-tests-5.8.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneclient-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneclient-tests}"
SRC_URI[x86_64_v2_python3-keystoneclient-tests.sha256sum] = "da81b2148278bbcb5d433dbaf1c714e80e90002eac119b63280f8841321d0109"

URI_aarch64_python-keystoneclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-keystoneclient-doc-5.8.0-2.el10_2.noarch.rpm;name=aarch64_python-keystoneclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-keystoneclient-doc}"
SRC_URI[aarch64_python-keystoneclient-doc.sha256sum] = "ff85a3026e3af5849ca80c560d01836252de731f2620f01830807577b9c40431"

URI_aarch64_python3-keystoneclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneclient-5.8.0-2.el10_2.noarch.rpm;name=aarch64_python3-keystoneclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneclient}"
SRC_URI[aarch64_python3-keystoneclient.sha256sum] = "6dd4c4fa389137b7011a1e3ad029de16cdddd1488ef254f2c9ece5fd8693686c"

URI_aarch64_python3-keystoneclient-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneclient-tests-5.8.0-2.el10_2.noarch.rpm;name=aarch64_python3-keystoneclient-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneclient-tests}"
SRC_URI[aarch64_python3-keystoneclient-tests.sha256sum] = "dbbbdd43941344cd26ca500111e54066aba8941f292c5d8d10c958f92224a3ec"

RDEPENDS:python-keystoneclient-doc = " \
 "
RDEPENDS:python3-keystoneclient = " \
 python3 \
 python3-debtcollector \
 python3-keyring \
 python3-keystoneauth1 \
 python3-oslo-config \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-packaging \
 python3-pbr \
 python3-requests \
 python3-stevedore \
 "
RDEPENDS:python3-keystoneclient-tests = " \
 python3 \
 python3-keystoneclient \
 "
