# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_json"
PV = "1.0.151"
PR = "1.el10_2"
PACKAGES = " \
 rust-serde_json+alloc-devel \
 rust-serde_json+arbitrary_precision-devel \
 rust-serde_json+default-devel \
 rust-serde_json+float_roundtrip-devel \
 rust-serde_json+indexmap-devel \
 rust-serde_json+preserve_order-devel \
 rust-serde_json+raw_value-devel \
 rust-serde_json+std-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-serde_json-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_json-1.0.151-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53ccc4f21c07a3c665b49f40a1dea6a54963ccf24c07ef4d780543150b7523b8"

URI_x86_64_v2_rust-serde_json+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+alloc-devel-1.0.151-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_json+alloc-devel.sha256sum] = "5210d1b696f81ad95fcc3aeb5816090c75f0b6db67a585e0892b10021bb577bd"

URI_x86_64_v2_rust-serde_json+arbitrary_precision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+arbitrary_precision-devel-1.0.151-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+arbitrary_precision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+arbitrary_precision-devel}"
SRC_URI[x86_64_v2_rust-serde_json+arbitrary_precision-devel.sha256sum] = "96e91dc2940cf4b9a3d24246fa022c8a21f9426068cf5beff08316e80a071667"

URI_x86_64_v2_rust-serde_json+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+default-devel-1.0.151-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+default-devel}"
SRC_URI[x86_64_v2_rust-serde_json+default-devel.sha256sum] = "c0a348f654a15b59dad775612db0497358f1516556e6516b3b855305e93dec8c"

URI_x86_64_v2_rust-serde_json+float_roundtrip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+float_roundtrip-devel-1.0.151-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+float_roundtrip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+float_roundtrip-devel}"
SRC_URI[x86_64_v2_rust-serde_json+float_roundtrip-devel.sha256sum] = "c9565d4052c5e3641807979b0c8259ed58440bfb2e98a5c6221590f94a102aaf"

URI_x86_64_v2_rust-serde_json+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+indexmap-devel-1.0.151-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+indexmap-devel}"
SRC_URI[x86_64_v2_rust-serde_json+indexmap-devel.sha256sum] = "68851c5e0dff0d5cb134987c678c69a8b46159c547a12317e1121ca92a395d19"

URI_x86_64_v2_rust-serde_json+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+preserve_order-devel-1.0.151-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-serde_json+preserve_order-devel.sha256sum] = "b5f4c9a2edc0b986e51319576464c9be52f32c43f159db11b0507f404ae28df5"

URI_x86_64_v2_rust-serde_json+raw_value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+raw_value-devel-1.0.151-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+raw_value-devel}"
SRC_URI[x86_64_v2_rust-serde_json+raw_value-devel.sha256sum] = "1e3c5823e6f089d875e94f4240c0961420746c06ae27f98b9315980403661fae"

URI_x86_64_v2_rust-serde_json+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+std-devel-1.0.151-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+std-devel}"
SRC_URI[x86_64_v2_rust-serde_json+std-devel.sha256sum] = "779ed30087aa5335030adbcc39f2c59ce3c281a12aeaed7213d5a4c488111bd6"

URI_x86_64_v2_rust-serde_json+unbounded_depth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+unbounded_depth-devel-1.0.151-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+unbounded_depth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+unbounded_depth-devel}"
SRC_URI[x86_64_v2_rust-serde_json+unbounded_depth-devel.sha256sum] = "633d96f5864073b085bbe444ac073e3152e2b01e58500a67ddbddb980e425661"

URI_x86_64_v2_rust-serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json-devel-1.0.151-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json-devel}"
SRC_URI[x86_64_v2_rust-serde_json-devel.sha256sum] = "24e923413c6312839e3b9c111ed25e602d3ecdd1213226ee5ae85ae33ac7a8de"

URI_aarch64_rust-serde_json+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+alloc-devel-1.0.151-1.el10_2.noarch.rpm;name=aarch64_rust-serde_json+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+alloc-devel}"
SRC_URI[aarch64_rust-serde_json+alloc-devel.sha256sum] = "25be185da82683c046e492a81869f1c16cd9bd885aabd2e3ccd45791766abc1d"

URI_aarch64_rust-serde_json+arbitrary_precision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+arbitrary_precision-devel-1.0.151-1.el10_2.noarch.rpm;name=aarch64_rust-serde_json+arbitrary_precision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+arbitrary_precision-devel}"
SRC_URI[aarch64_rust-serde_json+arbitrary_precision-devel.sha256sum] = "a8c934fdc077b11a3ab24888107577516095eb49cfe2f7db3ab211e0001cf9fe"

URI_aarch64_rust-serde_json+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+default-devel-1.0.151-1.el10_2.noarch.rpm;name=aarch64_rust-serde_json+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+default-devel}"
SRC_URI[aarch64_rust-serde_json+default-devel.sha256sum] = "165f96fdc935cc492dd73f350809fabcffca840ddf7122128cefce7249a4e331"

URI_aarch64_rust-serde_json+float_roundtrip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+float_roundtrip-devel-1.0.151-1.el10_2.noarch.rpm;name=aarch64_rust-serde_json+float_roundtrip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+float_roundtrip-devel}"
SRC_URI[aarch64_rust-serde_json+float_roundtrip-devel.sha256sum] = "75ce4b81b9c97f2b3ae608d135b7cf96f7be3c2e5d01c95476242f3ce7964fc1"

URI_aarch64_rust-serde_json+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+indexmap-devel-1.0.151-1.el10_2.noarch.rpm;name=aarch64_rust-serde_json+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+indexmap-devel}"
SRC_URI[aarch64_rust-serde_json+indexmap-devel.sha256sum] = "4f77473595fd813c255b913b4ef478522a2aaba15d820c81f03bc24d88975a15"

URI_aarch64_rust-serde_json+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+preserve_order-devel-1.0.151-1.el10_2.noarch.rpm;name=aarch64_rust-serde_json+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+preserve_order-devel}"
SRC_URI[aarch64_rust-serde_json+preserve_order-devel.sha256sum] = "848d7179cf252deb83c23f092bce0647d9290f1ea7e70f1a4636c49e5a995b2d"

URI_aarch64_rust-serde_json+raw_value-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+raw_value-devel-1.0.151-1.el10_2.noarch.rpm;name=aarch64_rust-serde_json+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+raw_value-devel}"
SRC_URI[aarch64_rust-serde_json+raw_value-devel.sha256sum] = "819dbadb460ab70071ce0cb97ed1045de318f8a1eeb9ce7a3b9086530cbedd59"

URI_aarch64_rust-serde_json+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+std-devel-1.0.151-1.el10_2.noarch.rpm;name=aarch64_rust-serde_json+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+std-devel}"
SRC_URI[aarch64_rust-serde_json+std-devel.sha256sum] = "83944fc31446ff5268a2d05050db5a1ef06b591d476b801c0e25983ea9ae8f31"

URI_aarch64_rust-serde_json+unbounded_depth-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+unbounded_depth-devel-1.0.151-1.el10_2.noarch.rpm;name=aarch64_rust-serde_json+unbounded_depth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+unbounded_depth-devel}"
SRC_URI[aarch64_rust-serde_json+unbounded_depth-devel.sha256sum] = "e658703f97532c53831217c981e2d421028e87944ab96afbf1ea2bf99c8af2e2"

URI_aarch64_rust-serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json-devel-1.0.151-1.el10_2.noarch.rpm;name=aarch64_rust-serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json-devel}"
SRC_URI[aarch64_rust-serde_json-devel.sha256sum] = "e9cf33da03e71a3a3ae5f365a4b61f9c0c80657cd1eceeac22754c1cab0cdcb2"

RDEPENDS:rust-serde_json+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+arbitrary_precision-devel = " \
 cargo \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+default-devel = " \
 cargo \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+float_roundtrip-devel = " \
 cargo \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+preserve_order-devel = " \
 cargo \
 rust-serde_json+indexmap-devel \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+raw_value-devel = " \
 cargo \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-serde_core+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+unbounded_depth-devel = " \
 cargo \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json-devel = " \
 cargo \
 rust \
 rust-itoa+default-devel \
 rust-memchr-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 rust-zmij+default-devel \
 "
