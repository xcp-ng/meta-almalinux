# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-icon-theme"
PV = "3.12.0"
PR = "25.el10_1"
PACKAGES = " \
 gnome-icon-theme \
 gnome-icon-theme-devel \
 gnome-icon-theme-legacy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-icon-theme-3.12.0-25.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74c69c7fb9e4337f84dd3ce357348a5d6337f34ccdcdefc7b17e1ac6c7ecc5a0"

URI_x86_64_v2_gnome-icon-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-icon-theme-3.12.0-25.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-icon-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-icon-theme}"
SRC_URI[x86_64_v2_gnome-icon-theme.sha256sum] = "5af287772432af934745da73fa04d57f61271649c78fce8579e711a2afa98462"

URI_x86_64_v2_gnome-icon-theme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-icon-theme-devel-3.12.0-25.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-icon-theme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-icon-theme-devel}"
SRC_URI[x86_64_v2_gnome-icon-theme-devel.sha256sum] = "45c243e8351ab2e1eadb5b2d95e7949461c378ba9c4b39a92e025713d2e1c353"

URI_x86_64_v2_gnome-icon-theme-legacy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-icon-theme-legacy-3.12.0-25.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-icon-theme-legacy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-icon-theme-legacy}"
SRC_URI[x86_64_v2_gnome-icon-theme-legacy.sha256sum] = "de84f280ad63ad7c1520c20a566d0e12eb563b0ead4880ae7f9a6d842f437428"

URI_aarch64_gnome-icon-theme = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-icon-theme-3.12.0-25.el10_1.noarch.rpm;name=aarch64_gnome-icon-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-icon-theme}"
SRC_URI[aarch64_gnome-icon-theme.sha256sum] = "6daf760612907b5978ac41444025f4fd952bb7e5b434dc3000b60b929b16a6c9"

URI_aarch64_gnome-icon-theme-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-icon-theme-devel-3.12.0-25.el10_1.noarch.rpm;name=aarch64_gnome-icon-theme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-icon-theme-devel}"
SRC_URI[aarch64_gnome-icon-theme-devel.sha256sum] = "0ef684dddc561b897f0201f7a86126ebe1e313138377cec0f0af5ff6686459ff"

URI_aarch64_gnome-icon-theme-legacy = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-icon-theme-legacy-3.12.0-25.el10_1.noarch.rpm;name=aarch64_gnome-icon-theme-legacy;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-icon-theme-legacy}"
SRC_URI[aarch64_gnome-icon-theme-legacy.sha256sum] = "2b77c632e504eacc0f8011f0d4bef4c60ea1941086db0d5a21f0a16ab111b786"

RDEPENDS:gnome-icon-theme = " \
 bash \
 hicolor-icon-theme \
 "
RDEPENDS:gnome-icon-theme-devel = " \
 gnome-icon-theme \
 pkgconf-pkg-config \
 "
RDEPENDS:gnome-icon-theme-legacy = " \
 gnome-icon-theme \
 "
