# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gshhg-gmt-nc4"
PV = "2.3.7"
PR = "11.el10_1"
PACKAGES = " \
 gshhg-gmt-nc4 \
 gshhg-gmt-nc4-full \
 gshhg-gmt-nc4-high \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gshhg-gmt-nc4-2.3.7-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6535856beb9cb55a8a9226dac949be3f2f88f4ced03ea203beec8b533ae549cf"

URI_x86_64_v2_gshhg-gmt-nc4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gshhg-gmt-nc4-2.3.7-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gshhg-gmt-nc4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gshhg-gmt-nc4}"
SRC_URI[x86_64_v2_gshhg-gmt-nc4.sha256sum] = "72c019d5c10d498e991a3ba16e337f5b3f688bcd0ce3a98fa6d1fb19313f4ec9"

URI_x86_64_v2_gshhg-gmt-nc4-full = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gshhg-gmt-nc4-full-2.3.7-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gshhg-gmt-nc4-full;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gshhg-gmt-nc4-full}"
SRC_URI[x86_64_v2_gshhg-gmt-nc4-full.sha256sum] = "9a6d1273ac82f97d21c03a0f8dc7f89fb578dd08e2a313fbadf6e21381ad579c"

URI_x86_64_v2_gshhg-gmt-nc4-high = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gshhg-gmt-nc4-high-2.3.7-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gshhg-gmt-nc4-high;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gshhg-gmt-nc4-high}"
SRC_URI[x86_64_v2_gshhg-gmt-nc4-high.sha256sum] = "4b9de1223ae29cb8e62d6b3f94c02202f932f52fae01bbc2d8c427c7c576d3ae"

URI_aarch64_gshhg-gmt-nc4 = "${EPEL_MIRROR}/aarch64/Packages/g/gshhg-gmt-nc4-2.3.7-11.el10_1.noarch.rpm;name=aarch64_gshhg-gmt-nc4;unpack=0"
SRC_URI:append = " ${URI_aarch64_gshhg-gmt-nc4}"
SRC_URI[aarch64_gshhg-gmt-nc4.sha256sum] = "c9bca608ff9915bb548b4d3f0638a12b07f25c1136dd5585556a4ed1df8d4c45"

URI_aarch64_gshhg-gmt-nc4-full = "${EPEL_MIRROR}/aarch64/Packages/g/gshhg-gmt-nc4-full-2.3.7-11.el10_1.noarch.rpm;name=aarch64_gshhg-gmt-nc4-full;unpack=0"
SRC_URI:append = " ${URI_aarch64_gshhg-gmt-nc4-full}"
SRC_URI[aarch64_gshhg-gmt-nc4-full.sha256sum] = "ba318e7514a08f0fc32dcae6a1addd7c99e10cf4bfae962f641124a927c510e7"

URI_aarch64_gshhg-gmt-nc4-high = "${EPEL_MIRROR}/aarch64/Packages/g/gshhg-gmt-nc4-high-2.3.7-11.el10_1.noarch.rpm;name=aarch64_gshhg-gmt-nc4-high;unpack=0"
SRC_URI:append = " ${URI_aarch64_gshhg-gmt-nc4-high}"
SRC_URI[aarch64_gshhg-gmt-nc4-high.sha256sum] = "11340386e23c0e952589594240802c89c02cb1a31114012c0ef2e57cd50db249"

RDEPENDS:gshhg-gmt-nc4 = " \
 "
RDEPENDS:gshhg-gmt-nc4-full = " \
 gshhg-gmt-nc4 \
 "
RDEPENDS:gshhg-gmt-nc4-high = " \
 gshhg-gmt-nc4 \
 "
