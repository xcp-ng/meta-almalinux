# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-kolo-xmlrpc"
PV = "0"
PR = "21.20210110git38db28d.el10_0"
PACKAGES = " \
 golang-github-kolo-xmlrpc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-kolo-xmlrpc-0-21.20210110git38db28d.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0762ac0eaa3a4c14718f8fe511c04ea2f3ecbd182d39a52a5a7b13ab1c5170e"

URI_aarch64_golang-github-kolo-xmlrpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-kolo-xmlrpc-devel-0-21.20210110git38db28d.el10_0.noarch.rpm;name=aarch64_golang-github-kolo-xmlrpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-kolo-xmlrpc-devel}"
SRC_URI[aarch64_golang-github-kolo-xmlrpc-devel.sha256sum] = "56219207da0e507d63fe925279d9cde67e5ed7743812e15f81af2873c55231c4"

RDEPENDS:golang-github-kolo-xmlrpc-devel = " \
 go-filesystem \
 "
