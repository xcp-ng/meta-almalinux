# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-syntax0.6"
PV = "0.6.29"
PR = "4.el10_0"
PACKAGES = " \
 rust-regex-syntax0.6+default-devel \
 rust-regex-syntax0.6+unicode-age-devel \
 rust-regex-syntax0.6+unicode-bool-devel \
 rust-regex-syntax0.6+unicode-case-devel \
 rust-regex-syntax0.6+unicode-devel \
 rust-regex-syntax0.6+unicode-gencat-devel \
 rust-regex-syntax0.6+unicode-perl-devel \
 rust-regex-syntax0.6+unicode-script-devel \
 rust-regex-syntax0.6+unicode-segment-devel \
 rust-regex-syntax0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-syntax0.6-0.6.29-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f2e898d7343eec902c8310ed333bd9b9bd457d137885b0305f0b36c38884871"

URI_x86_64_v2_rust-regex-syntax0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax0.6+default-devel-0.6.29-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax0.6+default-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax0.6+default-devel.sha256sum] = "0a8768da3eb7e9939c41a0a820ca38c9d6713ab02c57dc0649e71b4be70b57f3"

URI_x86_64_v2_rust-regex-syntax0.6+unicode-age-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax0.6+unicode-age-devel-0.6.29-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax0.6+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax0.6+unicode-age-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax0.6+unicode-age-devel.sha256sum] = "2e27eade1c1199cb98015d8391668085c1f00c6c301e0a167f597812dff4c27f"

URI_x86_64_v2_rust-regex-syntax0.6+unicode-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax0.6+unicode-bool-devel-0.6.29-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax0.6+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax0.6+unicode-bool-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax0.6+unicode-bool-devel.sha256sum] = "865f712f199b76e54d208c1be25d4c7a1a9f845e01538ce3c80503179ed96220"

URI_x86_64_v2_rust-regex-syntax0.6+unicode-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax0.6+unicode-case-devel-0.6.29-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax0.6+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax0.6+unicode-case-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax0.6+unicode-case-devel.sha256sum] = "b2bbc8a15bfce5311eb5d2ecc3a07bbc8a5579319b64f59e3af79cef29e70694"

URI_x86_64_v2_rust-regex-syntax0.6+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax0.6+unicode-devel-0.6.29-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax0.6+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax0.6+unicode-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax0.6+unicode-devel.sha256sum] = "b79c59f872ecaf2b887f87b3a260216ed23c308b2c93262d751c982148167b0a"

URI_x86_64_v2_rust-regex-syntax0.6+unicode-gencat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax0.6+unicode-gencat-devel-0.6.29-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax0.6+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax0.6+unicode-gencat-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax0.6+unicode-gencat-devel.sha256sum] = "e070e03b0fff03dc105293d8812e930f4a3c8327246a9fffef2ea691e6831d7e"

URI_x86_64_v2_rust-regex-syntax0.6+unicode-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax0.6+unicode-perl-devel-0.6.29-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax0.6+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax0.6+unicode-perl-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax0.6+unicode-perl-devel.sha256sum] = "b654205405744ed10e125e23149f6aa437e1c9e574d4775cf0130de981099623"

URI_x86_64_v2_rust-regex-syntax0.6+unicode-script-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax0.6+unicode-script-devel-0.6.29-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax0.6+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax0.6+unicode-script-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax0.6+unicode-script-devel.sha256sum] = "ffd4c4b46af7203757a05c757358081ecfefa7fedcb99870ed8509bb085de3d0"

URI_x86_64_v2_rust-regex-syntax0.6+unicode-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax0.6+unicode-segment-devel-0.6.29-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax0.6+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax0.6+unicode-segment-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax0.6+unicode-segment-devel.sha256sum] = "ce337c6af71c7a845077095f836b88e94011b8a51be6bda91c8494a12d1efc7e"

URI_x86_64_v2_rust-regex-syntax0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax0.6-devel-0.6.29-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax0.6-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax0.6-devel.sha256sum] = "5336f29f20a77bc5dac91ad9eccbee4be96c0a95ddf8f2eecaf1cee309fe6a99"

URI_aarch64_rust-regex-syntax0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax0.6+default-devel-0.6.29-4.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax0.6+default-devel}"
SRC_URI[aarch64_rust-regex-syntax0.6+default-devel.sha256sum] = "116a2ee50e8025f29b9c6f9b41f94e5317f8ec6939739ae29ca5cf3c32392bae"

URI_aarch64_rust-regex-syntax0.6+unicode-age-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax0.6+unicode-age-devel-0.6.29-4.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax0.6+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax0.6+unicode-age-devel}"
SRC_URI[aarch64_rust-regex-syntax0.6+unicode-age-devel.sha256sum] = "b69abd83bea288c1f19d61b8126ddfc6f72398f2026800733812c84888a2bf5c"

URI_aarch64_rust-regex-syntax0.6+unicode-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax0.6+unicode-bool-devel-0.6.29-4.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax0.6+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax0.6+unicode-bool-devel}"
SRC_URI[aarch64_rust-regex-syntax0.6+unicode-bool-devel.sha256sum] = "d193d4e0e45566026c3c982ad890b8154436ed8703c6350486e155f64b3a744c"

URI_aarch64_rust-regex-syntax0.6+unicode-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax0.6+unicode-case-devel-0.6.29-4.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax0.6+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax0.6+unicode-case-devel}"
SRC_URI[aarch64_rust-regex-syntax0.6+unicode-case-devel.sha256sum] = "a89cf799576cab1d84ea606732cea2dd3cce6a22c9be1f04812d5d35e5735c25"

URI_aarch64_rust-regex-syntax0.6+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax0.6+unicode-devel-0.6.29-4.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax0.6+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax0.6+unicode-devel}"
SRC_URI[aarch64_rust-regex-syntax0.6+unicode-devel.sha256sum] = "d4beccf3522ad40a7f4be4b817a6d39fb07600f5727daa323e0811c2e22df779"

URI_aarch64_rust-regex-syntax0.6+unicode-gencat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax0.6+unicode-gencat-devel-0.6.29-4.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax0.6+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax0.6+unicode-gencat-devel}"
SRC_URI[aarch64_rust-regex-syntax0.6+unicode-gencat-devel.sha256sum] = "600e3a8000e2144a4181fe8fb28ecf6319e65cd26237c16bcb1cc63b94d1e00a"

URI_aarch64_rust-regex-syntax0.6+unicode-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax0.6+unicode-perl-devel-0.6.29-4.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax0.6+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax0.6+unicode-perl-devel}"
SRC_URI[aarch64_rust-regex-syntax0.6+unicode-perl-devel.sha256sum] = "5c1f267b2d494f4bb294bc70c15e543c94d19d81106c88d069a4db63adb79fab"

URI_aarch64_rust-regex-syntax0.6+unicode-script-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax0.6+unicode-script-devel-0.6.29-4.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax0.6+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax0.6+unicode-script-devel}"
SRC_URI[aarch64_rust-regex-syntax0.6+unicode-script-devel.sha256sum] = "4a999f8f29c3a5a785b8596ca70017c69b3303abf4b11d86374c2751c1a3ba5e"

URI_aarch64_rust-regex-syntax0.6+unicode-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax0.6+unicode-segment-devel-0.6.29-4.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax0.6+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax0.6+unicode-segment-devel}"
SRC_URI[aarch64_rust-regex-syntax0.6+unicode-segment-devel.sha256sum] = "10bd5e5812ba68b8b6c9a7ec256907e1d1d9cabdee0d7a9063aa0a1bb7816c15"

URI_aarch64_rust-regex-syntax0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax0.6-devel-0.6.29-4.el10_0.noarch.rpm;name=aarch64_rust-regex-syntax0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax0.6-devel}"
SRC_URI[aarch64_rust-regex-syntax0.6-devel.sha256sum] = "7c7939aff49c959d6eae68c92425efd9695edea22984b629296a8129be73f404"

RDEPENDS:rust-regex-syntax0.6+default-devel = " \
 cargo \
 rust-regex-syntax0.6+unicode-devel \
 rust-regex-syntax0.6-devel \
 "
RDEPENDS:rust-regex-syntax0.6+unicode-age-devel = " \
 cargo \
 rust-regex-syntax0.6-devel \
 "
RDEPENDS:rust-regex-syntax0.6+unicode-bool-devel = " \
 cargo \
 rust-regex-syntax0.6-devel \
 "
RDEPENDS:rust-regex-syntax0.6+unicode-case-devel = " \
 cargo \
 rust-regex-syntax0.6-devel \
 "
RDEPENDS:rust-regex-syntax0.6+unicode-devel = " \
 cargo \
 rust-regex-syntax0.6+unicode-age-devel \
 rust-regex-syntax0.6+unicode-bool-devel \
 rust-regex-syntax0.6+unicode-case-devel \
 rust-regex-syntax0.6+unicode-gencat-devel \
 rust-regex-syntax0.6+unicode-perl-devel \
 rust-regex-syntax0.6+unicode-script-devel \
 rust-regex-syntax0.6+unicode-segment-devel \
 rust-regex-syntax0.6-devel \
 "
RDEPENDS:rust-regex-syntax0.6+unicode-gencat-devel = " \
 cargo \
 rust-regex-syntax0.6-devel \
 "
RDEPENDS:rust-regex-syntax0.6+unicode-perl-devel = " \
 cargo \
 rust-regex-syntax0.6-devel \
 "
RDEPENDS:rust-regex-syntax0.6+unicode-script-devel = " \
 cargo \
 rust-regex-syntax0.6-devel \
 "
RDEPENDS:rust-regex-syntax0.6+unicode-segment-devel = " \
 cargo \
 rust-regex-syntax0.6-devel \
 "
RDEPENDS:rust-regex-syntax0.6-devel = " \
 bash \
 cargo \
 "
