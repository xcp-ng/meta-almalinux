# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "meson"
PV = "1.4.1"
PR = "4.el10"
PACKAGES = " \
 meson \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/meson-1.4.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e150d00a07c4dacda3fb4289b7cd16ba89ec954a7406967ba920870a6e2e5b4"

URI_x86_64_v2_meson = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/meson-1.4.1-4.el10.noarch.rpm;name=x86_64_v2_meson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_meson}"
SRC_URI[x86_64_v2_meson.sha256sum] = "a7b81a7a8a7d54f1060683ac2fb9a7fbf32132a46590fc40bb62de07a432b448"

URI_aarch64_meson = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/meson-1.4.1-4.el10.noarch.rpm;name=aarch64_meson;unpack=0"
SRC_URI:append = " ${URI_aarch64_meson}"
SRC_URI[aarch64_meson.sha256sum] = "a7b81a7a8a7d54f1060683ac2fb9a7fbf32132a46590fc40bb62de07a432b448"

RDEPENDS:meson = " \
 ninja-build \
 python3 \
 python3-setuptools \
 "
