# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-theme-builder"
PV = "0.2.0"
PR = "0.17.b2.el10_1"
PACKAGES = " \
 python3-sphinx-theme-builder \
 python3-sphinx-theme-builder+cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-theme-builder-0.2.0-0.17.b2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a79412967fd979128bb66f341777adfddc5b16f4c74e5d3264f8631e6aed1c5e"

URI_x86_64_v2_python3-sphinx-theme-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-theme-builder-0.2.0-0.17.b2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-theme-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-theme-builder}"
SRC_URI[x86_64_v2_python3-sphinx-theme-builder.sha256sum] = "3742d3d5889956362d547e080c93f53ec6487c0ad29586d64e2cffed1d46ebc1"

URI_x86_64_v2_python3-sphinx-theme-builder+cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-theme-builder+cli-0.2.0-0.17.b2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-theme-builder+cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-theme-builder+cli}"
SRC_URI[x86_64_v2_python3-sphinx-theme-builder+cli.sha256sum] = "a3fbfe9e33c0c82551953ebff5c2960947389d52b1f12d8f9101cbe70e7aae2c"

URI_aarch64_python3-sphinx-theme-builder = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-theme-builder-0.2.0-0.17.b2.el10_1.noarch.rpm;name=aarch64_python3-sphinx-theme-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-theme-builder}"
SRC_URI[aarch64_python3-sphinx-theme-builder.sha256sum] = "10e632ccca031a110d10444e972501d0db7398884572a163410fab3d5142e0f7"

URI_aarch64_python3-sphinx-theme-builder+cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-theme-builder+cli-0.2.0-0.17.b2.el10_1.noarch.rpm;name=aarch64_python3-sphinx-theme-builder+cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-theme-builder+cli}"
SRC_URI[aarch64_python3-sphinx-theme-builder+cli.sha256sum] = "dc156d75cfbd8839eced3761665b74ee65baa7c44f1bedd52f18fd3ae56c03ae"

RDEPENDS:python3-sphinx-theme-builder = " \
 python3 \
 python3-nodeenv \
 python3-packaging \
 python3-pyproject-metadata \
 python3-rich \
 python3-setuptools \
 "
RDEPENDS:python3-sphinx-theme-builder+cli = " \
 python3 \
 python3-build \
 python3-click \
 python3-sphinx-autobuild \
 python3-sphinx-theme-builder \
 "
