# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yggdrasil"
PV = "0.4.10"
PR = "1.el10"
PACKAGES = " \
 yggdrasil \
 yggdrasil-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yggdrasil-0.4.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e02e432262af380ab30656c27d511149d5c8f4b64a4d3118cc04eecd473be2ff"

URI_x86_64_v2_yggdrasil = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yggdrasil-0.4.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_yggdrasil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yggdrasil}"
SRC_URI[x86_64_v2_yggdrasil.sha256sum] = "30b32e43ac73142a9bd0a4e0b0ea104bed8bcfe01c253d9c56d04d8c26bab3f9"

URI_x86_64_v2_yggdrasil-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/yggdrasil-devel-0.4.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_yggdrasil-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yggdrasil-devel}"
SRC_URI[x86_64_v2_yggdrasil-devel.sha256sum] = "9fee4350b1fedbca94c2142b05f9662ed6ed3891714ea5f49a196b7998cff826"

URI_aarch64_yggdrasil = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yggdrasil-0.4.10-1.el10.aarch64.rpm;name=aarch64_yggdrasil;unpack=0"
SRC_URI:append = " ${URI_aarch64_yggdrasil}"
SRC_URI[aarch64_yggdrasil.sha256sum] = "84ba2e0b1c459045845a6a16150fe9e97e38db5f71339f1c704b74bd4d5723cc"

URI_aarch64_yggdrasil-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/yggdrasil-devel-0.4.10-1.el10.aarch64.rpm;name=aarch64_yggdrasil-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yggdrasil-devel}"
SRC_URI[aarch64_yggdrasil-devel.sha256sum] = "4ec39d44625be95b49511a6e313cfed14ba928a67423e3aedba705f52e708724"

RDEPENDS:yggdrasil = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:yggdrasil-devel = " \
 pkgconf-pkg-config \
 "
