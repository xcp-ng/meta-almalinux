# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-freeipa"
PV = "1.16.0"
PR = "1.el10"
PACKAGES = " \
 ansible-freeipa \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-freeipa-1.16.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f0bb56dee6443366658eb96b925281c9df3412df21a9009573a0c026dbef210"

URI_x86_64_v2_ansible-freeipa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-freeipa-1.16.0-1.el10.noarch.rpm;name=x86_64_v2_ansible-freeipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-freeipa}"
SRC_URI[x86_64_v2_ansible-freeipa.sha256sum] = "a8e3e38c4ed82d512e8e257dde866cdfa94d226572456c173f280cc3f5b1f03c"

URI_aarch64_ansible-freeipa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-freeipa-1.16.0-1.el10.noarch.rpm;name=aarch64_ansible-freeipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-freeipa}"
SRC_URI[aarch64_ansible-freeipa.sha256sum] = "a8e3e38c4ed82d512e8e257dde866cdfa94d226572456c173f280cc3f5b1f03c"

RDEPENDS:ansible-freeipa = " \
 ansible-core \
 bash \
 python3 \
 "
