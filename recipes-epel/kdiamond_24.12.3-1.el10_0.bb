# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdiamond"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kdiamond \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdiamond-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56e856971c00b0410863a1f7945f185eee6e0ecca858b44e1a91740d58e04679"

URI_x86_64_v2_kdiamond = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdiamond-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdiamond;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdiamond}"
SRC_URI[x86_64_v2_kdiamond.sha256sum] = "c234a367dd08312605ed7b168b15ae31b31eeffe88cfbcc583148f9c978c5a89"

URI_aarch64_kdiamond = "${EPEL_MIRROR}/aarch64/Packages/k/kdiamond-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdiamond;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdiamond}"
SRC_URI[aarch64_kdiamond.sha256sum] = "66d9fe57762332314fd36f8ca334d38ae71a164551a7a419b197dcd833d72011"

RDEPENDS:kdiamond = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
