# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ptyxis"
PV = "47.13"
PR = "1.el10"
PACKAGES = " \
 ptyxis \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ptyxis-47.13-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3db7f57cd2274859410ff458e7d5f20e3dbd2ce57453c5aa3ec40367885ef348"

URI_x86_64_v2_ptyxis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ptyxis-47.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_ptyxis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptyxis}"
SRC_URI[x86_64_v2_ptyxis.sha256sum] = "245351129034733ab14f9c9dd06b8edee5f280b282de0714f4941dec715f978e"

URI_aarch64_ptyxis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ptyxis-47.13-1.el10.aarch64.rpm;name=aarch64_ptyxis;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptyxis}"
SRC_URI[aarch64_ptyxis.sha256sum] = "98d3ad7250bc5e2198bf032b2e1866312f811c47fc0f760154f0c6dfed54dcba"

RDEPENDS:ptyxis = " \
 glib2 \
 glibc \
 gtk4 \
 hicolor-icon-theme \
 json-glib \
 libadwaita \
 libgcc \
 libportal \
 libportal-gtk4 \
 pango \
 vte291-gtk4 \
 "
