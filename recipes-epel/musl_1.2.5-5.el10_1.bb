# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "musl"
PV = "1.2.5"
PR = "5.el10_1"
PACKAGES = " \
 musl-clang \
 musl-devel \
 musl-filesystem \
 musl-gcc \
 musl-libc \
 musl-libc-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/musl-1.2.5-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dae604c6fa4b3d13e671ab04a03c2581668bfc2c4a6ec96d269d789c8870fa67"

URI_x86_64_v2_musl-clang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-clang-1.2.5-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-clang}"
SRC_URI[x86_64_v2_musl-clang.sha256sum] = "a1e76a1a2950c978f6ba79e0afc6e08ed5f34762a2d925fdb3e5628f9e845064"

URI_x86_64_v2_musl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-devel-1.2.5-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-devel}"
SRC_URI[x86_64_v2_musl-devel.sha256sum] = "cd0d3abb609885d81ed2739bd833a441d8afc65e2414f5eae42bee53238dd6d3"

URI_x86_64_v2_musl-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-filesystem-1.2.5-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-filesystem}"
SRC_URI[x86_64_v2_musl-filesystem.sha256sum] = "c0b0670efee6066e96d8e4cdde28f84fdc30cf1664125e03c7929d3b0fff3363"

URI_x86_64_v2_musl-gcc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-gcc-1.2.5-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-gcc}"
SRC_URI[x86_64_v2_musl-gcc.sha256sum] = "86f7304a92bf626ef64f9f14c334e3684473c17d999884c5962ffe904acb19b3"

URI_x86_64_v2_musl-libc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-libc-1.2.5-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-libc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-libc}"
SRC_URI[x86_64_v2_musl-libc.sha256sum] = "58d91a51a07c27e27511aa615e4eabbf8f5229f3f242a0ea4267d9ff64499081"

URI_x86_64_v2_musl-libc-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-libc-static-1.2.5-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-libc-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-libc-static}"
SRC_URI[x86_64_v2_musl-libc-static.sha256sum] = "e00a2ae6d5bb58c5f400b73a47edba42d35e5e43825c6a1ac74a735d37665601"

URI_aarch64_musl-clang = "${EPEL_MIRROR}/aarch64/Packages/m/musl-clang-1.2.5-5.el10_1.aarch64.rpm;name=aarch64_musl-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-clang}"
SRC_URI[aarch64_musl-clang.sha256sum] = "608e9a4ed7d2aeb5803dea980659160dd265c67fe36b12ad16cf783c81ed163d"

URI_aarch64_musl-devel = "${EPEL_MIRROR}/aarch64/Packages/m/musl-devel-1.2.5-5.el10_1.aarch64.rpm;name=aarch64_musl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-devel}"
SRC_URI[aarch64_musl-devel.sha256sum] = "49e12c22309bb5317aaa94ee748e8d091d0742faa67034939459bdc9181e781f"

URI_aarch64_musl-filesystem = "${EPEL_MIRROR}/aarch64/Packages/m/musl-filesystem-1.2.5-5.el10_1.aarch64.rpm;name=aarch64_musl-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-filesystem}"
SRC_URI[aarch64_musl-filesystem.sha256sum] = "0b36d84eb2cff10548e6d62bf3f938ebbd036b34a72987051515c0efed53dfe5"

URI_aarch64_musl-gcc = "${EPEL_MIRROR}/aarch64/Packages/m/musl-gcc-1.2.5-5.el10_1.aarch64.rpm;name=aarch64_musl-gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-gcc}"
SRC_URI[aarch64_musl-gcc.sha256sum] = "3dd1df11fcb0ba8f9a62c78e3ce2f57f9144f0a822bc0794450add06536374e8"

URI_aarch64_musl-libc = "${EPEL_MIRROR}/aarch64/Packages/m/musl-libc-1.2.5-5.el10_1.aarch64.rpm;name=aarch64_musl-libc;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-libc}"
SRC_URI[aarch64_musl-libc.sha256sum] = "67a2a09c7a9c15d00ebb40d06a9aa36cba602edc5d4b53f564f66bb8f61e0400"

URI_aarch64_musl-libc-static = "${EPEL_MIRROR}/aarch64/Packages/m/musl-libc-static-1.2.5-5.el10_1.aarch64.rpm;name=aarch64_musl-libc-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-libc-static}"
SRC_URI[aarch64_musl-libc-static.sha256sum] = "002a26356aeef9238630234a0d614f151208034a0b70ef3da331ba276a7d6d91"

RDEPENDS:musl-clang = " \
 bash \
 clang \
 musl-devel \
 "
RDEPENDS:musl-devel = " \
 musl-libc \
 "
RDEPENDS:musl-filesystem = " \
 "
RDEPENDS:musl-gcc = " \
 bash \
 gcc \
 musl-devel \
 "
RDEPENDS:musl-libc = " \
 musl-filesystem \
 "
RDEPENDS:musl-libc-static = " \
 musl-devel \
 "
