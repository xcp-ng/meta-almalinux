# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-argos"
PV = "3^20250327git1326404"
PR = "3.el10_0"
PACKAGES = " \
 gnome-shell-extension-argos \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-shell-extension-argos-3^20250327git1326404-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02d05b68e3e9b79aa66f34976259ab798df8169bd9acd7a84f030b353b338e58"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - gnome-shell-extension-argos: (gnome-shell >= 45.0 with gnome-shell < 49.0)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - gnome-shell-extension-argos: (gnome-shell >= 45.0 with gnome-shell < 49.0)

URI_x86_64_v2_gnome-shell-extension-argos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-shell-extension-argos-3^20250327git1326404-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-shell-extension-argos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-argos}"
SRC_URI[x86_64_v2_gnome-shell-extension-argos.sha256sum] = "5b51bc766ff9de536d3094186666a9fc389d42e25464480280490ba39322c44f"

URI_aarch64_gnome-shell-extension-argos = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-shell-extension-argos-3^20250327git1326404-3.el10_0.noarch.rpm;name=aarch64_gnome-shell-extension-argos;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-argos}"
SRC_URI[aarch64_gnome-shell-extension-argos.sha256sum] = "52950fccc8f2f5e811f9d21180018b533c8ab8b97159936219615ad906877b79"

RDEPENDS:gnome-shell-extension-argos = " \
 xdg-terminal-exec \
 "
