# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cwd-Guard"
PV = "0.05"
PR = "21.el10_0"
PACKAGES = " \
 perl-Cwd-Guard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cwd-Guard-0.05-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d08f1b80f32387b419e1d88bbea3e088785ae6495372b0c9a8ce46af02bc26f"

URI_x86_64_v2_perl-Cwd-Guard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cwd-Guard-0.05-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Cwd-Guard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cwd-Guard}"
SRC_URI[x86_64_v2_perl-Cwd-Guard.sha256sum] = "62b2095466e88fd7b7487752cc22424b7f51ab1d1d233e9e4d7be34f2c8035ee"

URI_aarch64_perl-Cwd-Guard = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cwd-Guard-0.05-21.el10_0.noarch.rpm;name=aarch64_perl-Cwd-Guard;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cwd-Guard}"
SRC_URI[aarch64_perl-Cwd-Guard.sha256sum] = "72d72963241db5cd16291a0aadc1de366ff54e453edf500496236d24b71a4cd9"

RDEPENDS:perl-Cwd-Guard = " \
 perl-Exporter \
 perl-constant \
 perl-if \
 perl-libs \
 perl-parent \
 "
