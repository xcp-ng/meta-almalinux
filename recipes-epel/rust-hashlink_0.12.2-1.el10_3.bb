# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashlink"
PV = "0.12.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-hashlink+default-devel \
 rust-hashlink+serde-devel \
 rust-hashlink+serde_impl-devel \
 rust-hashlink-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hashlink-0.12.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "23f4885b362f7b3bc9419bacd0e583bc2671f1025ff20fcd2361e65840a59314"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+default-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashlink+default-devel.sha256sum] = "b746aaf6a8755214cc06dba9af53dec49b87901dabc4215b24334ae0e941d46b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+serde-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashlink+serde-devel.sha256sum] = "b7eff0b50ab27dcef755299862637990bd8637b6558f72f88f88f27cabc6543b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+serde_impl-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+serde_impl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashlink+serde_impl-devel.sha256sum] = "2e3cb235741d64f7c6e60ec613bcf30ae8892c1b6fc0d2ede47d2fc97c7e8b3e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashlink-devel.sha256sum] = "be49828c60ff76c49f0cdf20ad4812e89ece770d251a99f6764712b599903750"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+default-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-hashlink+default-devel;unpack=0"
SRC_URI[aarch64_rust-hashlink+default-devel.sha256sum] = "10b35045b545341933f478f777cd217e553f468d6608dd44a6bf6933f6d5d705"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+serde-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-hashlink+serde-devel;unpack=0"
SRC_URI[aarch64_rust-hashlink+serde-devel.sha256sum] = "0e9d51bff4763c6391b6dc8fc4f1b62fc945bddf14aeae75efc4579fb713a1c2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+serde_impl-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-hashlink+serde_impl-devel;unpack=0"
SRC_URI[aarch64_rust-hashlink+serde_impl-devel.sha256sum] = "df0607295118ebe8c98809c99234a1ed18e5465795db53b7b13df24eedb42830"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-hashlink-devel;unpack=0"
SRC_URI[aarch64_rust-hashlink-devel.sha256sum] = "3d4090e729fdf34eedf45269e7831fb7f7a9aaf6c0ff459f820a99e0e12dd256"

RDEPENDS:rust-hashlink+default-devel = " \
 cargo \
 rust-hashlink-devel \
 "
RDEPENDS:rust-hashlink+serde-devel = " \
 cargo \
 rust-hashlink-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hashlink+serde_impl-devel = " \
 cargo \
 rust-hashlink+serde-devel \
 rust-hashlink-devel \
 "
RDEPENDS:rust-hashlink-devel = " \
 cargo \
 rust \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown-devel \
 "
