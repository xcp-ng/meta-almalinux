# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-notify"
PV = "8.2.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-notify+crossbeam-channel-devel \
 rust-notify+default-devel \
 rust-notify+flume-devel \
 rust-notify+serde-devel \
 rust-notify+serialization-compat-6-devel \
 rust-notify-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-notify-8.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7e4fb05a585b107ab9310418383197f0ad1ebcd63fbb2fde50580a438e7eb49"

URI_x86_64_v2_rust-notify+crossbeam-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify+crossbeam-channel-devel-8.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify+crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify+crossbeam-channel-devel}"
SRC_URI[x86_64_v2_rust-notify+crossbeam-channel-devel.sha256sum] = "d98bfac18e0f57c429d627e1ba54cf8b8fd820a985ace0da0479dbe4af6d42d8"

URI_x86_64_v2_rust-notify+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify+default-devel-8.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify+default-devel}"
SRC_URI[x86_64_v2_rust-notify+default-devel.sha256sum] = "f184650602d9f0b2c6a1979a74a368182e07456ba4a6dbb8ba70ba7a5f8cb08b"

URI_x86_64_v2_rust-notify+flume-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify+flume-devel-8.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify+flume-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify+flume-devel}"
SRC_URI[x86_64_v2_rust-notify+flume-devel.sha256sum] = "08da787f1f75af61f0ab93f7bf24b3d1f0d6ba87f05b70a41d01496867551a5f"

URI_x86_64_v2_rust-notify+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify+serde-devel-8.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify+serde-devel}"
SRC_URI[x86_64_v2_rust-notify+serde-devel.sha256sum] = "0df57419802f11a831431a281830b244b38bd0cead54db36c63bc40600dfee2f"

URI_x86_64_v2_rust-notify+serialization-compat-6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify+serialization-compat-6-devel-8.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify+serialization-compat-6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify+serialization-compat-6-devel}"
SRC_URI[x86_64_v2_rust-notify+serialization-compat-6-devel.sha256sum] = "29d0c9f5b20272c6ee53fc9d3538c6d6f144791a2bd3a722ac9389349565e7ba"

URI_x86_64_v2_rust-notify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-devel-8.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-devel}"
SRC_URI[x86_64_v2_rust-notify-devel.sha256sum] = "c9e8c2eb70b63efab7f6658b9b8e3ff82993106fd4863a65f5cd833ef340de32"

URI_aarch64_rust-notify+crossbeam-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify+crossbeam-channel-devel-8.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-notify+crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify+crossbeam-channel-devel}"
SRC_URI[aarch64_rust-notify+crossbeam-channel-devel.sha256sum] = "3bbc7bce948d2058f2b80b07d5d41867e675911d13a4695973a90446fead6d31"

URI_aarch64_rust-notify+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify+default-devel-8.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-notify+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify+default-devel}"
SRC_URI[aarch64_rust-notify+default-devel.sha256sum] = "0511faec3494a28a5a791a71241e9b34b75b5e555242ebecfd8346a22607ed4a"

URI_aarch64_rust-notify+flume-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify+flume-devel-8.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-notify+flume-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify+flume-devel}"
SRC_URI[aarch64_rust-notify+flume-devel.sha256sum] = "a82b5758522c04a67204cfecd638559e5688e73fbd94db2195a2d9b4bb0a5be8"

URI_aarch64_rust-notify+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify+serde-devel-8.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-notify+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify+serde-devel}"
SRC_URI[aarch64_rust-notify+serde-devel.sha256sum] = "aaa336dd1d933b8a7be9afa3ff1dc99f24ce1b418ef0b256cdd9fbbf78af6a91"

URI_aarch64_rust-notify+serialization-compat-6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify+serialization-compat-6-devel-8.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-notify+serialization-compat-6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify+serialization-compat-6-devel}"
SRC_URI[aarch64_rust-notify+serialization-compat-6-devel.sha256sum] = "6012df832308c6bf0d02f8eceafdecdf2cd9ad92273752c7bd019b245e98ce34"

URI_aarch64_rust-notify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-devel-8.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-notify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-devel}"
SRC_URI[aarch64_rust-notify-devel.sha256sum] = "600995f672d6e0a60a41e95d3a37f23694933dac749f7771d698e18b495b0bf6"

RDEPENDS:rust-notify+crossbeam-channel-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-notify-devel \
 "
RDEPENDS:rust-notify+default-devel = " \
 cargo \
 rust-notify-devel \
 "
RDEPENDS:rust-notify+flume-devel = " \
 cargo \
 rust-flume+default-devel \
 rust-notify-devel \
 "
RDEPENDS:rust-notify+serde-devel = " \
 cargo \
 rust-notify-devel \
 rust-notify-types+serde-devel \
 "
RDEPENDS:rust-notify+serialization-compat-6-devel = " \
 cargo \
 rust-notify-devel \
 rust-notify-types+serialization-compat-6-devel \
 "
RDEPENDS:rust-notify-devel = " \
 cargo \
 rust \
 rust-inotify-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-mio+default-devel \
 rust-mio+os-ext-devel \
 rust-notify-types+default-devel \
 rust-walkdir+default-devel \
 "
