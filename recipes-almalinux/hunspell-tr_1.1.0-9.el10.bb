# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-tr"
PV = "1.1.0"
PR = "9.el10"
PACKAGES = " \
 hunspell-tr \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-tr-1.1.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66be106f33be59988872fdc48e98ff12d1e7eb5cecb46ad3c00855fc5ba56247"

URI_x86_64_v2_hunspell-tr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-tr-1.1.0-9.el10.noarch.rpm;name=x86_64_v2_hunspell-tr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-tr}"
SRC_URI[x86_64_v2_hunspell-tr.sha256sum] = "23c08db707525ccc369fe0a08a8a0a46fb6f53a75480cf5f504edb170239a8c1"

URI_aarch64_hunspell-tr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-tr-1.1.0-9.el10.noarch.rpm;name=aarch64_hunspell-tr;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-tr}"
SRC_URI[aarch64_hunspell-tr.sha256sum] = "23c08db707525ccc369fe0a08a8a0a46fb6f53a75480cf5f504edb170239a8c1"

RDEPENDS:hunspell-tr = " \
 hunspell-filesystem \
 "
