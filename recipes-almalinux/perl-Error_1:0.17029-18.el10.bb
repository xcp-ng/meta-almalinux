# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Error"
PE = "1"
PV = "0.17029"
PR = "18.el10"
PACKAGES = " \
 perl-Error \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Error-0.17029-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bffa29bb2a69fa2784a0a5683200a4cc8c2983460f2312559972ba175928d9a9"

URI_x86_64_v2_perl-Error = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Error-0.17029-18.el10.noarch.rpm;name=x86_64_v2_perl-Error;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Error}"
SRC_URI[x86_64_v2_perl-Error.sha256sum] = "a9e4f3346a6e8f4ff9b023039a50321727d3d6c11136de389e154ef3ed817f39"

URI_aarch64_perl-Error = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Error-0.17029-18.el10.noarch.rpm;name=aarch64_perl-Error;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Error}"
SRC_URI[aarch64_perl-Error.sha256sum] = "a9e4f3346a6e8f4ff9b023039a50321727d3d6c11136de389e154ef3ed817f39"

RDEPENDS:perl-Error = " \
 perl-Carp \
 perl-Error \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 perl-vars \
 "
