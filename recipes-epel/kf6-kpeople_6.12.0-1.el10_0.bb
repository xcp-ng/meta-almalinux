# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpeople"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kpeople \
 kf6-kpeople-devel \
 kf6-kpeople-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kpeople-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fa0672e7fc1f6919d345dda2104ca939f67c85539f8fe5c1bbeaf96f0884f95"

URI_x86_64_v2_kf6-kpeople = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpeople;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople}"
SRC_URI[x86_64_v2_kf6-kpeople.sha256sum] = "8d5fccfcfc35754de04a5225dfeb7ab62fb40674d6a5638a75c346c2c0712ce3"

URI_x86_64_v2_kf6-kpeople-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpeople-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople-devel}"
SRC_URI[x86_64_v2_kf6-kpeople-devel.sha256sum] = "14493486d0f000bb1dca5f83f9c53a6a9ca7e4745758bbbb450860a00e6c806e"

URI_x86_64_v2_kf6-kpeople-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpeople-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople-doc}"
SRC_URI[x86_64_v2_kf6-kpeople-doc.sha256sum] = "1b9d11869034c33c21ef5a7ebac7147154b4099fa08cea2b4ebb3f726451b5de"

URI_aarch64_kf6-kpeople = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kpeople;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople}"
SRC_URI[aarch64_kf6-kpeople.sha256sum] = "57f19f71ae4aa5d1d1763fa6f633c003e94fa8824c7fc3d2e302de8a523ddd9f"

URI_aarch64_kf6-kpeople-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kpeople-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople-devel}"
SRC_URI[aarch64_kf6-kpeople-devel.sha256sum] = "98b86f78687b388e9270b38a3116e7f3b70ff31c1c0c4674c07c4553a79698a5"

URI_aarch64_kf6-kpeople-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kpeople-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople-doc}"
SRC_URI[aarch64_kf6-kpeople-doc.sha256sum] = "502e1f022d9e57cd89d462b08328a66ff006d2a7a2c56490311aa0ca4f2cda88"

RDEPENDS:kf6-kpeople = " \
 glibc \
 kf6-filesystem \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kpeople-devel = " \
 cmake-filesystem \
 kf6-kpeople \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kpeople-doc = " \
 "
