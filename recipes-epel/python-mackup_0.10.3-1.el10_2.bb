# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mackup"
PV = "0.10.3"
PR = "1.el10_2"
PACKAGES = " \
 mackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mackup-0.10.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "722f97674a216cdf23224f8f597dbf784329cb3cd94979a2b2f480a98be89520"

URI_x86_64_v2_mackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mackup-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mackup}"
SRC_URI[x86_64_v2_mackup.sha256sum] = "e2cc018545c937182a8bbe19c0f036d58b849b0c7b20f9184eafd2fd601ae440"

URI_aarch64_mackup = "${EPEL_MIRROR}/aarch64/Packages/m/mackup-0.10.3-1.el10_2.noarch.rpm;name=aarch64_mackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_mackup}"
SRC_URI[aarch64_mackup.sha256sum] = "6b0e99635b054c3a56ac4a109f26a69f6d5f992d2180adda597a3a2e8c0d76bd"

RDEPENDS:mackup = " \
 procps-ng \
 python3 \
 python3-docopt-ng \
 "
