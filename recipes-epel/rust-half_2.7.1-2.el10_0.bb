# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-half"
PV = "2.7.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-half+alloc-devel \
 rust-half+arbitrary-devel \
 rust-half+bytemuck-devel \
 rust-half+default-devel \
 rust-half+num-traits-devel \
 rust-half+rand_distr-devel \
 rust-half+rkyv-devel \
 rust-half+serde-devel \
 rust-half+std-devel \
 rust-half+use-intrinsics-devel \
 rust-half+zerocopy-devel \
 rust-half-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-half-2.7.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cffa3093dc6715985ed015209bebfb2681c60476714fd41809d254388edf1334"

URI_x86_64_v2_rust-half+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+alloc-devel-2.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+alloc-devel}"
SRC_URI[x86_64_v2_rust-half+alloc-devel.sha256sum] = "b9f38c5067685d87e5c17d8aa6d711af3f59f2de3c4834f232bf6a4c96ce6b0b"

URI_x86_64_v2_rust-half+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+arbitrary-devel-2.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-half+arbitrary-devel.sha256sum] = "1a1facdc4abbf142e525d2503e7fa20ac5fba6756029c9abde85d0caae3d598b"

URI_x86_64_v2_rust-half+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+bytemuck-devel-2.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-half+bytemuck-devel.sha256sum] = "7887371215cab8d7ca516bfbd77d91be70e3367fead8ae54a6c0b7f69dadb281"

URI_x86_64_v2_rust-half+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+default-devel-2.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+default-devel}"
SRC_URI[x86_64_v2_rust-half+default-devel.sha256sum] = "b269aca5a0a1b7930320c0e54d97af78b1c69c6f463a8736c01912d0b314f31a"

URI_x86_64_v2_rust-half+num-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+num-traits-devel-2.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+num-traits-devel}"
SRC_URI[x86_64_v2_rust-half+num-traits-devel.sha256sum] = "c6fe17003d054ee58668a0dc5b389dec42219ca44b56a7360804c50dd76dc225"

URI_x86_64_v2_rust-half+rand_distr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+rand_distr-devel-2.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+rand_distr-devel}"
SRC_URI[x86_64_v2_rust-half+rand_distr-devel.sha256sum] = "517de579037010b38c927e4102f5e20ba7e35a1bbcd21100000480f5d7246cdd"

URI_x86_64_v2_rust-half+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+rkyv-devel-2.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+rkyv-devel}"
SRC_URI[x86_64_v2_rust-half+rkyv-devel.sha256sum] = "c73f01d86197b6e306d50a786db2b99b62705c66d75ea45230a434f22c85ba61"

URI_x86_64_v2_rust-half+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+serde-devel-2.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+serde-devel}"
SRC_URI[x86_64_v2_rust-half+serde-devel.sha256sum] = "449f628cbdaec086bc6dbc5cce55f33ff987d2e441f3e650375c360420390e0b"

URI_x86_64_v2_rust-half+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+std-devel-2.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+std-devel}"
SRC_URI[x86_64_v2_rust-half+std-devel.sha256sum] = "b53f8b40bfce6b2b998807a152b74589dc8e4882f99d8c0e9f2a7cb5432c6300"

URI_x86_64_v2_rust-half+use-intrinsics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+use-intrinsics-devel-2.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+use-intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+use-intrinsics-devel}"
SRC_URI[x86_64_v2_rust-half+use-intrinsics-devel.sha256sum] = "947e142208f9d514c6dda6f111589f8bb5710158c06bdfb6f9643ec3f7299ccc"

URI_x86_64_v2_rust-half+zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+zerocopy-devel-2.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+zerocopy-devel}"
SRC_URI[x86_64_v2_rust-half+zerocopy-devel.sha256sum] = "ccaf7ada6c3f5ed336d31448682ca6d801740844650f23cb0ce71e2e6ef4a04f"

URI_x86_64_v2_rust-half-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half-devel-2.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half-devel}"
SRC_URI[x86_64_v2_rust-half-devel.sha256sum] = "07e2d7f47f937d73195f3d9a7e288cfd3645c7600e72d60b555cb369dc5675a2"

URI_aarch64_rust-half+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+alloc-devel-2.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-half+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+alloc-devel}"
SRC_URI[aarch64_rust-half+alloc-devel.sha256sum] = "a958fcec8b1e6a6b4c4e87e145ca3a4acbb9367fb59f07c9884fb34f7b567975"

URI_aarch64_rust-half+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+arbitrary-devel-2.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-half+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+arbitrary-devel}"
SRC_URI[aarch64_rust-half+arbitrary-devel.sha256sum] = "ad8186af47ed3b02f7171a6dae1e50b75100653191b56a75321f662d0fc46c68"

URI_aarch64_rust-half+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+bytemuck-devel-2.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-half+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+bytemuck-devel}"
SRC_URI[aarch64_rust-half+bytemuck-devel.sha256sum] = "82d072ca77bbd01958ed8eed10b9d8c96a530acf87c8e9c2f83dcc665807d4b0"

URI_aarch64_rust-half+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+default-devel-2.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-half+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+default-devel}"
SRC_URI[aarch64_rust-half+default-devel.sha256sum] = "5fc279302744b3f73c8e381895ce04e55a27770f099683db200b9f1dfcce90df"

URI_aarch64_rust-half+num-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+num-traits-devel-2.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-half+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+num-traits-devel}"
SRC_URI[aarch64_rust-half+num-traits-devel.sha256sum] = "e1f666c792c3874a0e434aeedf27f2bf8a7a49594cab96771945f2162b6ce831"

URI_aarch64_rust-half+rand_distr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+rand_distr-devel-2.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-half+rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+rand_distr-devel}"
SRC_URI[aarch64_rust-half+rand_distr-devel.sha256sum] = "0c4e281498885e6dedb165796f6dbc02e2ff96e5f9517073ee086884889beedb"

URI_aarch64_rust-half+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+rkyv-devel-2.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-half+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+rkyv-devel}"
SRC_URI[aarch64_rust-half+rkyv-devel.sha256sum] = "a50a0727f534f5fec2c3fbde8a0b6a833da1a3ad8305ef1393ed8c262fb16da6"

URI_aarch64_rust-half+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+serde-devel-2.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-half+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+serde-devel}"
SRC_URI[aarch64_rust-half+serde-devel.sha256sum] = "5a7c7a5ea0a7eba3f8a61c2f9752326933a3bb34a365fee1b3bbd7cb819a68d5"

URI_aarch64_rust-half+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+std-devel-2.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-half+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+std-devel}"
SRC_URI[aarch64_rust-half+std-devel.sha256sum] = "cc9dd38e8b8853a72a602238fdafb8ed59662f24dfae293f542a8f55add8ed2b"

URI_aarch64_rust-half+use-intrinsics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+use-intrinsics-devel-2.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-half+use-intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+use-intrinsics-devel}"
SRC_URI[aarch64_rust-half+use-intrinsics-devel.sha256sum] = "cef93bfdddb757d81c4af882f39fef5d5467063e1ef069f197dc17b14662fcb1"

URI_aarch64_rust-half+zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+zerocopy-devel-2.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-half+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+zerocopy-devel}"
SRC_URI[aarch64_rust-half+zerocopy-devel.sha256sum] = "aad47a78c6fc9f423683f2908082de879c0e2492cf6e7716c6da3a143155f10d"

URI_aarch64_rust-half-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half-devel-2.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-half-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half-devel}"
SRC_URI[aarch64_rust-half-devel.sha256sum] = "4cfe48ddb4ddce5e6f4c8fd200301bfa86f31c3b9952e4701b27d363f9a6b70d"

RDEPENDS:rust-half+alloc-devel = " \
 cargo \
 rust-half-devel \
 "
RDEPENDS:rust-half+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-half-devel \
 "
RDEPENDS:rust-half+bytemuck-devel = " \
 cargo \
 rust-bytemuck+derive-devel \
 rust-bytemuck-devel \
 rust-half-devel \
 "
RDEPENDS:rust-half+default-devel = " \
 cargo \
 rust-half+std-devel \
 rust-half-devel \
 "
RDEPENDS:rust-half+num-traits-devel = " \
 cargo \
 rust-half-devel \
 rust-num-traits+libm-devel \
 rust-num-traits-devel \
 "
RDEPENDS:rust-half+rand_distr-devel = " \
 cargo \
 rust-half-devel \
 rust-rand+thread_rng-devel \
 rust-rand-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-half+rkyv-devel = " \
 cargo \
 rust-half-devel \
 rust-rkyv+default-devel \
 "
RDEPENDS:rust-half+serde-devel = " \
 cargo \
 rust-half-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-half+std-devel = " \
 cargo \
 rust-half+alloc-devel \
 rust-half-devel \
 "
RDEPENDS:rust-half+use-intrinsics-devel = " \
 cargo \
 rust-half-devel \
 "
RDEPENDS:rust-half+zerocopy-devel = " \
 cargo \
 rust-half-devel \
 "
RDEPENDS:rust-half-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy-devel \
 "
