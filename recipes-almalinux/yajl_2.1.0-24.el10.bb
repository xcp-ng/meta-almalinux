# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yajl"
PV = "2.1.0"
PR = "24.el10"
PACKAGES = " \
 yajl \
 yajl-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yajl-2.1.0-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97e5abdb06f7168c2c4d6c2aa8f19c62c4ddc66c5e588a004e8826874ea18042"

URI_x86_64_v2_yajl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yajl-2.1.0-24.el10.x86_64_v2.rpm;name=x86_64_v2_yajl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yajl}"
SRC_URI[x86_64_v2_yajl.sha256sum] = "b987d051a71f81fa8f9c9a7779da10141378bcbc210dbccba87bc827aceb656f"

URI_x86_64_v2_yajl-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/yajl-devel-2.1.0-24.el10.x86_64_v2.rpm;name=x86_64_v2_yajl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yajl-devel}"
SRC_URI[x86_64_v2_yajl-devel.sha256sum] = "e92badbb93afd3a57d90076a6e35d2932fd09987b8f48eeeb0ffa013a11cff21"

URI_aarch64_yajl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yajl-2.1.0-24.el10.aarch64.rpm;name=aarch64_yajl;unpack=0"
SRC_URI:append = " ${URI_aarch64_yajl}"
SRC_URI[aarch64_yajl.sha256sum] = "3a48f6247e9680a0146b1da3bd1bc2706dd524d61038bef43e1580d2c3474114"

URI_aarch64_yajl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/yajl-devel-2.1.0-24.el10.aarch64.rpm;name=aarch64_yajl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yajl-devel}"
SRC_URI[aarch64_yajl-devel.sha256sum] = "125d65de707613b3c323a642d128970dccc21e515ec2a45d4be65bd17c7fbbda"

RDEPENDS:yajl = " \
 glibc \
 "
RDEPENDS:yajl-devel = " \
 pkgconf-pkg-config \
 yajl \
 "
