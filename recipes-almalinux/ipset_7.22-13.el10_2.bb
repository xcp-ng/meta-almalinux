# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipset"
PV = "7.22"
PR = "13.el10_2"
PACKAGES = " \
 ipset \
 ipset-devel \
 ipset-libs \
 ipset-service \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ipset-7.22-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f131a02e2e68112ad70c8369b3120042604d94db63d75db3327b28a158ff495e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ipset-7.22-13.el10_2.x86_64_v2.rpm;name=x86_64_v2_ipset;unpack=0"
SRC_URI[x86_64_v2_ipset.sha256sum] = "93dbd093288114399ed3ec2a4c12efb5ba7e16efe4003d50106be9ceeae29b9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ipset-devel-7.22-13.el10_2.x86_64_v2.rpm;name=x86_64_v2_ipset-devel;unpack=0"
SRC_URI[x86_64_v2_ipset-devel.sha256sum] = "6347ea99c5e4ebc466241d0596fc6cc4c2a71609bd542ebfecf9ec4b2888b855"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ipset-libs-7.22-13.el10_2.x86_64_v2.rpm;name=x86_64_v2_ipset-libs;unpack=0"
SRC_URI[x86_64_v2_ipset-libs.sha256sum] = "088c998752bcf4d71b76783c24bc8e2ede45450125b2b2d996d73fcfc0b78678"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipset-service-7.22-13.el10_2.noarch.rpm;name=x86_64_v2_ipset-service;unpack=0"
SRC_URI[x86_64_v2_ipset-service.sha256sum] = "eb5184175175a22ea3ae5f23c061318cab7154d5b701e5218e5bd8789d876af2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ipset-7.22-13.el10_2.aarch64.rpm;name=aarch64_ipset;unpack=0"
SRC_URI[aarch64_ipset.sha256sum] = "4716fe090c3365571ac99bd00a338b38978fa10d55723615840fd4bd36ce0cca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ipset-devel-7.22-13.el10_2.aarch64.rpm;name=aarch64_ipset-devel;unpack=0"
SRC_URI[aarch64_ipset-devel.sha256sum] = "c044dba2407d48ec2481acb4c16942c661f16293da3a72226af81e8badf6decf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ipset-libs-7.22-13.el10_2.aarch64.rpm;name=aarch64_ipset-libs;unpack=0"
SRC_URI[aarch64_ipset-libs.sha256sum] = "3d28f3b55eb01c0b36035d34f9437d5491a13ba120ac57c14432bcf7d49508db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipset-service-7.22-13.el10_2.noarch.rpm;name=aarch64_ipset-service;unpack=0"
SRC_URI[aarch64_ipset-service.sha256sum] = "eb5184175175a22ea3ae5f23c061318cab7154d5b701e5218e5bd8789d876af2"

RDEPENDS:ipset = " \
 bash \
 glibc \
 ipset-libs \
 "
RDEPENDS:ipset-devel = " \
 ipset-libs \
 kernel-headers \
 libmnl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:ipset-libs = " \
 glibc \
 libmnl \
 "
RDEPENDS:ipset-service = " \
 bash \
 ipset \
 iptables-nft-services \
 systemd \
 "
