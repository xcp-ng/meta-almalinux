# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iputils"
PV = "20240905"
PR = "4.el10"
PACKAGES = " \
 iputils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iputils-20240905-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2be3bacb33a54ba5e85af29cedb7888fafcbd8fe852a54dde7e82fb01db3a0a2"

URI_x86_64_v2_iputils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iputils-20240905-4.el10.x86_64_v2.rpm;name=x86_64_v2_iputils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iputils}"
SRC_URI[x86_64_v2_iputils.sha256sum] = "dc88c2fb14c7fda2779ebca039d8ca11904c32eb4b9932a7b332be4c81a45f8a"

URI_aarch64_iputils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iputils-20240905-4.el10.aarch64.rpm;name=aarch64_iputils;unpack=0"
SRC_URI:append = " ${URI_aarch64_iputils}"
SRC_URI[aarch64_iputils.sha256sum] = "8596e04daa4aab9e9dee9935054f21744f03d7c59725dae2b7f91eea37fe1478"

RDEPENDS:iputils = " \
 glibc \
 libcap \
 libidn2 \
 "
