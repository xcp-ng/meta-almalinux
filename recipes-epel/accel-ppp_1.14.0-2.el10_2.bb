# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "accel-ppp"
PV = "1.14.0"
PR = "2.el10_2"
PACKAGES = " \
 accel-ppp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/accel-ppp-1.14.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5994416810aad4404cf93ee426505921a46cb0bbf2ddae067765445ea037c4c6"

URI_x86_64_v2_accel-ppp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/accel-ppp-1.14.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_accel-ppp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accel-ppp}"
SRC_URI[x86_64_v2_accel-ppp.sha256sum] = "ea1f3fe10e96e26914a6686603f8604478e8c94175d9e6c137c2cf679a12cd1f"

URI_aarch64_accel-ppp = "${EPEL_MIRROR}/aarch64/Packages/a/accel-ppp-1.14.0-2.el10_2.aarch64.rpm;name=aarch64_accel-ppp;unpack=0"
SRC_URI:append = " ${URI_aarch64_accel-ppp}"
SRC_URI[aarch64_accel-ppp.sha256sum] = "9e20d15f7c5ea19676cdc36e3e7969d44aba6e23fa7fc927c529a38d41e67814"

RDEPENDS:accel-ppp = " \
 bash \
 glibc \
 openssl-libs \
 pcre2 \
 "
