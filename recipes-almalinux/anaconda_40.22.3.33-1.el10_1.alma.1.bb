# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "anaconda"
PV = "40.22.3.33"
PR = "1.el10_1.alma.1"
PACKAGES = " \
 anaconda \
 anaconda-core \
 anaconda-dracut \
 anaconda-gui \
 anaconda-install-env-deps \
 anaconda-install-img-deps \
 anaconda-tui \
 anaconda-widgets \
 anaconda-widgets-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/anaconda-40.22.3.33-1.el10_1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2dd7a41514b12838f4a7a33b887232210eaf48832cf0f8553443110924f2126e"

URI_x86_64_v2_anaconda = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-40.22.3.33-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda}"
SRC_URI[x86_64_v2_anaconda.sha256sum] = "62c5315dc6f9c24426f6c3f4818ed35d47e1722a67c1dae3e90c0b1b61cd8a6e"

URI_x86_64_v2_anaconda-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-core-40.22.3.33-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-core}"
SRC_URI[x86_64_v2_anaconda-core.sha256sum] = "57a7b96d40222de55949c8cb7480dda874e386ecb7e123ad434887b1ab43d546"

URI_x86_64_v2_anaconda-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-dracut-40.22.3.33-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-dracut}"
SRC_URI[x86_64_v2_anaconda-dracut.sha256sum] = "e0edef91d55e603aca82f5148d5e1074b9ee71110ea644bfc31553888a0ca9ab"

URI_x86_64_v2_anaconda-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-gui-40.22.3.33-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-gui}"
SRC_URI[x86_64_v2_anaconda-gui.sha256sum] = "94ac288f895bdbaf4661391c949f72e769ea507d39c52f54207c292ab79da57b"

URI_x86_64_v2_anaconda-install-env-deps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-install-env-deps-40.22.3.33-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-install-env-deps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-install-env-deps}"
SRC_URI[x86_64_v2_anaconda-install-env-deps.sha256sum] = "b4058bcbfc3807bcb95e650f8d8c87e70ab2d76da8965192a4208cf604bd13b2"

URI_x86_64_v2_anaconda-install-img-deps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-install-img-deps-40.22.3.33-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-install-img-deps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-install-img-deps}"
SRC_URI[x86_64_v2_anaconda-install-img-deps.sha256sum] = "a8054cc5c73d346d71292540fb856ea50de4bd90c3ae953793e8c2381cf223ad"

URI_x86_64_v2_anaconda-tui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-tui-40.22.3.33-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-tui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-tui}"
SRC_URI[x86_64_v2_anaconda-tui.sha256sum] = "5da8cb57615cef7b892a4b923d07752bea859f287a192457ea9e2ad7dd3e1ffe"

URI_x86_64_v2_anaconda-widgets = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-widgets-40.22.3.33-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-widgets}"
SRC_URI[x86_64_v2_anaconda-widgets.sha256sum] = "8eea73fbf49840b044f7bb96913e97331cfc50aeea0522fa2ecc55631a8f99f5"

URI_x86_64_v2_anaconda-widgets-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/anaconda-widgets-devel-40.22.3.33-1.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-widgets-devel}"
SRC_URI[x86_64_v2_anaconda-widgets-devel.sha256sum] = "a81d15f076d1a6bcd9a07a1117a70a705895b6bdf851ef2e0283a732fc48d4e4"

URI_aarch64_anaconda = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-40.22.3.33-1.el10_1.alma.1.aarch64.rpm;name=aarch64_anaconda;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda}"
SRC_URI[aarch64_anaconda.sha256sum] = "e4baf87616067adc9adb7d24cb66e20ed81b0db632f6788abe1c7e0d033e449e"

URI_aarch64_anaconda-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-core-40.22.3.33-1.el10_1.alma.1.aarch64.rpm;name=aarch64_anaconda-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-core}"
SRC_URI[aarch64_anaconda-core.sha256sum] = "6220417059292eaa0c37f927cd60c7d3a98cd212ccc42309e55cfb4070fad61e"

URI_aarch64_anaconda-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-dracut-40.22.3.33-1.el10_1.alma.1.aarch64.rpm;name=aarch64_anaconda-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-dracut}"
SRC_URI[aarch64_anaconda-dracut.sha256sum] = "d84b57407439a2f8858934968dc131dadb8daedd979fbd7be133d382a383a6b2"

URI_aarch64_anaconda-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-gui-40.22.3.33-1.el10_1.alma.1.aarch64.rpm;name=aarch64_anaconda-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-gui}"
SRC_URI[aarch64_anaconda-gui.sha256sum] = "b4bc7b06a90e255fed3b5f717e6c4497b0a6b688522bab89e76f92d4b1002ae0"

URI_aarch64_anaconda-install-env-deps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-install-env-deps-40.22.3.33-1.el10_1.alma.1.aarch64.rpm;name=aarch64_anaconda-install-env-deps;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-install-env-deps}"
SRC_URI[aarch64_anaconda-install-env-deps.sha256sum] = "cf63efb713f2e19c93e84956f3fd813b9e34746eea85972801a2619e08826a46"

URI_aarch64_anaconda-install-img-deps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-install-img-deps-40.22.3.33-1.el10_1.alma.1.aarch64.rpm;name=aarch64_anaconda-install-img-deps;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-install-img-deps}"
SRC_URI[aarch64_anaconda-install-img-deps.sha256sum] = "68a43aeefbb20ca9f48b3239c1610cf5fc3a76bff86430a5ececb15708fbf3de"

URI_aarch64_anaconda-tui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-tui-40.22.3.33-1.el10_1.alma.1.aarch64.rpm;name=aarch64_anaconda-tui;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-tui}"
SRC_URI[aarch64_anaconda-tui.sha256sum] = "637783573ff2b9900bca3b264497a516330565a3eca05708d81ef97e1bfe79bb"

URI_aarch64_anaconda-widgets = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-widgets-40.22.3.33-1.el10_1.alma.1.aarch64.rpm;name=aarch64_anaconda-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-widgets}"
SRC_URI[aarch64_anaconda-widgets.sha256sum] = "b89a2ad6acff630f6e78ccc8b5e57d2182cfdce97a546dfb78b47f09329c07a9"

URI_aarch64_anaconda-widgets-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/anaconda-widgets-devel-40.22.3.33-1.el10_1.alma.1.aarch64.rpm;name=aarch64_anaconda-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-widgets-devel}"
SRC_URI[aarch64_anaconda-widgets-devel.sha256sum] = "72c6d0569ff88ca5d7639ebe7dc492378c6170a502fbd55c3103c1136b6b8273"

RDEPENDS:anaconda = " \
 anaconda-gui \
 anaconda-tui \
 "
RDEPENDS:anaconda-core = " \
 NetworkManager \
 NetworkManager-libnm \
 anaconda-tui \
 bash \
 chrony \
 cracklib-dicts \
 crypto-policies \
 crypto-policies-scripts \
 dbus-daemon \
 flatpak \
 flatpak-libs \
 kbd \
 python3 \
 python3-blivet \
 python3-blockdev \
 python3-dasbus \
 python3-dnf \
 python3-gobject-base \
 python3-kickstart \
 python3-langtable \
 python3-libs \
 python3-libselinux \
 python3-meh \
 python3-pid \
 python3-productmd \
 python3-pwquality \
 python3-pyparted \
 python3-requests \
 python3-requests-file \
 python3-requests-ftp \
 python3-rpm \
 python3-systemd \
 systemd \
 util-linux \
 virtual//usr/bin/date \
 virtual/glibc-langpack-en_or_glibc-all-langpacks \
 "
RDEPENDS:anaconda-dracut = " \
 bash \
 dnsconfd \
 dnsconfd-dracut \
 dracut \
 dracut-live \
 dracut-network \
 glibc \
 iputils \
 libarchive \
 python3 \
 python3-kickstart \
 rpm-libs \
 xz \
 "
RDEPENDS:anaconda-gui = " \
 NetworkManager-wifi \
 adwaita-icon-theme \
 almalinux-logos \
 anaconda-core \
 anaconda-widgets \
 nm-connection-editor \
 python3 \
 python3-iso639 \
 python3-meh-gui \
 python3-xkbregistry \
 tecla \
 "
RDEPENDS:anaconda-install-env-deps = " \
 dosfstools \
 e2fsprogs \
 gdb \
 isomd5sum \
 kexec-tools \
 libblockdev-plugins-all \
 realmd \
 rsync \
 tmux \
 udisks2-iscsi \
 xfsprogs \
 "
RDEPENDS:anaconda-install-img-deps:x86_64_v2 = " \
 anaconda-install-env-deps \
 brltty \
 createrepo_c \
 device-mapper-multipath \
 dnsconfd \
 dnsconfd-dracut \
 fcoe-utils \
 gnome-kiosk \
 gnome-remote-desktop \
 gsettings-desktop-schemas \
 kdump-anaconda-addon \
 librsvg2 \
 mesa-dri-drivers \
 nm-connection-editor \
 nvme-cli \
 openssl \
 ostree \
 python3-pam \
 rpm-ostree \
 skopeo \
 zram-generator \
"
RDEPENDS:anaconda-install-img-deps:aarch64 = " \
 anaconda-install-env-deps \
 brltty \
 createrepo_c \
 device-mapper-multipath \
 dnsconfd \
 dnsconfd-dracut \
 gnome-kiosk \
 gnome-remote-desktop \
 gsettings-desktop-schemas \
 kdump-anaconda-addon \
 librsvg2 \
 mesa-dri-drivers \
 nm-connection-editor \
 nvme-cli \
 openssl \
 ostree \
 python3-pam \
 rpm-ostree \
 skopeo \
 zram-generator \
"
RDEPENDS:anaconda-tui = " \
 anaconda-core \
 python3 \
 python3-simpleline \
 "
RDEPENDS:anaconda-widgets = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libgcc \
 pango \
 python3 \
 "
RDEPENDS:anaconda-widgets-devel = " \
 anaconda-widgets \
 "
