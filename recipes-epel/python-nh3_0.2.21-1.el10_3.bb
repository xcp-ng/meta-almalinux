# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nh3"
PV = "0.2.21"
PR = "1.el10_3"
PACKAGES = " \
 python3-nh3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-nh3-0.2.21-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d8ff91af49a00115ee9907690624f971683db2d99e9c95e02cf225d384367bd"

URI_aarch64_python3-nh3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nh3-0.2.21-1.el10_3.aarch64.rpm;name=aarch64_python3-nh3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nh3}"
SRC_URI[aarch64_python3-nh3.sha256sum] = "2d00cc91507ab7bae011bb677ba7102ff08f01d7fc369ad1306aa7dfae3b4e94"

RDEPENDS:python3-nh3 = " \
 glibc \
 libgcc \
 python3 \
 "
