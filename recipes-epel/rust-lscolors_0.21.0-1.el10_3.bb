# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lscolors"
PV = "0.21.0"
PR = "1.el10_3"
PACKAGES = " \
 lscolors \
 rust-lscolors+ansi_term-devel \
 rust-lscolors+crossterm-devel \
 rust-lscolors+default-devel \
 rust-lscolors+gnu_legacy-devel \
 rust-lscolors+nu-ansi-term-devel \
 rust-lscolors+owo-colors-devel \
 rust-lscolors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lscolors-0.21.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6653a0a7f95681ebe26079ceb3e498289d390cb98f9345c38a9dd83c76685df"

URI_x86_64_v2_lscolors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lscolors-0.21.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lscolors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lscolors}"
SRC_URI[x86_64_v2_lscolors.sha256sum] = "a8ae3fe53dbed268f7801bcc4b0ab12d4971b6abd7dd8bf2f062fd7424269461"

URI_x86_64_v2_rust-lscolors+ansi_term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+ansi_term-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+ansi_term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+ansi_term-devel}"
SRC_URI[x86_64_v2_rust-lscolors+ansi_term-devel.sha256sum] = "570ac120a5fd3c07a65e29ea22d73c159349ff89e54d108772b2df69f037a1fd"

URI_x86_64_v2_rust-lscolors+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+crossterm-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+crossterm-devel}"
SRC_URI[x86_64_v2_rust-lscolors+crossterm-devel.sha256sum] = "ad035e0e61bc6a22dd45962ae1ff151d06cc3f595b38d34c325918e9daccec0b"

URI_x86_64_v2_rust-lscolors+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+default-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+default-devel}"
SRC_URI[x86_64_v2_rust-lscolors+default-devel.sha256sum] = "6beb6c8018dfac142dcc331f9ec221907540cb234e2e871325cc1ff7660b1a2c"

URI_x86_64_v2_rust-lscolors+gnu_legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+gnu_legacy-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+gnu_legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+gnu_legacy-devel}"
SRC_URI[x86_64_v2_rust-lscolors+gnu_legacy-devel.sha256sum] = "df2ec1b598dbb34285a9c90f9b8841866c2116edcf9f5650b5d0aa2a1548d7a3"

URI_x86_64_v2_rust-lscolors+nu-ansi-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+nu-ansi-term-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+nu-ansi-term-devel}"
SRC_URI[x86_64_v2_rust-lscolors+nu-ansi-term-devel.sha256sum] = "e2ae3a8d2b1c09498b86e45b1e67f8095caf3d7ef39400a196a226fda3a96578"

URI_x86_64_v2_rust-lscolors+owo-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+owo-colors-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+owo-colors-devel}"
SRC_URI[x86_64_v2_rust-lscolors+owo-colors-devel.sha256sum] = "dcf7b4ea6bcb781c0e3267bce7b08b5acae90d03092300d92c9f7f3205b05bb6"

URI_x86_64_v2_rust-lscolors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors-devel-0.21.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors-devel}"
SRC_URI[x86_64_v2_rust-lscolors-devel.sha256sum] = "9935182e1fe2bf7d6cb9846d61063479121e374d544c36da3d4db966440f1937"

URI_aarch64_lscolors = "${EPEL_MIRROR}/aarch64/Packages/l/lscolors-0.21.0-1.el10_3.aarch64.rpm;name=aarch64_lscolors;unpack=0"
SRC_URI:append = " ${URI_aarch64_lscolors}"
SRC_URI[aarch64_lscolors.sha256sum] = "7cd5e039bbc12fe166736ac7c3f40d31d0628397546ef6602519b083bb6823ed"

URI_aarch64_rust-lscolors+ansi_term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+ansi_term-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-lscolors+ansi_term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+ansi_term-devel}"
SRC_URI[aarch64_rust-lscolors+ansi_term-devel.sha256sum] = "933e8a3e765dbb6b69992337dcf1609be0164a9661590d9ed89282713ba6eea3"

URI_aarch64_rust-lscolors+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+crossterm-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-lscolors+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+crossterm-devel}"
SRC_URI[aarch64_rust-lscolors+crossterm-devel.sha256sum] = "e0a691c4eee437e2c0ab3575225bdd6f22c9ccfcdbc7b76ac91697c01c1dcf0f"

URI_aarch64_rust-lscolors+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+default-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-lscolors+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+default-devel}"
SRC_URI[aarch64_rust-lscolors+default-devel.sha256sum] = "3b1945b5043cfbc9683620cd9eddfbb4d15f3fc91f85184897ad3811a2c410c3"

URI_aarch64_rust-lscolors+gnu_legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+gnu_legacy-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-lscolors+gnu_legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+gnu_legacy-devel}"
SRC_URI[aarch64_rust-lscolors+gnu_legacy-devel.sha256sum] = "24661d0e0294573130fdaaf90ae22a805441ee264eccb068619e24f64d37b2d6"

URI_aarch64_rust-lscolors+nu-ansi-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+nu-ansi-term-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-lscolors+nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+nu-ansi-term-devel}"
SRC_URI[aarch64_rust-lscolors+nu-ansi-term-devel.sha256sum] = "a990a313260fda7c6b44794d29551dff2085d1b322def48f942a2d662cdfb519"

URI_aarch64_rust-lscolors+owo-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+owo-colors-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-lscolors+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+owo-colors-devel}"
SRC_URI[aarch64_rust-lscolors+owo-colors-devel.sha256sum] = "cc66dfa78abd32eadd559b8ce65d4223e2ff49aaefa1d378c57e40665f98b181"

URI_aarch64_rust-lscolors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors-devel-0.21.0-1.el10_3.noarch.rpm;name=aarch64_rust-lscolors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors-devel}"
SRC_URI[aarch64_rust-lscolors-devel.sha256sum] = "557829071eba88154b7e3cbc9d64bb2babbc93596007999af2d90ea9651f73dc"

RDEPENDS:lscolors = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-lscolors+ansi_term-devel = " \
 cargo \
 rust-ansi_term+default-devel \
 rust-lscolors-devel \
 "
RDEPENDS:rust-lscolors+crossterm-devel = " \
 cargo \
 rust-crossterm+default-devel \
 rust-lscolors-devel \
 "
RDEPENDS:rust-lscolors+default-devel = " \
 cargo \
 rust-lscolors+nu-ansi-term-devel \
 rust-lscolors-devel \
 "
RDEPENDS:rust-lscolors+gnu_legacy-devel = " \
 cargo \
 rust-lscolors-devel \
 rust-nu-ansi-term+default-devel \
 rust-nu-ansi-term+gnu_legacy-devel \
 "
RDEPENDS:rust-lscolors+nu-ansi-term-devel = " \
 cargo \
 rust-lscolors-devel \
 rust-nu-ansi-term+default-devel \
 "
RDEPENDS:rust-lscolors+owo-colors-devel = " \
 cargo \
 rust-lscolors-devel \
 rust-owo-colors+default-devel \
 "
RDEPENDS:rust-lscolors-devel = " \
 cargo \
 rust \
 rust-aho-corasick+default-devel \
 "
