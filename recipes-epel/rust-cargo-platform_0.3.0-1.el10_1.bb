# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-platform"
PV = "0.3.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-cargo-platform+default-devel \
 rust-cargo-platform-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-platform-0.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "34c990cd5ab0228b1826550e1c0f0cb689ce7e612160020bf72c99711844a17a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-platform+default-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-platform+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-platform+default-devel.sha256sum] = "214ba6029c28ad00c678501fc5f9d806515750f7c3e2e2ce8e4e4170e96c229f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-platform-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-platform-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-platform-devel.sha256sum] = "74d971f2bc30e0ca51720adcec05ca00d108bc50a9db18c1d39b1d7bcd339ad2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-platform+default-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-platform+default-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-platform+default-devel.sha256sum] = "eff19887fc30e851a2d9344b0c7b846dd529b377824d195da2c3fb8cfa1de18a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-platform-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-platform-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-platform-devel.sha256sum] = "8e54e43cde44f0016d6e19aa4621b69692996089f9d0d1fc4290ff5943d404de"

RDEPENDS:rust-cargo-platform+default-devel = " \
 cargo \
 rust-cargo-platform-devel \
 "
RDEPENDS:rust-cargo-platform-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 "
