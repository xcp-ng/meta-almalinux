# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-ruby"
PV = "0.23.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree-sitter-ruby+default-devel \
 rust-tree-sitter-ruby-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-ruby-0.23.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99504319cf012eb143eb72cd2f444f0e02ce8c9652c2d8a51a1b677728367608"

URI_x86_64_v2_rust-tree-sitter-ruby+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ruby+default-devel-0.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ruby+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ruby+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ruby+default-devel.sha256sum] = "4fa4ecd0d41cb9f7b9fe337bf0f513d6ffeaf156f8ec3a6404bf91d2cab36975"

URI_x86_64_v2_rust-tree-sitter-ruby-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ruby-devel-0.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ruby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ruby-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ruby-devel.sha256sum] = "f2f247dde36a94cd5af448c0fb7513d700a8ffb1fa2db24dec48da4b8e47901f"

URI_aarch64_rust-tree-sitter-ruby+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ruby+default-devel-0.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-ruby+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ruby+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-ruby+default-devel.sha256sum] = "cdad8295973c0dc9df125f46f86894f972f468379249d9bd242c6304101de695"

URI_aarch64_rust-tree-sitter-ruby-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ruby-devel-0.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-ruby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ruby-devel}"
SRC_URI[aarch64_rust-tree-sitter-ruby-devel.sha256sum] = "c85f5d0ab6f21b818a3437fc2d3847ca42b0775992e156d818f9a18b654f7612"

RDEPENDS:rust-tree-sitter-ruby+default-devel = " \
 cargo \
 rust-tree-sitter-ruby-devel \
 "
RDEPENDS:rust-tree-sitter-ruby-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
