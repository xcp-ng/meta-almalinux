# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spki"
PV = "0.8.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-spki+alloc-devel \
 rust-spki+arbitrary-devel \
 rust-spki+base64-devel \
 rust-spki+default-devel \
 rust-spki+digest-devel \
 rust-spki+fingerprint-devel \
 rust-spki+pem-devel \
 rust-spki+sha2-devel \
 rust-spki+std-devel \
 rust-spki-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-spki-0.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c7d2d7b1bd004be549282ca896378fcde1f21c7c46c081355cf4a1570138fdc"

URI_x86_64_v2_rust-spki+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+alloc-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+alloc-devel}"
SRC_URI[x86_64_v2_rust-spki+alloc-devel.sha256sum] = "0cbdc1b44eb3c4756f3b57fdb4f546e6efeabda6fef62516899d4f6a7faf73c7"

URI_x86_64_v2_rust-spki+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+arbitrary-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-spki+arbitrary-devel.sha256sum] = "132d3768c2753e6e84f978ea9255c291e71f4134cf2d60656e9b2eb9eab01953"

URI_x86_64_v2_rust-spki+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+base64-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+base64-devel}"
SRC_URI[x86_64_v2_rust-spki+base64-devel.sha256sum] = "d08205551d6d1abd39f8857a1051b0706c33f0e59c0bee19e43ded419ec76f69"

URI_x86_64_v2_rust-spki+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+default-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+default-devel}"
SRC_URI[x86_64_v2_rust-spki+default-devel.sha256sum] = "501c00dc61b4e00d9a4884639a68b028c30899a67ee0e1cda3ee720e1c18bf18"

URI_x86_64_v2_rust-spki+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+digest-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+digest-devel}"
SRC_URI[x86_64_v2_rust-spki+digest-devel.sha256sum] = "71526140a68e9af1c7a24aca486c2b7137b30113b4447cca4bd535ecbcf28be7"

URI_x86_64_v2_rust-spki+fingerprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+fingerprint-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+fingerprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+fingerprint-devel}"
SRC_URI[x86_64_v2_rust-spki+fingerprint-devel.sha256sum] = "3b390a42aed3665eccdbb11b832a9b699f2c31f19b0e386bb24833d8f8694b7b"

URI_x86_64_v2_rust-spki+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+pem-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+pem-devel}"
SRC_URI[x86_64_v2_rust-spki+pem-devel.sha256sum] = "9808dbf05ed3c7c7e376f698381157d4f60f3e5ed46ab8305df0190e2a29b7f0"

URI_x86_64_v2_rust-spki+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+sha2-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+sha2-devel}"
SRC_URI[x86_64_v2_rust-spki+sha2-devel.sha256sum] = "df151dcd464111669438d5dbe34b34c7e4b7bdf327326647a85541729b33f601"

URI_x86_64_v2_rust-spki+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+std-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+std-devel}"
SRC_URI[x86_64_v2_rust-spki+std-devel.sha256sum] = "8a3a3b35628626dacce018475b56a9cd14372e4a9e389c030a39d33aec8fe429"

URI_x86_64_v2_rust-spki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki-devel}"
SRC_URI[x86_64_v2_rust-spki-devel.sha256sum] = "27641945d21c1ba075e016595a07365408d880ebc8c9fac79ff795ac95a781be"

URI_aarch64_rust-spki+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+alloc-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-spki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+alloc-devel}"
SRC_URI[aarch64_rust-spki+alloc-devel.sha256sum] = "87331e515e83f53dbbb666bae863ffae2ebe998182bbd43854ff631caa82d916"

URI_aarch64_rust-spki+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+arbitrary-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-spki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+arbitrary-devel}"
SRC_URI[aarch64_rust-spki+arbitrary-devel.sha256sum] = "ebe794fea43d58e420c131be63b9369988b74507abc6a60bc94442d271605aad"

URI_aarch64_rust-spki+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+base64-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-spki+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+base64-devel}"
SRC_URI[aarch64_rust-spki+base64-devel.sha256sum] = "6022d4e56d2919f02bd3d5ee095a413351ad648ca74b59998dc43e73ea4f5c72"

URI_aarch64_rust-spki+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+default-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-spki+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+default-devel}"
SRC_URI[aarch64_rust-spki+default-devel.sha256sum] = "3bb84c9373afea973226508e9307aa0c6edc619d1fb1e333abf3264252286df4"

URI_aarch64_rust-spki+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+digest-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-spki+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+digest-devel}"
SRC_URI[aarch64_rust-spki+digest-devel.sha256sum] = "72c02d74973f4ae3df5fa716453a800e029ef7e702103503af1be38e600bd955"

URI_aarch64_rust-spki+fingerprint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+fingerprint-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-spki+fingerprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+fingerprint-devel}"
SRC_URI[aarch64_rust-spki+fingerprint-devel.sha256sum] = "4437e39c9ad4546e85bfc0390113f3c3ada19b2fde7eb109c6d1a387ac01a4a0"

URI_aarch64_rust-spki+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+pem-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-spki+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+pem-devel}"
SRC_URI[aarch64_rust-spki+pem-devel.sha256sum] = "4e4394e8befa895cba6b62a78123296fac00058f34fd52d610ba86cd9a24938a"

URI_aarch64_rust-spki+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+sha2-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-spki+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+sha2-devel}"
SRC_URI[aarch64_rust-spki+sha2-devel.sha256sum] = "a1f1eea457c537e19833fcb27546d756e16c457abbb9aeada4af84c7b0e78c9d"

URI_aarch64_rust-spki+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+std-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-spki+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+std-devel}"
SRC_URI[aarch64_rust-spki+std-devel.sha256sum] = "65a15354d10c73053e0130ca7d92c4dedd03977118f89c507e18eae2cb0f668c"

URI_aarch64_rust-spki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-spki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki-devel}"
SRC_URI[aarch64_rust-spki-devel.sha256sum] = "57b7922c465d0433521fbd39ae98fb7c23e7361843c00cd9fdde8886bbffeb7e"

RDEPENDS:rust-spki+alloc-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-base64ct-devel \
 rust-der+alloc-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-der+arbitrary-devel \
 rust-spki+std-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+base64-devel = " \
 cargo \
 rust-base64ct-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+default-devel = " \
 cargo \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+digest-devel = " \
 cargo \
 rust-digest-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+fingerprint-devel = " \
 cargo \
 rust-spki+digest-devel \
 rust-spki+sha2-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+pem-devel = " \
 cargo \
 rust-der+pem-devel \
 rust-spki+alloc-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+sha2-devel = " \
 cargo \
 rust-sha2-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+std-devel = " \
 cargo \
 rust-der+std-devel \
 rust-spki+alloc-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki-devel = " \
 cargo \
 rust \
 rust-der+default-devel \
 rust-der+oid-devel \
 "
