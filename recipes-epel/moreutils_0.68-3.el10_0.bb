# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "moreutils"
PV = "0.68"
PR = "3.el10_0"
PACKAGES = " \
 moreutils \
 moreutils-parallel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/moreutils-0.68-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e827b09a9f64fffac18cbc95be94466e3c3477b601254b04839ffaf64b523f0"

URI_x86_64_v2_moreutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/moreutils-0.68-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_moreutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_moreutils}"
SRC_URI[x86_64_v2_moreutils.sha256sum] = "b8a5b46f67af8c7bfaf44de4826cd7dafc31158611065fbaf25ef419611e9dd2"

URI_x86_64_v2_moreutils-parallel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/moreutils-parallel-0.68-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_moreutils-parallel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_moreutils-parallel}"
SRC_URI[x86_64_v2_moreutils-parallel.sha256sum] = "b62c2323fc7a9f46b30947b18ad6df7105a9094b7432b9031898267db4a191c4"

URI_aarch64_moreutils = "${EPEL_MIRROR}/aarch64/Packages/m/moreutils-0.68-3.el10_0.aarch64.rpm;name=aarch64_moreutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_moreutils}"
SRC_URI[aarch64_moreutils.sha256sum] = "1d2462927d654ccecb5ca48f6a25f3555ad05323774cec56bbf0b3815f58daf4"

URI_aarch64_moreutils-parallel = "${EPEL_MIRROR}/aarch64/Packages/m/moreutils-parallel-0.68-3.el10_0.aarch64.rpm;name=aarch64_moreutils-parallel;unpack=0"
SRC_URI:append = " ${URI_aarch64_moreutils-parallel}"
SRC_URI[aarch64_moreutils-parallel.sha256sum] = "c4b68a956017b3b6334c6c03a459113700fb3f0e0a8373d888861942ab1d86e5"

RDEPENDS:moreutils = " \
 glibc \
 perl-File-Basename \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-IPC-Run \
 perl-POSIX \
 perl-PathTools \
 perl-Time-Duration \
 perl-Time-HiRes \
 perl-TimeDate \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:moreutils-parallel = " \
 glibc \
 moreutils \
 "
