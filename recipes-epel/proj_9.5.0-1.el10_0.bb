# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "proj"
PV = "9.5.0"
PR = "1.el10_0"
PACKAGES = " \
 proj \
 proj-data \
 proj-data-ar \
 proj-data-at \
 proj-data-au \
 proj-data-be \
 proj-data-br \
 proj-data-ca \
 proj-data-ch \
 proj-data-cz \
 proj-data-de \
 proj-data-dk \
 proj-data-es \
 proj-data-eur \
 proj-data-europe \
 proj-data-fi \
 proj-data-fo \
 proj-data-fr \
 proj-data-is \
 proj-data-jp \
 proj-data-mx \
 proj-data-nc \
 proj-data-nl \
 proj-data-no \
 proj-data-north-america \
 proj-data-nz \
 proj-data-oceania \
 proj-data-pl \
 proj-data-pt \
 proj-data-se \
 proj-data-si \
 proj-data-sk \
 proj-data-uk \
 proj-data-us \
 proj-data-world \
 proj-data-za \
 proj-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/proj-9.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f20c3d0eb9c07c00ebd1ef86e8845b92181f9f616633ab8ac7e4f985f287e910"

URI_x86_64_v2_proj = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-9.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj}"
SRC_URI[x86_64_v2_proj.sha256sum] = "bc41f0f368a2de145491b32001514a4ff1f3a49563230d236d2d5c5564cca8d6"

URI_x86_64_v2_proj-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data}"
SRC_URI[x86_64_v2_proj-data.sha256sum] = "14f9b092f67ce0f8d8d0eee3fc422aee00a3e14a9bccddd33fad8673fcf5c9db"

URI_x86_64_v2_proj-data-ar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-ar-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-ar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-ar}"
SRC_URI[x86_64_v2_proj-data-ar.sha256sum] = "e3d4f8a5ddd49dfc08c365dc842ba53b6f5fdd2b2bd6ce45aaa8fe06e6d1069a"

URI_x86_64_v2_proj-data-at = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-at-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-at;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-at}"
SRC_URI[x86_64_v2_proj-data-at.sha256sum] = "d930969910ce19beded274ca181281095514e570cba802053ae26401f7fd0646"

URI_x86_64_v2_proj-data-au = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-au-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-au;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-au}"
SRC_URI[x86_64_v2_proj-data-au.sha256sum] = "699321db467c718c0c655b5f2752d7cc76639f8b536732cb7a957895f273bd97"

URI_x86_64_v2_proj-data-be = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-be-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-be;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-be}"
SRC_URI[x86_64_v2_proj-data-be.sha256sum] = "1775e5569a70c69901d710a632f26aa6674129f44c53d56620bca263b70dd2b1"

URI_x86_64_v2_proj-data-br = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-br-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-br;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-br}"
SRC_URI[x86_64_v2_proj-data-br.sha256sum] = "d70676f5a304e43e9985e19e7fc3e98c7912af664b7f098e7910d096eade0021"

URI_x86_64_v2_proj-data-ca = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-ca-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-ca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-ca}"
SRC_URI[x86_64_v2_proj-data-ca.sha256sum] = "8b3e50a0c2825b0f9b2e6f764dc8918a7339668936432c2f6f855fc375f307fd"

URI_x86_64_v2_proj-data-ch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-ch-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-ch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-ch}"
SRC_URI[x86_64_v2_proj-data-ch.sha256sum] = "81166f870c67f6d01296383de3a22b1275c219ee2943ef32bae383fd0b774f58"

URI_x86_64_v2_proj-data-cz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-cz-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-cz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-cz}"
SRC_URI[x86_64_v2_proj-data-cz.sha256sum] = "ef6e7169c6babfd7afeee79fc1704bf6d9870d778302b213b2633b6a6ab4a482"

URI_x86_64_v2_proj-data-de = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-de-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-de;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-de}"
SRC_URI[x86_64_v2_proj-data-de.sha256sum] = "7aa6df5ae5ef55816d97c0f32d456c9aeded88e9b05c313b24d7a06a61f237f0"

URI_x86_64_v2_proj-data-dk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-dk-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-dk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-dk}"
SRC_URI[x86_64_v2_proj-data-dk.sha256sum] = "e25041128da6b2bf88170a58788dd9287bd88fec72c66305a2266d4f3508f3c8"

URI_x86_64_v2_proj-data-es = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-es-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-es;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-es}"
SRC_URI[x86_64_v2_proj-data-es.sha256sum] = "8d2216adb90f0900ec8f7ac48b57c9bac1573d4a408074dfc695bc1a59b9806d"

URI_x86_64_v2_proj-data-eur = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-eur-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-eur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-eur}"
SRC_URI[x86_64_v2_proj-data-eur.sha256sum] = "0e53b37940da672592b546453bfe5796506efd52ad57345e84636df4eaa9f303"

URI_x86_64_v2_proj-data-europe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-europe-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-europe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-europe}"
SRC_URI[x86_64_v2_proj-data-europe.sha256sum] = "0cec7ed6acfb429bbf94fb4315594722d8f1609dc94567d734370cfc8b7e32c2"

URI_x86_64_v2_proj-data-fi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-fi-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-fi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-fi}"
SRC_URI[x86_64_v2_proj-data-fi.sha256sum] = "06e9d1d3ebbce0b020fba38776df220537e5ac1e0190beeb3394cb944dc46ebe"

URI_x86_64_v2_proj-data-fo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-fo-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-fo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-fo}"
SRC_URI[x86_64_v2_proj-data-fo.sha256sum] = "f5e2633e2848298679712c03e49d0fba680f5a0cef4d935d62c3872503cfb65a"

URI_x86_64_v2_proj-data-fr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-fr-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-fr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-fr}"
SRC_URI[x86_64_v2_proj-data-fr.sha256sum] = "1d0de0c2737631ea265a6669fb212b6e458afa974a6cd66656e9ff720ef035a1"

URI_x86_64_v2_proj-data-is = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-is-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-is;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-is}"
SRC_URI[x86_64_v2_proj-data-is.sha256sum] = "8f923febdf7164de2ec5257da8a353200d56ff8281c21e7aa52ed8da5f2cfe4e"

URI_x86_64_v2_proj-data-jp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-jp-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-jp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-jp}"
SRC_URI[x86_64_v2_proj-data-jp.sha256sum] = "ac0a750727ab6844d6ae3f0d51320df4819c002c7fcf8acc9efd585c7adce675"

URI_x86_64_v2_proj-data-mx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-mx-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-mx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-mx}"
SRC_URI[x86_64_v2_proj-data-mx.sha256sum] = "2d594b4c8303ac6d7c25fa5bde610a3e257d67c85f157064454a0df836eaf1dc"

URI_x86_64_v2_proj-data-nc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-nc-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-nc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-nc}"
SRC_URI[x86_64_v2_proj-data-nc.sha256sum] = "6e28401e9e30bc71d7853eba562acd15ddb5d616e0691d097e701a4a53904080"

URI_x86_64_v2_proj-data-nl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-nl-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-nl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-nl}"
SRC_URI[x86_64_v2_proj-data-nl.sha256sum] = "511a4b4c812bc9c712615f2eef48fdbafc6e1892532b2a840e8ac243b65b81b3"

URI_x86_64_v2_proj-data-no = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-no-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-no;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-no}"
SRC_URI[x86_64_v2_proj-data-no.sha256sum] = "841f981259b239296a3c3050f40e056a6d7a3c2fc4fa9c8cf17c47ab5a80680d"

URI_x86_64_v2_proj-data-north-america = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-north-america-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-north-america;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-north-america}"
SRC_URI[x86_64_v2_proj-data-north-america.sha256sum] = "c820d2ab415bf9e3362029f8859765ff2bed14201bf99ef14e92c1472ab14257"

URI_x86_64_v2_proj-data-nz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-nz-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-nz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-nz}"
SRC_URI[x86_64_v2_proj-data-nz.sha256sum] = "20152c0f2e057c4a136d7cf29747cc41d28dc64bfc3c72cfac2601f9c0fa1a8f"

URI_x86_64_v2_proj-data-oceania = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-oceania-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-oceania;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-oceania}"
SRC_URI[x86_64_v2_proj-data-oceania.sha256sum] = "603393e23d18d63ff6849f2763060ef5fcd467e8ee61d6f8a77ee11cc63e15ba"

URI_x86_64_v2_proj-data-pl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-pl-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-pl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-pl}"
SRC_URI[x86_64_v2_proj-data-pl.sha256sum] = "f5c2352b51449ea32236ecf709a404f48325688e43c3c3caf704f46392fe06a6"

URI_x86_64_v2_proj-data-pt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-pt-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-pt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-pt}"
SRC_URI[x86_64_v2_proj-data-pt.sha256sum] = "cb103039754d4bf5eabe124517109bdec34e22e479b8217233efbfc537dc05f1"

URI_x86_64_v2_proj-data-se = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-se-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-se;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-se}"
SRC_URI[x86_64_v2_proj-data-se.sha256sum] = "f276a0943c4914c45442b5178cef217661e583338ff2d5d13bfe84d3b44f473f"

URI_x86_64_v2_proj-data-si = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-si-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-si;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-si}"
SRC_URI[x86_64_v2_proj-data-si.sha256sum] = "dcd3aaea696f75e2d2ccbb5b15d6a5df624bd279f5b68baf1b244fa002a371f7"

URI_x86_64_v2_proj-data-sk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-sk-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-sk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-sk}"
SRC_URI[x86_64_v2_proj-data-sk.sha256sum] = "333b8bde2f864811891e989e8ab76d79a0b859b79f28dc3f9f34efdc74ac2729"

URI_x86_64_v2_proj-data-uk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-uk-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-uk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-uk}"
SRC_URI[x86_64_v2_proj-data-uk.sha256sum] = "86023d70a4fd67986ae580e8f98575f5c01228ec3b36b04f078b49a338707f4d"

URI_x86_64_v2_proj-data-us = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-us-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-us;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-us}"
SRC_URI[x86_64_v2_proj-data-us.sha256sum] = "748a127d5f83c4127fb51f612e1322a9573ab8ec331cb25cae8829f723a44787"

URI_x86_64_v2_proj-data-world = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-world-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-world;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-world}"
SRC_URI[x86_64_v2_proj-data-world.sha256sum] = "3092762a5b8e348b76c0818a2acf474bb19cd4b88838243b4d1d584f4caa2253"

URI_x86_64_v2_proj-data-za = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-data-za-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_proj-data-za;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-data-za}"
SRC_URI[x86_64_v2_proj-data-za.sha256sum] = "ff9b2cd978a841718fcb514eb47f2255f081d99ca801ba1344e79e3013a885a7"

URI_x86_64_v2_proj-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proj-devel-9.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proj-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proj-devel}"
SRC_URI[x86_64_v2_proj-devel.sha256sum] = "8364da95cd7f9a3273757785aadf57c07805250c1949bd72400443a2fa940cf6"

URI_aarch64_proj = "${EPEL_MIRROR}/aarch64/Packages/p/proj-9.5.0-1.el10_0.aarch64.rpm;name=aarch64_proj;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj}"
SRC_URI[aarch64_proj.sha256sum] = "a409a9b2d0782f627ae8400f16807429d1628c919fdc12e6f14537b549ab4b98"

URI_aarch64_proj-data = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data}"
SRC_URI[aarch64_proj-data.sha256sum] = "f05659faf25c9cc97e544fa8883a65a172f2b5d9ec122630cfb13841d1fd7208"

URI_aarch64_proj-data-ar = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-ar-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-ar;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-ar}"
SRC_URI[aarch64_proj-data-ar.sha256sum] = "a81a0b0d187ab275372687e2cf5236168ad8fdad8419ea53ab8ddd5069215626"

URI_aarch64_proj-data-at = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-at-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-at;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-at}"
SRC_URI[aarch64_proj-data-at.sha256sum] = "48a487ff11bd750c440bdfb717bd34402896ca077b4f07f9e6f5898c07707cbc"

URI_aarch64_proj-data-au = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-au-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-au;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-au}"
SRC_URI[aarch64_proj-data-au.sha256sum] = "bfb1c557f7ffdff46b056f5d6e3ca1a92f83c8a47eb8a27c4a2cfac3afeda7d8"

URI_aarch64_proj-data-be = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-be-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-be;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-be}"
SRC_URI[aarch64_proj-data-be.sha256sum] = "70de11eee95e001769a0081a4f8069f40dfe0399b8fcd0740ca8c882e4fd50b9"

URI_aarch64_proj-data-br = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-br-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-br;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-br}"
SRC_URI[aarch64_proj-data-br.sha256sum] = "d4cf25ccad8012059698f4617e2425736d63cd618c8065f3c5fc89fba53340bf"

URI_aarch64_proj-data-ca = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-ca-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-ca;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-ca}"
SRC_URI[aarch64_proj-data-ca.sha256sum] = "64948cc6a2b78ded273a84d37175a3e6a689b2951049c547f3507d60c8b9a118"

URI_aarch64_proj-data-ch = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-ch-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-ch;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-ch}"
SRC_URI[aarch64_proj-data-ch.sha256sum] = "49d1768107011c9193577489ba917885018f0aca4e7e2ba3f9e0e9fed79475bc"

URI_aarch64_proj-data-cz = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-cz-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-cz;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-cz}"
SRC_URI[aarch64_proj-data-cz.sha256sum] = "5a13b759de6c411aadeac6a0df7e9ea75ef3b9957c63d5851278dca7fc0e9844"

URI_aarch64_proj-data-de = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-de-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-de;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-de}"
SRC_URI[aarch64_proj-data-de.sha256sum] = "ca8846ddc3eb802c996091074ae963ce6d2be0d2b199e03757895426e46f54ca"

URI_aarch64_proj-data-dk = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-dk-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-dk;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-dk}"
SRC_URI[aarch64_proj-data-dk.sha256sum] = "dbf9642cb20a3d5dca4248b258e06c970dcdef03ba18d2bdda60502b6a6b7acf"

URI_aarch64_proj-data-es = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-es-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-es;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-es}"
SRC_URI[aarch64_proj-data-es.sha256sum] = "2788cc695f7aa9e77d71d00f2b6ede7d96fb361d9ec90f90e7ce75618f9cc3e7"

URI_aarch64_proj-data-eur = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-eur-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-eur;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-eur}"
SRC_URI[aarch64_proj-data-eur.sha256sum] = "dd6738d48846700d01799cdb957be84e5ccbc840b56ad7c4d621dbfa0b0481a5"

URI_aarch64_proj-data-europe = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-europe-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-europe;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-europe}"
SRC_URI[aarch64_proj-data-europe.sha256sum] = "cf435b924d1dbde0efdb6e3f790e34fe7c1406e13a41aadf8a5dbd6938333ee9"

URI_aarch64_proj-data-fi = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-fi-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-fi;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-fi}"
SRC_URI[aarch64_proj-data-fi.sha256sum] = "21878be716f60cf7896ca6a667dc226adc7d890860c7b72b2a592a67b888ce58"

URI_aarch64_proj-data-fo = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-fo-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-fo;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-fo}"
SRC_URI[aarch64_proj-data-fo.sha256sum] = "d375a28fb4cf097baa05afe0c69ab2ef185fd7bc92ee6fd7686ff7cc212924b3"

URI_aarch64_proj-data-fr = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-fr-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-fr;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-fr}"
SRC_URI[aarch64_proj-data-fr.sha256sum] = "f6eabdd47c2c4a18d16f1324b5b13cd91afc4e034293b554685a25af1193199c"

URI_aarch64_proj-data-is = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-is-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-is;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-is}"
SRC_URI[aarch64_proj-data-is.sha256sum] = "4c4780490ae424584913dce495a8720746eacc4f310beecfd73492f3a7995aac"

URI_aarch64_proj-data-jp = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-jp-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-jp;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-jp}"
SRC_URI[aarch64_proj-data-jp.sha256sum] = "b040b358adef8a791c365d3b6d8c22bcd7a5ae80e057dcd928489bffbbfac5be"

URI_aarch64_proj-data-mx = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-mx-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-mx;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-mx}"
SRC_URI[aarch64_proj-data-mx.sha256sum] = "8219d773088f397b221c810080079b2ec496538b71b820f0c2e026128b88867a"

URI_aarch64_proj-data-nc = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-nc-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-nc;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-nc}"
SRC_URI[aarch64_proj-data-nc.sha256sum] = "4dbdf30e9f50cfcc61002d424b9bd42a79477f5e1d46d7c673fb725578896ca6"

URI_aarch64_proj-data-nl = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-nl-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-nl;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-nl}"
SRC_URI[aarch64_proj-data-nl.sha256sum] = "d0f23d5d39132ca3ad4d294d716277e389cdfdb6d064df5a168390eb2fdfdebb"

URI_aarch64_proj-data-no = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-no-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-no;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-no}"
SRC_URI[aarch64_proj-data-no.sha256sum] = "1ed549493e9ecbc2b2608d7f85b77e6b2dc0c4b6775b654808829f60c4415061"

URI_aarch64_proj-data-north-america = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-north-america-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-north-america;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-north-america}"
SRC_URI[aarch64_proj-data-north-america.sha256sum] = "b2f8e9bdc98d3e08fee6ef4048cbaf04c7a787928f3f58b34534a2ef44a5203e"

URI_aarch64_proj-data-nz = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-nz-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-nz;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-nz}"
SRC_URI[aarch64_proj-data-nz.sha256sum] = "bdbb6d3bbb49f70e662d5ffb020987cd00b159bee5fb16fb84381d53d0e30dd5"

URI_aarch64_proj-data-oceania = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-oceania-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-oceania;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-oceania}"
SRC_URI[aarch64_proj-data-oceania.sha256sum] = "2aae9c704dc765edf09248d023bf40bf275825d698e02e5afc6fb24c5ef2d595"

URI_aarch64_proj-data-pl = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-pl-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-pl;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-pl}"
SRC_URI[aarch64_proj-data-pl.sha256sum] = "9dc1a0c98ddb6f9d40f92b7aa668b86bdb350430095a1a15691c45c785553a52"

URI_aarch64_proj-data-pt = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-pt-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-pt;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-pt}"
SRC_URI[aarch64_proj-data-pt.sha256sum] = "dc5023ac9ad55b6dd933d395ff44dc293a9a2031ec3741b38105499695b34ba6"

URI_aarch64_proj-data-se = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-se-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-se;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-se}"
SRC_URI[aarch64_proj-data-se.sha256sum] = "cdb54ddb27d301e0da2601f87c49f96c9abb04af9caebf3740671e17d1bb58a2"

URI_aarch64_proj-data-si = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-si-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-si;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-si}"
SRC_URI[aarch64_proj-data-si.sha256sum] = "fe329bc4a98aaa59f6908f4233bef9478a54d69c732a2c1f689a4b87a3c3934c"

URI_aarch64_proj-data-sk = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-sk-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-sk;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-sk}"
SRC_URI[aarch64_proj-data-sk.sha256sum] = "700863a2cff60ad8769c7ccd0bb0a8f4859577da4761c32a8e738532cd736333"

URI_aarch64_proj-data-uk = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-uk-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-uk;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-uk}"
SRC_URI[aarch64_proj-data-uk.sha256sum] = "7737d4623ae49ab33f8938366b8dc2c5bc1fffbf64eccf6755f0535f0dabf6fb"

URI_aarch64_proj-data-us = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-us-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-us;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-us}"
SRC_URI[aarch64_proj-data-us.sha256sum] = "c7d14a1cec21eefe57f50f6a1edddf6e51daa4bf5fc0171c1cfeaf2c594f002f"

URI_aarch64_proj-data-world = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-world-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-world;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-world}"
SRC_URI[aarch64_proj-data-world.sha256sum] = "88e507c0a30a753272f94af6d460a691cfb5accb16a4f96f9d92c1f0cf62e538"

URI_aarch64_proj-data-za = "${EPEL_MIRROR}/aarch64/Packages/p/proj-data-za-9.5.0-1.el10_0.noarch.rpm;name=aarch64_proj-data-za;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-data-za}"
SRC_URI[aarch64_proj-data-za.sha256sum] = "456ec73bc66c6c1801a3d7b21fa36147a7e3c1569ee5b3d3a610d732ae9659e8"

URI_aarch64_proj-devel = "${EPEL_MIRROR}/aarch64/Packages/p/proj-devel-9.5.0-1.el10_0.aarch64.rpm;name=aarch64_proj-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_proj-devel}"
SRC_URI[aarch64_proj-devel.sha256sum] = "4f36ace78d0cc8927686f990cf061b0172444b2932ccff8354a106af5aa60ddd"

RDEPENDS:proj = " \
 glibc \
 libgcc \
 libstdc++ \
 libtiff \
 proj-data \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:proj-data = " \
 "
RDEPENDS:proj-data-ar = " \
 proj-data \
 "
RDEPENDS:proj-data-at = " \
 proj-data \
 "
RDEPENDS:proj-data-au = " \
 proj-data \
 "
RDEPENDS:proj-data-be = " \
 proj-data \
 "
RDEPENDS:proj-data-br = " \
 proj-data \
 "
RDEPENDS:proj-data-ca = " \
 proj-data \
 "
RDEPENDS:proj-data-ch = " \
 proj-data \
 "
RDEPENDS:proj-data-cz = " \
 proj-data \
 "
RDEPENDS:proj-data-de = " \
 proj-data \
 "
RDEPENDS:proj-data-dk = " \
 proj-data \
 "
RDEPENDS:proj-data-es = " \
 proj-data \
 "
RDEPENDS:proj-data-eur = " \
 proj-data \
 "
RDEPENDS:proj-data-europe = " \
 proj-data-at \
 proj-data-be \
 proj-data-ch \
 proj-data-cz \
 proj-data-de \
 proj-data-dk \
 proj-data-es \
 proj-data-eur \
 proj-data-fi \
 proj-data-fo \
 proj-data-fr \
 proj-data-is \
 proj-data-nl \
 proj-data-pl \
 proj-data-pt \
 proj-data-se \
 proj-data-si \
 proj-data-sk \
 proj-data-uk \
 "
RDEPENDS:proj-data-fi = " \
 proj-data \
 "
RDEPENDS:proj-data-fo = " \
 proj-data \
 "
RDEPENDS:proj-data-fr = " \
 proj-data \
 "
RDEPENDS:proj-data-is = " \
 proj-data \
 "
RDEPENDS:proj-data-jp = " \
 proj-data \
 "
RDEPENDS:proj-data-mx = " \
 proj-data \
 "
RDEPENDS:proj-data-nc = " \
 proj-data \
 "
RDEPENDS:proj-data-nl = " \
 proj-data \
 "
RDEPENDS:proj-data-no = " \
 proj-data \
 "
RDEPENDS:proj-data-north-america = " \
 proj-data-ca \
 proj-data-us \
 "
RDEPENDS:proj-data-nz = " \
 proj-data \
 "
RDEPENDS:proj-data-oceania = " \
 proj-data-au \
 proj-data-nc \
 proj-data-nz \
 "
RDEPENDS:proj-data-pl = " \
 proj-data \
 "
RDEPENDS:proj-data-pt = " \
 proj-data \
 "
RDEPENDS:proj-data-se = " \
 proj-data \
 "
RDEPENDS:proj-data-si = " \
 proj-data \
 "
RDEPENDS:proj-data-sk = " \
 proj-data \
 "
RDEPENDS:proj-data-uk = " \
 proj-data \
 "
RDEPENDS:proj-data-us = " \
 proj-data \
 "
RDEPENDS:proj-data-world = " \
 proj-data-br \
 proj-data-jp \
 "
RDEPENDS:proj-data-za = " \
 proj-data \
 "
RDEPENDS:proj-devel = " \
 cmake-filesystem \
 libcurl-devel \
 libtiff-devel \
 pkgconf-pkg-config \
 proj \
 sqlite-devel \
 "
