# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Algorithm-Combinatorics"
PV = "0.27"
PR = "33.el10_0"
PACKAGES = " \
 perl-Algorithm-Combinatorics \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Algorithm-Combinatorics-0.27-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11f10132398257ff095e3e215bcde699fda80bf38824aafdf72533944ace255d"

URI_x86_64_v2_perl-Algorithm-Combinatorics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Algorithm-Combinatorics-0.27-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Algorithm-Combinatorics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Algorithm-Combinatorics}"
SRC_URI[x86_64_v2_perl-Algorithm-Combinatorics.sha256sum] = "be9e8cf5f32e3dfe78d77a2d2106d599cff0730806f7b9413d38391c0c496b67"

URI_aarch64_perl-Algorithm-Combinatorics = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Algorithm-Combinatorics-0.27-33.el10_0.aarch64.rpm;name=aarch64_perl-Algorithm-Combinatorics;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Algorithm-Combinatorics}"
SRC_URI[aarch64_perl-Algorithm-Combinatorics.sha256sum] = "11f242ad8617e7260880abff8dd30be25799b34b1b196cf24fae5cc6ab86ccbb"

RDEPENDS:perl-Algorithm-Combinatorics = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-base \
 perl-libs \
 "
