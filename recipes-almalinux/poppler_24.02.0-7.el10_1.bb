# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "poppler"
PV = "24.02.0"
PR = "7.el10_1"
PACKAGES = " \
 poppler \
 poppler-cpp \
 poppler-cpp-devel \
 poppler-devel \
 poppler-glib \
 poppler-glib-devel \
 poppler-glib-doc \
 poppler-qt6 \
 poppler-qt6-devel \
 poppler-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/poppler-24.02.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eff9f2b839641e548b3f6762faaec1ee6ddb9246ca1d44bf32366696cd551a98"

URI_x86_64_v2_poppler = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-24.02.0-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_poppler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler}"
SRC_URI[x86_64_v2_poppler.sha256sum] = "4560b2e0f8393477dc3f932b6328d10d902b661b5856c6bfe824c993b2234317"

URI_x86_64_v2_poppler-cpp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-cpp-24.02.0-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_poppler-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-cpp}"
SRC_URI[x86_64_v2_poppler-cpp.sha256sum] = "b2e5c80e14ae87317ea9c16ac41c4186a030602ad01d7fea9e623a5071672276"

URI_x86_64_v2_poppler-cpp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-cpp-devel-24.02.0-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_poppler-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-cpp-devel}"
SRC_URI[x86_64_v2_poppler-cpp-devel.sha256sum] = "8e4788d235b1c79ed0004fab9692d1fd002febc46f0f39494c8684532c234f75"

URI_x86_64_v2_poppler-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-devel-24.02.0-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_poppler-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-devel}"
SRC_URI[x86_64_v2_poppler-devel.sha256sum] = "8d4d66ac30cedf6880f0047d1b94e4768c87c8c9761ec35c2408a1e884c21c0f"

URI_x86_64_v2_poppler-glib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-glib-24.02.0-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_poppler-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-glib}"
SRC_URI[x86_64_v2_poppler-glib.sha256sum] = "45654fa3a6c01c8e7b07b88e9033e4927d835509aac6a319ef1f4d09f2924262"

URI_x86_64_v2_poppler-glib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-glib-devel-24.02.0-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_poppler-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-glib-devel}"
SRC_URI[x86_64_v2_poppler-glib-devel.sha256sum] = "18219d7cebf3bda582e3f23d27a4f239c401ae184e44ab224d0a40ff99789bc9"

URI_x86_64_v2_poppler-glib-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-glib-doc-24.02.0-7.el10_1.noarch.rpm;name=x86_64_v2_poppler-glib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-glib-doc}"
SRC_URI[x86_64_v2_poppler-glib-doc.sha256sum] = "94cfb72d303bddf260881ca767e64ff91af5fbb197dc31d7b0289d77cdb12fbc"

URI_x86_64_v2_poppler-qt6 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-qt6-24.02.0-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_poppler-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-qt6}"
SRC_URI[x86_64_v2_poppler-qt6.sha256sum] = "fc3045900c4207099cfe81b8d1af25237a863c1e4951aeb0f6819203e98e54c8"

URI_x86_64_v2_poppler-qt6-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-qt6-devel-24.02.0-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_poppler-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-qt6-devel}"
SRC_URI[x86_64_v2_poppler-qt6-devel.sha256sum] = "da0434fd57a92963feeee9c150593ed502330560e9ba7c6e53c5b619253df867"

URI_x86_64_v2_poppler-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-utils-24.02.0-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_poppler-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-utils}"
SRC_URI[x86_64_v2_poppler-utils.sha256sum] = "53b0eff4fab8076f39c52887f415a9f2c48bb18da5ebeb6bd9a29174ad2a090a"

URI_aarch64_poppler = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-24.02.0-7.el10_1.aarch64.rpm;name=aarch64_poppler;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler}"
SRC_URI[aarch64_poppler.sha256sum] = "12bbcb044f2f3909bc0c0633f20a2942189a4a12f5a454bd3fed989af4b3a2c9"

URI_aarch64_poppler-cpp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-cpp-24.02.0-7.el10_1.aarch64.rpm;name=aarch64_poppler-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-cpp}"
SRC_URI[aarch64_poppler-cpp.sha256sum] = "69cee9b67ec209776e2a32363323a4a0c13917cb729cbcb93a0e3b6a8e5b6cd9"

URI_aarch64_poppler-cpp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-cpp-devel-24.02.0-7.el10_1.aarch64.rpm;name=aarch64_poppler-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-cpp-devel}"
SRC_URI[aarch64_poppler-cpp-devel.sha256sum] = "52a26d9573fa0fe8decf7f016f077325db95adb63d17983c5ea51c61c2fcecdc"

URI_aarch64_poppler-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-devel-24.02.0-7.el10_1.aarch64.rpm;name=aarch64_poppler-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-devel}"
SRC_URI[aarch64_poppler-devel.sha256sum] = "9f6d49154ce32d5cbeda17195471155b0b6c9bd75e59e2b0498cb84bd49284a0"

URI_aarch64_poppler-glib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-glib-24.02.0-7.el10_1.aarch64.rpm;name=aarch64_poppler-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-glib}"
SRC_URI[aarch64_poppler-glib.sha256sum] = "72e24324cb1d19d9c814d8d260ac31402fa741c27ccc170a556fcb70608a3288"

URI_aarch64_poppler-glib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-glib-devel-24.02.0-7.el10_1.aarch64.rpm;name=aarch64_poppler-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-glib-devel}"
SRC_URI[aarch64_poppler-glib-devel.sha256sum] = "2cea75581734573202159e082f4203e4a5f61f07342207b22979294b10132b49"

URI_aarch64_poppler-glib-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-glib-doc-24.02.0-7.el10_1.noarch.rpm;name=aarch64_poppler-glib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-glib-doc}"
SRC_URI[aarch64_poppler-glib-doc.sha256sum] = "94cfb72d303bddf260881ca767e64ff91af5fbb197dc31d7b0289d77cdb12fbc"

URI_aarch64_poppler-qt6 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-qt6-24.02.0-7.el10_1.aarch64.rpm;name=aarch64_poppler-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-qt6}"
SRC_URI[aarch64_poppler-qt6.sha256sum] = "90b7595595c9286fd2b3e68802ff182ed3fa611292ef94aa1dcdd02e2340861c"

URI_aarch64_poppler-qt6-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-qt6-devel-24.02.0-7.el10_1.aarch64.rpm;name=aarch64_poppler-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-qt6-devel}"
SRC_URI[aarch64_poppler-qt6-devel.sha256sum] = "f5314082258d7195cf79acb45c08fe3d421f253bb8681712cfea1267d91e3a59"

URI_aarch64_poppler-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-utils-24.02.0-7.el10_1.aarch64.rpm;name=aarch64_poppler-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-utils}"
SRC_URI[aarch64_poppler-utils.sha256sum] = "2100a47b328a720aa8e9a17d56aa51af292ac72d5ac1678ab3c1a199d2d7e0a0"

RDEPENDS:poppler = " \
 fontconfig \
 freetype \
 glibc \
 gpgmepp \
 lcms2 \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 nspr \
 nss \
 openjpeg2 \
 poppler-data \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:poppler-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 poppler \
 "
RDEPENDS:poppler-cpp-devel = " \
 pkgconf-pkg-config \
 poppler-cpp \
 poppler-devel \
 "
RDEPENDS:poppler-devel = " \
 pkgconf-pkg-config \
 poppler \
 "
RDEPENDS:poppler-glib = " \
 cairo \
 freetype \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 poppler \
 "
RDEPENDS:poppler-glib-devel = " \
 cairo-devel \
 glib2-devel \
 pkgconf-pkg-config \
 poppler-devel \
 poppler-glib \
 "
RDEPENDS:poppler-glib-doc = " \
 "
RDEPENDS:poppler-qt6 = " \
 freetype \
 glibc \
 lcms2 \
 libgcc \
 libstdc++ \
 poppler \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:poppler-qt6-devel = " \
 pkgconf-pkg-config \
 poppler-devel \
 poppler-qt6 \
 qt6-qtbase-devel \
 "
RDEPENDS:poppler-utils = " \
 cairo \
 freetype \
 glibc \
 lcms2 \
 libgcc \
 libstdc++ \
 poppler \
 "
