# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdb"
PV = "5.3.28"
PR = "64.el10_0"
PACKAGES = " \
 libdb \
 libdb-convert-util \
 libdb-cxx \
 libdb-cxx-devel \
 libdb-devel \
 libdb-devel-doc \
 libdb-devel-static \
 libdb-sql \
 libdb-sql-devel \
 libdb-tcl \
 libdb-tcl-devel \
 libdb-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdb-5.3.28-64.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b53cf9a1c197d116204f2840f8b7d08307dbd0ebcf3b22d9c2577a804d904393"

URI_x86_64_v2_libdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdb-5.3.28-64.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdb}"
SRC_URI[x86_64_v2_libdb.sha256sum] = "92bd8cc40ad70c20a327704f6b794fe293bdb9eb26d656796a11c20d8e1915f6"

URI_x86_64_v2_libdb-convert-util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdb-convert-util-5.3.28-64.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdb-convert-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdb-convert-util}"
SRC_URI[x86_64_v2_libdb-convert-util.sha256sum] = "334b556f1fa40c197044f5b5641a8d535e17ded43e73040f617c6cdce4eb96ec"

URI_x86_64_v2_libdb-cxx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdb-cxx-5.3.28-64.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdb-cxx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdb-cxx}"
SRC_URI[x86_64_v2_libdb-cxx.sha256sum] = "902350b6903e259ed66d04a88ee4da18e28eac06c4661361507661c998d0ba77"

URI_x86_64_v2_libdb-cxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdb-cxx-devel-5.3.28-64.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdb-cxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdb-cxx-devel}"
SRC_URI[x86_64_v2_libdb-cxx-devel.sha256sum] = "770dbaf2f79ef64b6faaba1c644421b02061cc8dbeb12e3f8549a6fe5ae59a4c"

URI_x86_64_v2_libdb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdb-devel-5.3.28-64.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdb-devel}"
SRC_URI[x86_64_v2_libdb-devel.sha256sum] = "7e1fa20e6b3cb994aff2e5bc63c9b2f8de4cf5a810b6aa2431e6ad4d5863da98"

URI_x86_64_v2_libdb-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdb-devel-doc-5.3.28-64.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libdb-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdb-devel-doc}"
SRC_URI[x86_64_v2_libdb-devel-doc.sha256sum] = "576395d8874cb697750b10b5c9f523ed659b87b722cb61f9d21e24cefa7928c0"

URI_x86_64_v2_libdb-devel-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdb-devel-static-5.3.28-64.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdb-devel-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdb-devel-static}"
SRC_URI[x86_64_v2_libdb-devel-static.sha256sum] = "50c1556afa3c64c9e8261f05940c9c659168f17c76f40dd24b8250cdde56d3cf"

URI_x86_64_v2_libdb-sql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdb-sql-5.3.28-64.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdb-sql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdb-sql}"
SRC_URI[x86_64_v2_libdb-sql.sha256sum] = "6f7004dec0ad168e9ccf6f70e473e9952614d930911b34e6f63e55c20dfbb098"

URI_x86_64_v2_libdb-sql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdb-sql-devel-5.3.28-64.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdb-sql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdb-sql-devel}"
SRC_URI[x86_64_v2_libdb-sql-devel.sha256sum] = "a4056e7ca067bd4984f0fd16156229713908afeb0ca819cb817bd458ec63acfe"

URI_x86_64_v2_libdb-tcl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdb-tcl-5.3.28-64.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdb-tcl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdb-tcl}"
SRC_URI[x86_64_v2_libdb-tcl.sha256sum] = "6b4350d97bc97841ac44d0521d34ab63c6746af418753edcc0a651fa06d88ec7"

URI_x86_64_v2_libdb-tcl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdb-tcl-devel-5.3.28-64.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdb-tcl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdb-tcl-devel}"
SRC_URI[x86_64_v2_libdb-tcl-devel.sha256sum] = "02dec67db8524298ad35a11912e44b9fe705ba383f8640807751c2ae0e1606cd"

URI_x86_64_v2_libdb-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdb-utils-5.3.28-64.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdb-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdb-utils}"
SRC_URI[x86_64_v2_libdb-utils.sha256sum] = "95436cfb4296d9421235a24cb76cb9dc0e10b84eab481e6c5fad1a5a3edc8ee1"

URI_aarch64_libdb = "${EPEL_MIRROR}/aarch64/Packages/l/libdb-5.3.28-64.el10_0.aarch64.rpm;name=aarch64_libdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdb}"
SRC_URI[aarch64_libdb.sha256sum] = "d6c9eecea3bf631cd79a05564a1b82bdc48b15e90be48a9d7ae37e1b31475cca"

URI_aarch64_libdb-convert-util = "${EPEL_MIRROR}/aarch64/Packages/l/libdb-convert-util-5.3.28-64.el10_0.aarch64.rpm;name=aarch64_libdb-convert-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdb-convert-util}"
SRC_URI[aarch64_libdb-convert-util.sha256sum] = "7d8dd12a1477c1485b48e760e6d943f8a0837b6183dc8cef03b22042222924a7"

URI_aarch64_libdb-cxx = "${EPEL_MIRROR}/aarch64/Packages/l/libdb-cxx-5.3.28-64.el10_0.aarch64.rpm;name=aarch64_libdb-cxx;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdb-cxx}"
SRC_URI[aarch64_libdb-cxx.sha256sum] = "ad8fb020e93f28e64b95133e68065ef22826c80defba6c2404a4a984a1b8d981"

URI_aarch64_libdb-cxx-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdb-cxx-devel-5.3.28-64.el10_0.aarch64.rpm;name=aarch64_libdb-cxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdb-cxx-devel}"
SRC_URI[aarch64_libdb-cxx-devel.sha256sum] = "6d54cf6d1528dab7dccc761fc96446928cfc908f69ca2809b7055f97886731d7"

URI_aarch64_libdb-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdb-devel-5.3.28-64.el10_0.aarch64.rpm;name=aarch64_libdb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdb-devel}"
SRC_URI[aarch64_libdb-devel.sha256sum] = "14821f648439e40d198d70655ba19bd3eb567054728506c74aaf056aa6d6ab73"

URI_aarch64_libdb-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libdb-devel-doc-5.3.28-64.el10_0.noarch.rpm;name=aarch64_libdb-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdb-devel-doc}"
SRC_URI[aarch64_libdb-devel-doc.sha256sum] = "afbed565082f99efcad484451ab5f92101715417e1ac4a31db961d80214058f2"

URI_aarch64_libdb-devel-static = "${EPEL_MIRROR}/aarch64/Packages/l/libdb-devel-static-5.3.28-64.el10_0.aarch64.rpm;name=aarch64_libdb-devel-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdb-devel-static}"
SRC_URI[aarch64_libdb-devel-static.sha256sum] = "7670e0bc905f7b9164a19dad17098fe0a1aef58acd2ea7297a30e5f2911c6f9f"

URI_aarch64_libdb-sql = "${EPEL_MIRROR}/aarch64/Packages/l/libdb-sql-5.3.28-64.el10_0.aarch64.rpm;name=aarch64_libdb-sql;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdb-sql}"
SRC_URI[aarch64_libdb-sql.sha256sum] = "2cc8e7c3ab476c865fc4680fda3a175d57afa4ce81bed04ab25d780b24ce00cd"

URI_aarch64_libdb-sql-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdb-sql-devel-5.3.28-64.el10_0.aarch64.rpm;name=aarch64_libdb-sql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdb-sql-devel}"
SRC_URI[aarch64_libdb-sql-devel.sha256sum] = "3cfad91b54345580a361da3a156390d20d99eaa7c11e8e40529c82b3ae1d7cd4"

URI_aarch64_libdb-tcl = "${EPEL_MIRROR}/aarch64/Packages/l/libdb-tcl-5.3.28-64.el10_0.aarch64.rpm;name=aarch64_libdb-tcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdb-tcl}"
SRC_URI[aarch64_libdb-tcl.sha256sum] = "a8df94afc03e053bf802218cf03c3e086682af899cc0eca7284aab8fb1a0a9d4"

URI_aarch64_libdb-tcl-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdb-tcl-devel-5.3.28-64.el10_0.aarch64.rpm;name=aarch64_libdb-tcl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdb-tcl-devel}"
SRC_URI[aarch64_libdb-tcl-devel.sha256sum] = "574fbaa1b0152f901454af42fcac6905113b6de1f1ea89df69ebffa74d3ca515"

URI_aarch64_libdb-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libdb-utils-5.3.28-64.el10_0.aarch64.rpm;name=aarch64_libdb-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdb-utils}"
SRC_URI[aarch64_libdb-utils.sha256sum] = "bd594efa9583fa6ae9f2791eec2c7f368f34e1ea3b277ee76bbf04b9e0e40e4c"

RDEPENDS:libdb = " \
 glibc \
 "
RDEPENDS:libdb-convert-util = " \
 gdbm-libs \
 glibc \
 libgcc \
 libstdc++ \
 lmdb-libs \
 "
RDEPENDS:libdb-cxx = " \
 glibc \
 libdb \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libdb-cxx-devel = " \
 libdb-cxx \
 libdb-devel \
 "
RDEPENDS:libdb-devel = " \
 libdb \
 "
RDEPENDS:libdb-devel-doc = " \
 libdb \
 libdb-devel \
 "
RDEPENDS:libdb-devel-static = " \
 libdb-devel \
 "
RDEPENDS:libdb-sql = " \
 glibc \
 libdb \
 "
RDEPENDS:libdb-sql-devel = " \
 glibc \
 libdb-sql \
 "
RDEPENDS:libdb-tcl = " \
 glibc \
 libdb \
 "
RDEPENDS:libdb-tcl-devel = " \
 libdb-tcl \
 "
RDEPENDS:libdb-utils = " \
 glibc \
 libdb \
 "
