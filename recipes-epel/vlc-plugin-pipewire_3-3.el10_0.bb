# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vlc-plugin-pipewire"
PV = "3"
PR = "3.el10_0"
PACKAGES = " \
 vlc-plugin-pipewire \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vlc-plugin-pipewire-3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1ee396d69d79550d7e18be5444e5681785d5b2f480a12de58f4a5ccfc6c578f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-pipewire-3-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-pipewire;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-pipewire.sha256sum] = "a9d4fb4ed8849c4a8dd7232f19a7d864a9334cd3e2cf7eb49855ec0a20090186"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-pipewire-3-3.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-pipewire;unpack=0"
SRC_URI[aarch64_vlc-plugin-pipewire.sha256sum] = "2c62d6223a22ab04b9987f1cb771e115b75380532e69f16a3b46338aa2b0f5fb"

RDEPENDS:vlc-plugin-pipewire = " \
 glibc \
 pipewire-libs \
 vlc-libs \
 vlc-plugins-base \
 "
