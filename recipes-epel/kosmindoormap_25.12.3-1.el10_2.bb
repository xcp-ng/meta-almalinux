# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kosmindoormap"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kosmindoormap \
 kosmindoormap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kosmindoormap-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdfd75ecb7b4873cf2c996061cbce0bd6bdb5ffcb24e3919016b507c310af44e"

URI_x86_64_v2_kosmindoormap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kosmindoormap-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kosmindoormap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kosmindoormap}"
SRC_URI[x86_64_v2_kosmindoormap.sha256sum] = "a262898b02426165860c6e5b074a995b43849a56418498263b538c5fafd6dce7"

URI_x86_64_v2_kosmindoormap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kosmindoormap-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kosmindoormap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kosmindoormap-devel}"
SRC_URI[x86_64_v2_kosmindoormap-devel.sha256sum] = "ec061a7b8619c87c1337afef3db6f9d51792efb41d8e429bcfa62a267fa4eca6"

URI_aarch64_kosmindoormap = "${EPEL_MIRROR}/aarch64/Packages/k/kosmindoormap-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kosmindoormap;unpack=0"
SRC_URI:append = " ${URI_aarch64_kosmindoormap}"
SRC_URI[aarch64_kosmindoormap.sha256sum] = "1d60d8ccee6376c20ed7df8f682e06aa392076c7dca489b7c2d4fa36963ab125"

URI_aarch64_kosmindoormap-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kosmindoormap-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kosmindoormap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kosmindoormap-devel}"
SRC_URI[aarch64_kosmindoormap-devel.sha256sum] = "6d1eed1e79120f13ee81d46f9523a21672987d0d765ecaee72510398f64e082c"

RDEPENDS:kosmindoormap = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kservice \
 kopeninghours \
 kpublictransport \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kosmindoormap-devel = " \
 cmake-filesystem \
 kosmindoormap \
 "
