# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oci-delta"
PV = "0.3.0"
PR = "1.el10"
PACKAGES = " \
 oci-delta \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/oci-delta-0.3.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f1829ab538b44298e4360debbfa77733d2130750344cf4de79e85be2f66761f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/oci-delta-0.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_oci-delta;unpack=0"
SRC_URI[x86_64_v2_oci-delta.sha256sum] = "15ee9ad650040a662c8487161562001981fa683f759715a615d7a2ce34115981"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/oci-delta-0.3.0-1.el10.aarch64.rpm;name=aarch64_oci-delta;unpack=0"
SRC_URI[aarch64_oci-delta.sha256sum] = "cc240308021806d92c6e85a123c2152ed5bff6a8216b300871d11f7596d597fb"

RDEPENDS:oci-delta = " \
 glib2 \
 glibc \
 ostree-libs \
 "
