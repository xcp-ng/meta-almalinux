# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proptest"
PV = "1.9.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-proptest+alloc-devel \
 rust-proptest+atomic64bit-devel \
 rust-proptest+attr-macro-devel \
 rust-proptest+bit-set-devel \
 rust-proptest+default-code-coverage-devel \
 rust-proptest+default-devel \
 rust-proptest+fork-devel \
 rust-proptest+handle-panics-devel \
 rust-proptest+no_std-devel \
 rust-proptest+proptest-macro-devel \
 rust-proptest+regex-syntax-devel \
 rust-proptest+rusty-fork-devel \
 rust-proptest+std-devel \
 rust-proptest+tempfile-devel \
 rust-proptest+timeout-devel \
 rust-proptest+unstable-devel \
 rust-proptest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proptest-1.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b927b0ec7406f8e7181824131b10900b8040c7751e84ec09b305cf58eb457d7a"

URI_x86_64_v2_rust-proptest+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+alloc-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+alloc-devel}"
SRC_URI[x86_64_v2_rust-proptest+alloc-devel.sha256sum] = "80fed17b49e4c46cee381a10a54ba8d8782be61c7468d5d0ada83ea199c46492"

URI_x86_64_v2_rust-proptest+atomic64bit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+atomic64bit-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+atomic64bit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+atomic64bit-devel}"
SRC_URI[x86_64_v2_rust-proptest+atomic64bit-devel.sha256sum] = "7b9f807ea6d536325f73e50606293c15cb49bdbd092de1cbd7846d26e1fdc3db"

URI_x86_64_v2_rust-proptest+attr-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+attr-macro-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+attr-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+attr-macro-devel}"
SRC_URI[x86_64_v2_rust-proptest+attr-macro-devel.sha256sum] = "b7674ec626c12be717b70955682d58ebedba1e9a2db40e2af6eb05338e23c69f"

URI_x86_64_v2_rust-proptest+bit-set-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+bit-set-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+bit-set-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+bit-set-devel}"
SRC_URI[x86_64_v2_rust-proptest+bit-set-devel.sha256sum] = "a6ca330af389644d21bad6e0483bb7a697b5dc165105d8f8c6d7ec430d521fda"

URI_x86_64_v2_rust-proptest+default-code-coverage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+default-code-coverage-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+default-code-coverage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+default-code-coverage-devel}"
SRC_URI[x86_64_v2_rust-proptest+default-code-coverage-devel.sha256sum] = "8387c798c246f9f9006d765f500fc7c0243cac6a58862259362d3cbf08f095b5"

URI_x86_64_v2_rust-proptest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+default-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+default-devel}"
SRC_URI[x86_64_v2_rust-proptest+default-devel.sha256sum] = "14bcd0d37007f35581ad8da446353c4abb8845973f2f4b9aec7246481b71c415"

URI_x86_64_v2_rust-proptest+fork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+fork-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+fork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+fork-devel}"
SRC_URI[x86_64_v2_rust-proptest+fork-devel.sha256sum] = "e7676759d39b2f7cc5ca33947e15b3b0680ba0f53fee2b900034c8e242d2b9ce"

URI_x86_64_v2_rust-proptest+handle-panics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+handle-panics-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+handle-panics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+handle-panics-devel}"
SRC_URI[x86_64_v2_rust-proptest+handle-panics-devel.sha256sum] = "96fde046ac8b5107469a008f2080b707b4e3161f2ef523131d810bc866971b4e"

URI_x86_64_v2_rust-proptest+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+no_std-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+no_std-devel}"
SRC_URI[x86_64_v2_rust-proptest+no_std-devel.sha256sum] = "7b1dfc22b88d005b4cbd3eb7bb8cbc2a34078239a04e32d061420a4af36ae9b4"

URI_x86_64_v2_rust-proptest+proptest-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+proptest-macro-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+proptest-macro-devel}"
SRC_URI[x86_64_v2_rust-proptest+proptest-macro-devel.sha256sum] = "28f843ce44d9e65a4bf565449627dc5a25507defee41814e93542fe16d07a73d"

URI_x86_64_v2_rust-proptest+regex-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+regex-syntax-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+regex-syntax-devel}"
SRC_URI[x86_64_v2_rust-proptest+regex-syntax-devel.sha256sum] = "063638f96292a55e1d4dbf8e31e5177cb69b6d65264d285a4c2899d0a203b364"

URI_x86_64_v2_rust-proptest+rusty-fork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+rusty-fork-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+rusty-fork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+rusty-fork-devel}"
SRC_URI[x86_64_v2_rust-proptest+rusty-fork-devel.sha256sum] = "77840a0a17165fa29806683c087df4ad7640fe37189893a8a1315aced082114a"

URI_x86_64_v2_rust-proptest+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+std-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+std-devel}"
SRC_URI[x86_64_v2_rust-proptest+std-devel.sha256sum] = "36e7dd6404888559ea1d05522b1cc51aa22322ebf2f3c05d71d4c7b47a606573"

URI_x86_64_v2_rust-proptest+tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+tempfile-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+tempfile-devel}"
SRC_URI[x86_64_v2_rust-proptest+tempfile-devel.sha256sum] = "426f86f049adb28caba24a76054aab8c6bf8af9fd0fd7e94c611607819f4dce9"

URI_x86_64_v2_rust-proptest+timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+timeout-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+timeout-devel}"
SRC_URI[x86_64_v2_rust-proptest+timeout-devel.sha256sum] = "006e605d474878b08912e7d9557deef155f6873e545f06a96e90378c3581b864"

URI_x86_64_v2_rust-proptest+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+unstable-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+unstable-devel}"
SRC_URI[x86_64_v2_rust-proptest+unstable-devel.sha256sum] = "c3006ec61f09645db1e98f928207f27103183b5338c7ac1cb54470786b1666f4"

URI_x86_64_v2_rust-proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-devel-1.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-devel}"
SRC_URI[x86_64_v2_rust-proptest-devel.sha256sum] = "18e2589e0d66ef699729bc955a83738da6341a158d255d167b6cfb9afb5220d2"

URI_aarch64_rust-proptest+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+alloc-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+alloc-devel}"
SRC_URI[aarch64_rust-proptest+alloc-devel.sha256sum] = "afe753573582a5b378219daa4218069bb097a606b68fd9f083b1c95f34e08622"

URI_aarch64_rust-proptest+atomic64bit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+atomic64bit-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+atomic64bit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+atomic64bit-devel}"
SRC_URI[aarch64_rust-proptest+atomic64bit-devel.sha256sum] = "47d27f27978f79d3441299e8529e4a8ed01790193d9e311f6d50d309d8c0bdd7"

URI_aarch64_rust-proptest+attr-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+attr-macro-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+attr-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+attr-macro-devel}"
SRC_URI[aarch64_rust-proptest+attr-macro-devel.sha256sum] = "1602fd7fffd9e965a21ee5b06066661ed996dc6bbdd381b2902ec81c267991b6"

URI_aarch64_rust-proptest+bit-set-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+bit-set-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+bit-set-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+bit-set-devel}"
SRC_URI[aarch64_rust-proptest+bit-set-devel.sha256sum] = "aef2a125aad8262f3e52729d98e71378966b365856ee15650376fb1c0f618bdd"

URI_aarch64_rust-proptest+default-code-coverage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+default-code-coverage-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+default-code-coverage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+default-code-coverage-devel}"
SRC_URI[aarch64_rust-proptest+default-code-coverage-devel.sha256sum] = "cab06a47cc7e330b74605bcd9d601eefdab37c0124cd973a9144609d57186de6"

URI_aarch64_rust-proptest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+default-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+default-devel}"
SRC_URI[aarch64_rust-proptest+default-devel.sha256sum] = "1bf53d5441635524577978f9b707fc38e89af485a3361a1bdff70fc80604530e"

URI_aarch64_rust-proptest+fork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+fork-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+fork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+fork-devel}"
SRC_URI[aarch64_rust-proptest+fork-devel.sha256sum] = "2d9099cd32b274d60e8d02727496deeb1595cd5b24a4da1880373e8c7cef552e"

URI_aarch64_rust-proptest+handle-panics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+handle-panics-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+handle-panics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+handle-panics-devel}"
SRC_URI[aarch64_rust-proptest+handle-panics-devel.sha256sum] = "84e96aff3ea6e425ee96fcc70c75e80e1f853f275076ff51b6e16ee334ce31c7"

URI_aarch64_rust-proptest+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+no_std-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+no_std-devel}"
SRC_URI[aarch64_rust-proptest+no_std-devel.sha256sum] = "689d6a69c1f86c947aea1b7ecc18488ff2a779133bec46e0975bba1e6a1711dd"

URI_aarch64_rust-proptest+proptest-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+proptest-macro-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+proptest-macro-devel}"
SRC_URI[aarch64_rust-proptest+proptest-macro-devel.sha256sum] = "53d9b899fe9001c2998bbc0233951978d5ffa362c432732a68a22661cb7d0e3d"

URI_aarch64_rust-proptest+regex-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+regex-syntax-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+regex-syntax-devel}"
SRC_URI[aarch64_rust-proptest+regex-syntax-devel.sha256sum] = "008a669b1c42dcbdca4d062168f16ebf21e8874a08ebcf9bf9c8f1c8bc569b0a"

URI_aarch64_rust-proptest+rusty-fork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+rusty-fork-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+rusty-fork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+rusty-fork-devel}"
SRC_URI[aarch64_rust-proptest+rusty-fork-devel.sha256sum] = "55d042a7fcc2fa237efd739ffd3a03559564c216aefd0aa2c097185b48df006f"

URI_aarch64_rust-proptest+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+std-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+std-devel}"
SRC_URI[aarch64_rust-proptest+std-devel.sha256sum] = "42bf874f71aa5585af805d6dc73cea93c5a005cfb2e1bffd588843edde570f97"

URI_aarch64_rust-proptest+tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+tempfile-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+tempfile-devel}"
SRC_URI[aarch64_rust-proptest+tempfile-devel.sha256sum] = "48b61bf9097706e5f22fe01762fe7275ed53565c6d286b89172e376aad2ffbed"

URI_aarch64_rust-proptest+timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+timeout-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+timeout-devel}"
SRC_URI[aarch64_rust-proptest+timeout-devel.sha256sum] = "28fb56ef06c09c8f5b4ebbbf651eff75606b256a7b4278226e666120c0960012"

URI_aarch64_rust-proptest+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+unstable-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+unstable-devel}"
SRC_URI[aarch64_rust-proptest+unstable-devel.sha256sum] = "3ffc3f3d1532b844b61f40f12cb2f3634a6a3b0e733dcbba20c32a8ebca7ad6a"

URI_aarch64_rust-proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-devel-1.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-devel}"
SRC_URI[aarch64_rust-proptest-devel.sha256sum] = "13c6c3a49c40a44ceda75be104b55b187732dd1cda4e464536c464147609a5d5"

RDEPENDS:rust-proptest+alloc-devel = " \
 cargo \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+atomic64bit-devel = " \
 cargo \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+attr-macro-devel = " \
 cargo \
 rust-proptest+proptest-macro-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+bit-set-devel = " \
 cargo \
 rust-bit-set+default-devel \
 rust-bit-vec+default-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+default-code-coverage-devel = " \
 cargo \
 rust-proptest+bit-set-devel \
 rust-proptest+fork-devel \
 rust-proptest+std-devel \
 rust-proptest+timeout-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+default-devel = " \
 cargo \
 rust-proptest+bit-set-devel \
 rust-proptest+fork-devel \
 rust-proptest+std-devel \
 rust-proptest+timeout-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+fork-devel = " \
 cargo \
 rust-proptest+rusty-fork-devel \
 rust-proptest+std-devel \
 rust-proptest+tempfile-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+handle-panics-devel = " \
 cargo \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+no_std-devel = " \
 cargo \
 rust-num-traits+libm-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+proptest-macro-devel = " \
 cargo \
 rust-proptest-devel \
 rust-proptest-macro+default-devel \
 "
RDEPENDS:rust-proptest+regex-syntax-devel = " \
 cargo \
 rust-proptest-devel \
 rust-regex-syntax+default-devel \
 "
RDEPENDS:rust-proptest+rusty-fork-devel = " \
 cargo \
 rust-proptest-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-proptest+std-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-proptest+regex-syntax-devel \
 rust-proptest-devel \
 rust-rand0.9+os_rng-devel \
 rust-rand0.9+std-devel \
 "
RDEPENDS:rust-proptest+tempfile-devel = " \
 cargo \
 rust-proptest-devel \
 rust-tempfile+default-devel \
 "
RDEPENDS:rust-proptest+timeout-devel = " \
 cargo \
 rust-proptest+fork-devel \
 rust-proptest-devel \
 rust-rusty-fork+timeout-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-proptest+unstable-devel = " \
 cargo \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-num-traits-devel \
 rust-rand0.9+alloc-devel \
 rust-rand0.9-devel \
 rust-rand_chacha0.9-devel \
 rust-rand_xorshift0.4+default-devel \
 rust-unarray+default-devel \
 "
