# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ripemd"
PV = "0.1.3"
PR = "4.el10_2"
PACKAGES = " \
 rust-ripemd+default-devel \
 rust-ripemd+oid-devel \
 rust-ripemd+std-devel \
 rust-ripemd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ripemd-0.1.3-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec83424e6ac2e9217e63cf82581cac02a5cce05a19b81d75ae22f204689ccd6c"

URI_x86_64_v2_rust-ripemd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ripemd+default-devel-0.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ripemd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ripemd+default-devel}"
SRC_URI[x86_64_v2_rust-ripemd+default-devel.sha256sum] = "468fae23b0a5b7455fdc314fa0612bacec92760817230af0a273e78717fc3300"

URI_x86_64_v2_rust-ripemd+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ripemd+oid-devel-0.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ripemd+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ripemd+oid-devel}"
SRC_URI[x86_64_v2_rust-ripemd+oid-devel.sha256sum] = "9430f73551a005df032ebf6c6c472c4b7bf3df45a9cb65759caab1248656804d"

URI_x86_64_v2_rust-ripemd+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ripemd+std-devel-0.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ripemd+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ripemd+std-devel}"
SRC_URI[x86_64_v2_rust-ripemd+std-devel.sha256sum] = "2cfdcba6a00fcb8031301f29fe5a7599b3c13ae54c70785c096f6aaca86f2db6"

URI_x86_64_v2_rust-ripemd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ripemd-devel-0.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ripemd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ripemd-devel}"
SRC_URI[x86_64_v2_rust-ripemd-devel.sha256sum] = "503ce3a5486e7766e08222af12ed52b346fef967d15426ead2d25cfb44bf7fd8"

URI_aarch64_rust-ripemd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ripemd+default-devel-0.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-ripemd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ripemd+default-devel}"
SRC_URI[aarch64_rust-ripemd+default-devel.sha256sum] = "55c3456682a208f882e4baa6684e5acf8b2f7eeb8fcfafd88a43ddc406f6a4a6"

URI_aarch64_rust-ripemd+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ripemd+oid-devel-0.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-ripemd+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ripemd+oid-devel}"
SRC_URI[aarch64_rust-ripemd+oid-devel.sha256sum] = "8d5c7bc0d9e8b100869bce337104b3d218ec3635371cdf879596cf8ecd2834d7"

URI_aarch64_rust-ripemd+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ripemd+std-devel-0.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-ripemd+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ripemd+std-devel}"
SRC_URI[aarch64_rust-ripemd+std-devel.sha256sum] = "ba1566b9d66b8442efbf33d3be8382ebb631d0657386cd8e4cfa54f8b70afc3d"

URI_aarch64_rust-ripemd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ripemd-devel-0.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-ripemd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ripemd-devel}"
SRC_URI[aarch64_rust-ripemd-devel.sha256sum] = "523ded036d67f382eec53efd1f10faac854544826df04505b2607e5c7c0c4742"

RDEPENDS:rust-ripemd+default-devel = " \
 cargo \
 rust-ripemd+std-devel \
 rust-ripemd-devel \
 "
RDEPENDS:rust-ripemd+oid-devel = " \
 cargo \
 rust-digest0.10+oid-devel \
 rust-ripemd-devel \
 "
RDEPENDS:rust-ripemd+std-devel = " \
 cargo \
 rust-digest0.10+std-devel \
 rust-ripemd-devel \
 "
RDEPENDS:rust-ripemd-devel = " \
 cargo \
 rust-digest0.10+default-devel \
 "
