# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audacious"
PV = "4.4.2"
PR = "2.el10_1"
PACKAGES = " \
 audacious \
 audacious-devel \
 audacious-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/audacious-4.4.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b40328b3aa4858a13f299936adf5cd0c2989ee70d990821de3cfa2f4de87bf4"

URI_x86_64_v2_audacious = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audacious-4.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audacious;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audacious}"
SRC_URI[x86_64_v2_audacious.sha256sum] = "50c9a9a0ce42526e3b5aa84e42579eb15543602c6aa1af8577f4882c69fca66e"

URI_x86_64_v2_audacious-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audacious-devel-4.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audacious-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audacious-devel}"
SRC_URI[x86_64_v2_audacious-devel.sha256sum] = "1eb4ffc2c67d92faa06b3dc4d5ba14905652eb15f6906af84be681667b594061"

URI_x86_64_v2_audacious-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audacious-libs-4.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audacious-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audacious-libs}"
SRC_URI[x86_64_v2_audacious-libs.sha256sum] = "9592d9b0b60ba8d3d8121b564b7a53377824e7594b27e99a9f05b21ec0d490e4"

URI_aarch64_audacious = "${EPEL_MIRROR}/aarch64/Packages/a/audacious-4.4.2-2.el10_1.aarch64.rpm;name=aarch64_audacious;unpack=0"
SRC_URI:append = " ${URI_aarch64_audacious}"
SRC_URI[aarch64_audacious.sha256sum] = "ef7bc788613c6662795f692465cb12c90e56ed9d9b119eb091190c16b5c3f0f2"

URI_aarch64_audacious-devel = "${EPEL_MIRROR}/aarch64/Packages/a/audacious-devel-4.4.2-2.el10_1.aarch64.rpm;name=aarch64_audacious-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_audacious-devel}"
SRC_URI[aarch64_audacious-devel.sha256sum] = "50d518ddd8e4d57e7ee75de5e2e0ec1ab5dbb44b53ab03906d0440e8b9003059"

URI_aarch64_audacious-libs = "${EPEL_MIRROR}/aarch64/Packages/a/audacious-libs-4.4.2-2.el10_1.aarch64.rpm;name=aarch64_audacious-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_audacious-libs}"
SRC_URI[aarch64_audacious-libs.sha256sum] = "8260a34526b9780362d6cf040ac671609f686c3229fbcb6092ac7bc87a3b20d9"

RDEPENDS:audacious = " \
 audacious-libs \
 audacious-plugins \
 glib2 \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 qt6-qtsvg \
 "
RDEPENDS:audacious-devel = " \
 audacious-libs \
 glib2-devel \
 gtk3-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:audacious-libs = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libgcc \
 libstdc++ \
 pango \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
