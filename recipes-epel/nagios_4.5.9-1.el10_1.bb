# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nagios"
PV = "4.5.9"
PR = "1.el10_1"
PACKAGES = " \
 nagios \
 nagios-common \
 nagios-contrib \
 nagios-devel \
 nagios-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nagios-4.5.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f776b92ef556711afde5fd530897256bfae8d625a831e3e5a72cca43419499a"

URI_x86_64_v2_nagios = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-4.5.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios}"
SRC_URI[x86_64_v2_nagios.sha256sum] = "b606b18abaa5e4d12df0f6bdeda4bc1e7d38298a3c9e1482702b5c23ae90264c"

URI_x86_64_v2_nagios-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-common-4.5.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-common}"
SRC_URI[x86_64_v2_nagios-common.sha256sum] = "cb680763faa54667034d694333c5355f5c69c8c4a0f7a05b3f9222bdf2f601c8"

URI_x86_64_v2_nagios-contrib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-contrib-4.5.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-contrib}"
SRC_URI[x86_64_v2_nagios-contrib.sha256sum] = "c3c8fe6c9eebe30b25808be3bdc619b72d8bedfaa6d1dea0d502e74be7f9512d"

URI_x86_64_v2_nagios-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-devel-4.5.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-devel}"
SRC_URI[x86_64_v2_nagios-devel.sha256sum] = "6a5f820cfdd4200b208e088aa2623ff190eb565e146b30d70f2c7a4bb9595ee2"

URI_x86_64_v2_nagios-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-selinux-4.5.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nagios-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-selinux}"
SRC_URI[x86_64_v2_nagios-selinux.sha256sum] = "b06fb7deee2bf7e6c53f32ddaa80775b061c7ddef329233fe6434758f3c60a66"

URI_aarch64_nagios = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-4.5.9-1.el10_1.aarch64.rpm;name=aarch64_nagios;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios}"
SRC_URI[aarch64_nagios.sha256sum] = "93280118e0bca8e3cba2e4dcc977a7238781f0b0feb54ae6c0c3f4a09c878f4b"

URI_aarch64_nagios-common = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-common-4.5.9-1.el10_1.aarch64.rpm;name=aarch64_nagios-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-common}"
SRC_URI[aarch64_nagios-common.sha256sum] = "92246178bda515a42ff8a8bdc2887bbcd63004866e7370770e4012450e283bf7"

URI_aarch64_nagios-contrib = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-contrib-4.5.9-1.el10_1.aarch64.rpm;name=aarch64_nagios-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-contrib}"
SRC_URI[aarch64_nagios-contrib.sha256sum] = "4b1ff79660980e49375057469cea4810c520538fc8c46dc8e6d28b3b37f7e2db"

URI_aarch64_nagios-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-devel-4.5.9-1.el10_1.aarch64.rpm;name=aarch64_nagios-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-devel}"
SRC_URI[aarch64_nagios-devel.sha256sum] = "e9bf5847b5b6aea446dfca2fc918c205e7d4c24d10b03c6467e5a37e078d16de"

URI_aarch64_nagios-selinux = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-selinux-4.5.9-1.el10_1.noarch.rpm;name=aarch64_nagios-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-selinux}"
SRC_URI[aarch64_nagios-selinux.sha256sum] = "cc42903ad985a0a8f705571189b1a468d8278c96b72f855b8d81b56b339eada2"

RDEPENDS:nagios = " \
 bash \
 gd \
 glibc \
 httpd \
 nagios-common \
 nagios-plugins-disk \
 nagios-plugins-http \
 nagios-plugins-load \
 nagios-plugins-ping \
 nagios-plugins-procs \
 nagios-plugins-ssh \
 nagios-plugins-swap \
 nagios-plugins-users \
 nagios-selinux \
 openssl-libs \
 php \
 s-nail \
 "
RDEPENDS:nagios-common = " \
 shadow-utils \
 "
RDEPENDS:nagios-contrib = " \
 glibc \
 nagios \
 perl-File-Basename \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:nagios-devel = " \
 nagios \
 "
RDEPENDS:nagios-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
