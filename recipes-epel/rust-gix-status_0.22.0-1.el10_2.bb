# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-status"
PV = "0.22.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-status+default-devel \
 rust-gix-status+document-features-devel \
 rust-gix-status+worktree-rewrites-devel \
 rust-gix-status-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-status-0.22.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6cbab5d44a4c11f8e72419cfac1710c34557690071aa2ca956d5d553d81fd92"

URI_x86_64_v2_rust-gix-status+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+default-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+default-devel}"
SRC_URI[x86_64_v2_rust-gix-status+default-devel.sha256sum] = "51349aa8b8b4a2adddf412d585fa5da0d9ec957bc12da09d7e403a0b90882969"

URI_x86_64_v2_rust-gix-status+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+document-features-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-status+document-features-devel.sha256sum] = "d00232df53b5eabdc3d437be2c09538ed729002982bb84062b5cd451dcca62b6"

URI_x86_64_v2_rust-gix-status+worktree-rewrites-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+worktree-rewrites-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+worktree-rewrites-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+worktree-rewrites-devel}"
SRC_URI[x86_64_v2_rust-gix-status+worktree-rewrites-devel.sha256sum] = "e35aab0826117bf0329e6b008b25975886d42f273495ef7422b925d033bc9393"

URI_x86_64_v2_rust-gix-status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status-devel}"
SRC_URI[x86_64_v2_rust-gix-status-devel.sha256sum] = "e90bba91e30ba6275dd7d9b5c08da78fd45eddc3285434f9ced493d8ffd929f5"

URI_aarch64_rust-gix-status+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+default-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-status+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+default-devel}"
SRC_URI[aarch64_rust-gix-status+default-devel.sha256sum] = "70b4df82c1234c0224887c264c18409a69579b7e02a09f7bdc5dee0707d92b4f"

URI_aarch64_rust-gix-status+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+document-features-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-status+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+document-features-devel}"
SRC_URI[aarch64_rust-gix-status+document-features-devel.sha256sum] = "aff81dc7ae724cf8b2847c3c5d80085baf85aa5ae386b943b5d25514584c2791"

URI_aarch64_rust-gix-status+worktree-rewrites-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+worktree-rewrites-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-status+worktree-rewrites-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+worktree-rewrites-devel}"
SRC_URI[aarch64_rust-gix-status+worktree-rewrites-devel.sha256sum] = "d1598f1b7e8d97322f87db8085f0e4415e9ad80915b99304f7bdd7b7859adaab"

URI_aarch64_rust-gix-status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status-devel}"
SRC_URI[aarch64_rust-gix-status-devel.sha256sum] = "c11daa64cf37b04aa8c1136625e413b9540d67f6d2f3abd5183288f041dba864"

RDEPENDS:rust-gix-status+default-devel = " \
 cargo \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status+worktree-rewrites-devel = " \
 cargo \
 rust-gix-diff+blob-devel \
 rust-gix-diff-devel \
 rust-gix-dir+default-devel \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-filetime+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-thiserror+default-devel \
 "
