# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdal3.4"
PV = "3.4.3"
PR = "5.el10_2"
PACKAGES = " \
 gdal3.4 \
 gdal3.4-devel \
 gdal3.4-doc \
 gdal3.4-java \
 gdal3.4-javadoc \
 gdal3.4-libs \
 gdal3.4-perl \
 gdal3.4-python-tools \
 python3-gdal3.4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gdal3.4-3.4.3-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba7a3dabc4eb46c4e791c131ed9e65d12f5de53731ca8e0427d48d2d32b45053"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - gdal3.4-java: libgeos_c.so.1()(64bit)
# - gdal3.4-libs: libgeos_c.so.1()(64bit)

URI_x86_64_v2_gdal3.4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal3.4-3.4.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdal3.4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal3.4}"
SRC_URI[x86_64_v2_gdal3.4.sha256sum] = "938a493864f652dabf2ceaeaff6965430ec86f262c0703e1848f16e6d81c07b5"

URI_x86_64_v2_gdal3.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal3.4-devel-3.4.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdal3.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal3.4-devel}"
SRC_URI[x86_64_v2_gdal3.4-devel.sha256sum] = "4a3c3db7ba921fb27802e1610032fffa3733cf8ac30289f82a381ef28396e1c2"
RPROVIDES:gdal3.4-devel:x86_64_v2 = "virtual/pkgconfig_gdal_"

URI_x86_64_v2_gdal3.4-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal3.4-doc-3.4.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gdal3.4-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal3.4-doc}"
SRC_URI[x86_64_v2_gdal3.4-doc.sha256sum] = "8af94364231b80245a5dd05864d83b8ba6fcb7aedb30544087d3b8df7f5be5f4"

URI_x86_64_v2_gdal3.4-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal3.4-java-3.4.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdal3.4-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal3.4-java}"
SRC_URI[x86_64_v2_gdal3.4-java.sha256sum] = "cd42bd2387b1dbbf46f90389a8fe9165779d89f07ed5322207bcd509f3a7b2b5"

URI_x86_64_v2_gdal3.4-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal3.4-javadoc-3.4.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gdal3.4-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal3.4-javadoc}"
SRC_URI[x86_64_v2_gdal3.4-javadoc.sha256sum] = "ef4192ff5a7a0574615c2ea5e25e41f95140d0d530142cfb36fb345703ac48cf"

URI_x86_64_v2_gdal3.4-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal3.4-libs-3.4.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdal3.4-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal3.4-libs}"
SRC_URI[x86_64_v2_gdal3.4-libs.sha256sum] = "8c56eb13318a9ec591cf0dd481e92df93077acdc5e03c4e42599d6a8bb05d0de"

URI_x86_64_v2_gdal3.4-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal3.4-perl-3.4.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdal3.4-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal3.4-perl}"
SRC_URI[x86_64_v2_gdal3.4-perl.sha256sum] = "a6c7b20cd50af5d4bab67b7801e3c3514f1caa52803aca71a969cf15922abf82"

URI_x86_64_v2_gdal3.4-python-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal3.4-python-tools-3.4.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdal3.4-python-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal3.4-python-tools}"
SRC_URI[x86_64_v2_gdal3.4-python-tools.sha256sum] = "d28421a87b3932419e9f73b541292a0ba92431dbb2d378098985c7c4bf4fc077"

URI_x86_64_v2_python3-gdal3.4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gdal3.4-3.4.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-gdal3.4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gdal3.4}"
SRC_URI[x86_64_v2_python3-gdal3.4.sha256sum] = "e0754d9dc281d175851524f410554937c2fc53f2b23728c31c1e923eef71606b"

URI_aarch64_gdal3.4 = "${EPEL_MIRROR}/aarch64/Packages/g/gdal3.4-3.4.3-5.el10_2.aarch64.rpm;name=aarch64_gdal3.4;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal3.4}"
SRC_URI[aarch64_gdal3.4.sha256sum] = "ac3a04041181f91201b401205812589c02a0ed254406f9c97d2d0452a55306ed"

URI_aarch64_gdal3.4-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gdal3.4-devel-3.4.3-5.el10_2.aarch64.rpm;name=aarch64_gdal3.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal3.4-devel}"
SRC_URI[aarch64_gdal3.4-devel.sha256sum] = "4a245f3689f5a74193e241b672220c9d7ddda86c40603416cdd4f6456d4dd3c4"
RPROVIDES:gdal3.4-devel:aarch64 = "virtual/pkgconfig_gdal_"

URI_aarch64_gdal3.4-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gdal3.4-doc-3.4.3-5.el10_2.noarch.rpm;name=aarch64_gdal3.4-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal3.4-doc}"
SRC_URI[aarch64_gdal3.4-doc.sha256sum] = "a9897dc10d15a6be014c47f7768703e79a2991667c6e0c1a51ba5942978d9fbc"

URI_aarch64_gdal3.4-java = "${EPEL_MIRROR}/aarch64/Packages/g/gdal3.4-java-3.4.3-5.el10_2.aarch64.rpm;name=aarch64_gdal3.4-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal3.4-java}"
SRC_URI[aarch64_gdal3.4-java.sha256sum] = "59cfff42beddc26b2a0b3096ef3527ad325335a90c4b9bcf1f50173fe4ce1ffa"

URI_aarch64_gdal3.4-javadoc = "${EPEL_MIRROR}/aarch64/Packages/g/gdal3.4-javadoc-3.4.3-5.el10_2.noarch.rpm;name=aarch64_gdal3.4-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal3.4-javadoc}"
SRC_URI[aarch64_gdal3.4-javadoc.sha256sum] = "ed846d68faca28d7876ce5e8a27adb921e0cb7f46c4469533c1d60cc07d32bfc"

URI_aarch64_gdal3.4-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gdal3.4-libs-3.4.3-5.el10_2.aarch64.rpm;name=aarch64_gdal3.4-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal3.4-libs}"
SRC_URI[aarch64_gdal3.4-libs.sha256sum] = "8ad21b5d5398da3aff2298e1a9f4574ca8e884bc01d5b538ec406e1d93c63d8d"

URI_aarch64_gdal3.4-perl = "${EPEL_MIRROR}/aarch64/Packages/g/gdal3.4-perl-3.4.3-5.el10_2.aarch64.rpm;name=aarch64_gdal3.4-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal3.4-perl}"
SRC_URI[aarch64_gdal3.4-perl.sha256sum] = "25af4a050503c46cc8ef6770240074162c938b800cf9652ed975b4f426f2ce96"

URI_aarch64_gdal3.4-python-tools = "${EPEL_MIRROR}/aarch64/Packages/g/gdal3.4-python-tools-3.4.3-5.el10_2.aarch64.rpm;name=aarch64_gdal3.4-python-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal3.4-python-tools}"
SRC_URI[aarch64_gdal3.4-python-tools.sha256sum] = "85d5cbd061e85605dc38d5dc69ea265d8856184bf03cbea3abb0f5354fff6179"

URI_aarch64_python3-gdal3.4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gdal3.4-3.4.3-5.el10_2.aarch64.rpm;name=aarch64_python3-gdal3.4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gdal3.4}"
SRC_URI[aarch64_python3-gdal3.4.sha256sum] = "ca8172a7074284970c4dc363cb3cc9b2d4d7dc49ac404868f884e4bc55719d72"

RDEPENDS:gdal3.4 = " \
 bash \
 gdal3.4-libs \
 glibc \
 gpsbabel \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gdal3.4-devel = " \
 bash \
 gdal3.4-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:gdal3.4-doc = " \
 "
RDEPENDS:gdal3.4-java:x86_64_v2 = " \
 armadillo \
 cfitsio \
 expat \
 freexl \
 gdal3.4-libs \
 giflib \
 glibc \
 hdf5 \
 javapackages-filesystem \
 javapackages-tools \
 json-c \
 libdap \
 libgcc \
 libgeotiff \
 libgta \
 libjpeg-turbo \
 libkml \
 libpng \
 libpq \
 libspatialite \
 libstdc++ \
 libtiff \
 libwebp \
 libxml2 \
 libzstd \
 mariadb-connector-c \
 netcdf \
 ogdi \
 openjpeg2 \
 openssl-libs \
 pcre2 \
 poppler \
 proj \
 sqlite-libs \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 virtual/libdf.so.0___64bit_ \
 virtual/libmfhdf.so.0___64bit_ \
 xerces-c \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdal3.4-java:aarch64 = " \
 armadillo \
 cfitsio \
 expat \
 freexl \
 gdal3.4-libs \
 geos \
 giflib \
 glibc \
 hdf5 \
 javapackages-filesystem \
 javapackages-tools \
 json-c \
 libdap \
 libgcc \
 libgeotiff \
 libgta \
 libjpeg-turbo \
 libkml \
 libpng \
 libpq \
 libspatialite \
 libstdc++ \
 libtiff \
 libwebp \
 libxml2 \
 libzstd \
 mariadb-connector-c \
 netcdf \
 ogdi \
 openjpeg2 \
 openssl-libs \
 pcre2 \
 poppler \
 proj \
 sqlite-libs \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 virtual/libdf.so.0___64bit_ \
 virtual/libmfhdf.so.0___64bit_ \
 xerces-c \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdal3.4-javadoc = " \
 javapackages-filesystem \
 javapackages-tools \
 "
RDEPENDS:gdal3.4-libs:x86_64_v2 = " \
 armadillo \
 cfitsio \
 expat \
 freexl \
 giflib \
 glibc \
 hdf5 \
 json-c \
 libdap \
 libgcc \
 libgeotiff \
 libgta \
 libjpeg-turbo \
 libkml \
 libpng \
 libpq \
 libspatialite \
 libstdc++ \
 libtiff \
 libwebp \
 libxml2 \
 libzstd \
 mariadb-connector-c \
 netcdf \
 ogdi \
 openjpeg2 \
 openssl-libs \
 pcre2 \
 poppler \
 proj \
 sqlite-libs \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 virtual/libdf.so.0___64bit_ \
 virtual/libmfhdf.so.0___64bit_ \
 xerces-c \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdal3.4-libs:aarch64 = " \
 armadillo \
 cfitsio \
 expat \
 freexl \
 geos \
 giflib \
 glibc \
 hdf5 \
 json-c \
 libdap \
 libgcc \
 libgeotiff \
 libgta \
 libjpeg-turbo \
 libkml \
 libpng \
 libpq \
 libspatialite \
 libstdc++ \
 libtiff \
 libwebp \
 libxml2 \
 libzstd \
 mariadb-connector-c \
 netcdf \
 ogdi \
 openjpeg2 \
 openssl-libs \
 pcre2 \
 poppler \
 proj \
 sqlite-libs \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 virtual/libdf.so.0___64bit_ \
 virtual/libmfhdf.so.0___64bit_ \
 xerces-c \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdal3.4-perl = " \
 gdal3.4-libs \
 gdal3.4-perl \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Encode \
 perl-Exporter \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-base \
 perl-libs \
 perl-vars \
 "
RDEPENDS:gdal3.4-python-tools = " \
 python3 \
 python3-gdal3.4 \
 "
RDEPENDS:python3-gdal3.4 = " \
 gdal3.4-libs \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-numpy \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/pkgconfig_gdal_"

PROVIDES:append:aarch64 = " rpm/virtual/pkgconfig_gdal_"
