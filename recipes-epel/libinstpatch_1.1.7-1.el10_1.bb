# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libinstpatch"
PV = "1.1.7"
PR = "1.el10_1"
PACKAGES = " \
 libinstpatch \
 libinstpatch-devel \
 libinstpatch-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libinstpatch-1.1.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7e1901e1fb35a34c6a40119d4b52b0e440aaeea7e0b9cc12bbb5328f7170ce0"

URI_x86_64_v2_libinstpatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libinstpatch-1.1.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libinstpatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libinstpatch}"
SRC_URI[x86_64_v2_libinstpatch.sha256sum] = "a7865f9875f9e54cbb9533a2f42c00120548ef06a34c2796b1e7899a9ff2511a"

URI_x86_64_v2_libinstpatch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libinstpatch-devel-1.1.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libinstpatch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libinstpatch-devel}"
SRC_URI[x86_64_v2_libinstpatch-devel.sha256sum] = "edf23e3928833560d54e2acbd2a25228d16d089c50024e4e7be77abed8780aae"

URI_x86_64_v2_libinstpatch-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libinstpatch-doc-1.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libinstpatch-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libinstpatch-doc}"
SRC_URI[x86_64_v2_libinstpatch-doc.sha256sum] = "aac358c751dc9da435f5eae1615f9efc4c5406d3aaaa14e65d3e8ab110ea7586"

URI_aarch64_libinstpatch = "${EPEL_MIRROR}/aarch64/Packages/l/libinstpatch-1.1.7-1.el10_1.aarch64.rpm;name=aarch64_libinstpatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_libinstpatch}"
SRC_URI[aarch64_libinstpatch.sha256sum] = "5bc5830c27b61209456bf03c41187c926dcd9a73e0e21a6e3a49bdf557fd4ee5"

URI_aarch64_libinstpatch-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libinstpatch-devel-1.1.7-1.el10_1.aarch64.rpm;name=aarch64_libinstpatch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libinstpatch-devel}"
SRC_URI[aarch64_libinstpatch-devel.sha256sum] = "75fb5a4108c39c1a17d639cbbbdf7b4d112015f07e9bbd0ffc8edf9ae8e9e31d"

URI_aarch64_libinstpatch-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libinstpatch-doc-1.1.7-1.el10_1.noarch.rpm;name=aarch64_libinstpatch-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libinstpatch-doc}"
SRC_URI[aarch64_libinstpatch-doc.sha256sum] = "af63f0cf5a818f9ac0151980266a6310d2f8b34e0abf01fbd02e44ade575e0fd"

RDEPENDS:libinstpatch = " \
 glib2 \
 glibc \
 libsndfile \
 "
RDEPENDS:libinstpatch-devel = " \
 glib2-devel \
 libinstpatch \
 libsndfile-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libinstpatch-doc = " \
 "
