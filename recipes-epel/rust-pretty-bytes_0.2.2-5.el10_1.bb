# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pretty-bytes"
PV = "0.2.2"
PR = "5.el10_1"
PACKAGES = " \
 pretty-bytes \
 rust-pretty-bytes+default-devel \
 rust-pretty-bytes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pretty-bytes-0.2.2-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbcc6fc32f2268df315b0f3eb213f56fc41c3aad00ed9d96f62d2540faa2bece"

URI_x86_64_v2_pretty-bytes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pretty-bytes-0.2.2-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pretty-bytes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pretty-bytes}"
SRC_URI[x86_64_v2_pretty-bytes.sha256sum] = "a2099fd3b2147be73f124e9c081e7534645e1ebf5365fdb3811b4c5db86b4a11"

URI_x86_64_v2_rust-pretty-bytes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pretty-bytes+default-devel-0.2.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pretty-bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pretty-bytes+default-devel}"
SRC_URI[x86_64_v2_rust-pretty-bytes+default-devel.sha256sum] = "c52724ed209e1df69d08e6211388df2144eb0c7003401d7e1a8d664ad01b9635"

URI_x86_64_v2_rust-pretty-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pretty-bytes-devel-0.2.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pretty-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pretty-bytes-devel}"
SRC_URI[x86_64_v2_rust-pretty-bytes-devel.sha256sum] = "e2d9cde49c15134d90329ad48c7483e0bd2689ae06d28441c34001943ab4660f"

URI_aarch64_pretty-bytes = "${EPEL_MIRROR}/aarch64/Packages/p/pretty-bytes-0.2.2-5.el10_1.aarch64.rpm;name=aarch64_pretty-bytes;unpack=0"
SRC_URI:append = " ${URI_aarch64_pretty-bytes}"
SRC_URI[aarch64_pretty-bytes.sha256sum] = "d3cb4a1c4776f6b8f4913be17e58c88140085b0b3bb23f487a79c673b012a04e"

URI_aarch64_rust-pretty-bytes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pretty-bytes+default-devel-0.2.2-5.el10_1.noarch.rpm;name=aarch64_rust-pretty-bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pretty-bytes+default-devel}"
SRC_URI[aarch64_rust-pretty-bytes+default-devel.sha256sum] = "4761d28484ced950c5c1211aec3120558991e0d92e12e4ac73fac9f2e2ed5027"

URI_aarch64_rust-pretty-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pretty-bytes-devel-0.2.2-5.el10_1.noarch.rpm;name=aarch64_rust-pretty-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pretty-bytes-devel}"
SRC_URI[aarch64_rust-pretty-bytes-devel.sha256sum] = "9bd4ee285d8b82cebdc43a5bcaaa57f04cede565939c833167b24c68ae431a8b"

RDEPENDS:pretty-bytes = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-pretty-bytes+default-devel = " \
 cargo \
 rust-pretty-bytes-devel \
 "
RDEPENDS:rust-pretty-bytes-devel = " \
 cargo \
 rust-getopts+default-devel \
 "
