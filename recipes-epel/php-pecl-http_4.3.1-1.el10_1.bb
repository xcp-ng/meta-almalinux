# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-http"
PV = "4.3.1"
PR = "1.el10_1"
PACKAGES = " \
 php-pecl-http \
 php-pecl-http-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-http-4.3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58decbf92a859abe629017fe557b159825a4f88db49d37a50ef470de23fd54e9"

URI_x86_64_v2_php-pecl-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-http-4.3.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-http}"
SRC_URI[x86_64_v2_php-pecl-http.sha256sum] = "152ad704f87d50637b718ee55ecc0552e7a854741072687b868f9d32059f657b"

URI_x86_64_v2_php-pecl-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-http-devel-4.3.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-http-devel}"
SRC_URI[x86_64_v2_php-pecl-http-devel.sha256sum] = "64d35ded42793abaea29221c7eea32c2342fd3bd068be4d7eeac7ca4c79d787e"

URI_aarch64_php-pecl-http = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-http-4.3.1-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-http}"
SRC_URI[aarch64_php-pecl-http.sha256sum] = "5262ac5a8cd6fc0931bb7c281c4fc9c6b65234c2f0a538ca8dff560e77ec1d96"

URI_aarch64_php-pecl-http-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-http-devel-4.3.1-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-http-devel}"
SRC_URI[aarch64_php-pecl-http-devel.sha256sum] = "4be38e3bca601760a5b037bc6e64f6d70dfec4879d4d9d635ea7b4d8001c1a5f"

RDEPENDS:php-pecl-http = " \
 glibc \
 libbrotli \
 libevent \
 libicu \
 openssl-libs \
 php-common \
 php-pecl-raphf \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:php-pecl-http-devel = " \
 php-devel \
 php-pecl-http \
 "
