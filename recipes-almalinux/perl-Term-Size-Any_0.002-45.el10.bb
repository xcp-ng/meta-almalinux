# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Term-Size-Any"
PV = "0.002"
PR = "45.el10"
PACKAGES = " \
 perl-Term-Size-Any \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Term-Size-Any-0.002-45.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c176b4cbaeae3aa98f3a74efc92737e670456e5ebacfec2c1f1dece9827baea"

URI_x86_64_v2_perl-Term-Size-Any = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Term-Size-Any-0.002-45.el10.noarch.rpm;name=x86_64_v2_perl-Term-Size-Any;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Term-Size-Any}"
SRC_URI[x86_64_v2_perl-Term-Size-Any.sha256sum] = "64117b34781488da7872adb50d6c4922eaf2eb4c1c0361d0545530e7258955b5"

URI_aarch64_perl-Term-Size-Any = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Term-Size-Any-0.002-45.el10.noarch.rpm;name=aarch64_perl-Term-Size-Any;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Term-Size-Any}"
SRC_URI[aarch64_perl-Term-Size-Any.sha256sum] = "64117b34781488da7872adb50d6c4922eaf2eb4c1c0361d0545530e7258955b5"

RDEPENDS:perl-Term-Size-Any = " \
 perl-Term-Size-Perl \
 perl-libs \
 perl-vars \
 "
