# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dkms"
PV = "3.4.1"
PR = "1.el10_1"
PACKAGES = " \
 dkms \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dkms-3.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cd4fcbd4b9a0b5ff7ed74440394695b0ae080ec9630f72917ac9f9e248caf7e"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - dkms: (kernel-64k-devel-matched if kernel-64k-core)
# - dkms: (kernel-rt-debug-devel if kernel-rt-debug-core)
# - dkms: (kernel-rt-devel if kernel-rt-core)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - dkms: (kernel-rt-debug-devel if kernel-rt-debug-core)
# - dkms: (kernel-rt-devel if kernel-rt-core)

URI_x86_64_v2_dkms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dkms-3.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_dkms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dkms}"
SRC_URI[x86_64_v2_dkms.sha256sum] = "f9ee8d9d85d2f2e8e18d96c6503e14f7af6c75ec489540eb870ced08739e0f16"

URI_aarch64_dkms = "${EPEL_MIRROR}/aarch64/Packages/d/dkms-3.4.1-1.el10_1.noarch.rpm;name=aarch64_dkms;unpack=0"
SRC_URI:append = " ${URI_aarch64_dkms}"
SRC_URI[aarch64_dkms.sha256sum] = "4f039e3f774bf42e17e80a6cadf587e6e4fcc2eecf468afd5f71cae55692ce7b"

RDEPENDS:dkms:x86_64_v2 = " \
 bash \
 cpio \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 gzip \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmod \
 make \
 patch \
 sed \
 tar \
 virtual/coreutils \
 which \
"
RDEPENDS:dkms:aarch64 = " \
 bash \
 cpio \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 gzip \
 kernel-64k-devel-matched \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmod \
 make \
 patch \
 sed \
 tar \
 virtual/coreutils \
 which \
"
