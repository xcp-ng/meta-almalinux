# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sip6"
PV = "6.14.0"
PR = "1.el10"
PACKAGES = " \
 sip6 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sip6-6.14.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ab8c40c54efa033b1be850fdceed9ce13ed15ab0b164e9665c5752ec4fc57f33"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sip6-6.14.0-1.el10.noarch.rpm;name=x86_64_v2_sip6;unpack=0"
SRC_URI[x86_64_v2_sip6.sha256sum] = "3c875b549dba32c210e48b738a439ba9f6b22ee7d09a5f803e8d45d28b1b690c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sip6-6.14.0-1.el10.noarch.rpm;name=aarch64_sip6;unpack=0"
SRC_URI[aarch64_sip6.sha256sum] = "3c875b549dba32c210e48b738a439ba9f6b22ee7d09a5f803e8d45d28b1b690c"

RDEPENDS:sip6 = " \
 python3 \
 python3-packaging \
 python3-setuptools \
 "
