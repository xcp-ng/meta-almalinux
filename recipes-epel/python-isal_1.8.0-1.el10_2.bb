# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-isal"
PV = "1.8.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-isal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-isal-1.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc00c1006a8e6e286877ccca0b93405bf100a766fec0afc31721e2b5a23bca08"

URI_x86_64_v2_python3-isal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-isal-1.8.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-isal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-isal}"
SRC_URI[x86_64_v2_python3-isal.sha256sum] = "8dc3daf6337dd0296df6aa73c8bb7620faeb21a9f9663841a11f886c4f1fbea1"

URI_aarch64_python3-isal = "${EPEL_MIRROR}/aarch64/Packages/p/python3-isal-1.8.0-1.el10_2.aarch64.rpm;name=aarch64_python3-isal;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-isal}"
SRC_URI[aarch64_python3-isal.sha256sum] = "39ccc4f073450468e986408e8ab35b75302afd649be8ae76c0c89c357bc2b19a"

RDEPENDS:python3-isal = " \
 glibc \
 isa-l \
 python3 \
 "
