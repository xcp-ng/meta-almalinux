# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c2esp"
PV = "2.7"
PR = "34.el10"
PACKAGES = " \
 c2esp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/c2esp-2.7-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95d6ceabcca718b0654664b7e07871a39101f2693762aba3a42eed31787ce476"

URI_x86_64_v2_c2esp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/c2esp-2.7-34.el10.x86_64_v2.rpm;name=x86_64_v2_c2esp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c2esp}"
SRC_URI[x86_64_v2_c2esp.sha256sum] = "30dcaa46b25ba3abce17e821a8740fd5564f1df8d18a3df0a9c39e65a90b9abc"

URI_aarch64_c2esp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/c2esp-2.7-34.el10.aarch64.rpm;name=aarch64_c2esp;unpack=0"
SRC_URI:append = " ${URI_aarch64_c2esp}"
SRC_URI[aarch64_c2esp.sha256sum] = "ba9dd8d4477b9b7183fcc1c8b3d503bf0169d7a88aeda399cd9c538f7e128697"

RDEPENDS:c2esp = " \
 cups-filesystem \
 cups-libs \
 glibc \
 jbigkit-libs \
 libcupsfilters \
 libppd \
 zlib-ng-compat \
 "
