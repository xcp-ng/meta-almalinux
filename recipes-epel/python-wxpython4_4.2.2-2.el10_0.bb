# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-wxpython4"
PV = "4.2.2"
PR = "2.el10_0"
PACKAGES = " \
 python-wxpython4-doc \
 python3-wxpython4 \
 python3-wxpython4-media \
 python3-wxpython4-webview \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-wxpython4-4.2.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "027c3d167283db57e1a98394bab2d593d3b3665e37dd4855ec511f0f40104628"

URI_x86_64_v2_python-wxpython4-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-wxpython4-doc-4.2.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-wxpython4-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-wxpython4-doc}"
SRC_URI[x86_64_v2_python-wxpython4-doc.sha256sum] = "a76f02ac9ba35f8aa00868c3c205f41c01a62ba801b236c3b37c7658811520e8"

URI_x86_64_v2_python3-wxpython4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-wxpython4-4.2.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-wxpython4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wxpython4}"
SRC_URI[x86_64_v2_python3-wxpython4.sha256sum] = "365740975c8ed3b5af9b1e9dcc9c12fb31823b767c083fdc90dee5b56f3ac9db"

URI_x86_64_v2_python3-wxpython4-media = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-wxpython4-media-4.2.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-wxpython4-media;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wxpython4-media}"
SRC_URI[x86_64_v2_python3-wxpython4-media.sha256sum] = "2ded893741a9130c73779fdcd1c8fcbbf6556a990bc158bff21e109c127b0471"

URI_x86_64_v2_python3-wxpython4-webview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-wxpython4-webview-4.2.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-wxpython4-webview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wxpython4-webview}"
SRC_URI[x86_64_v2_python3-wxpython4-webview.sha256sum] = "ae38409f955a4b7621820d7af510a413cb412d72f1ae1da2782e4a768c5cc7bc"

URI_aarch64_python-wxpython4-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-wxpython4-doc-4.2.2-2.el10_0.noarch.rpm;name=aarch64_python-wxpython4-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-wxpython4-doc}"
SRC_URI[aarch64_python-wxpython4-doc.sha256sum] = "c60290e24b38cc790a6886287b709abab136d0394a710faf33f9505f7fe133a9"

URI_aarch64_python3-wxpython4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-wxpython4-4.2.2-2.el10_0.aarch64.rpm;name=aarch64_python3-wxpython4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wxpython4}"
SRC_URI[aarch64_python3-wxpython4.sha256sum] = "b0af645309a96299acecbdb57c4cbfda22de94c8e37a44fbe044c570f8ef9cf0"

URI_aarch64_python3-wxpython4-media = "${EPEL_MIRROR}/aarch64/Packages/p/python3-wxpython4-media-4.2.2-2.el10_0.aarch64.rpm;name=aarch64_python3-wxpython4-media;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wxpython4-media}"
SRC_URI[aarch64_python3-wxpython4-media.sha256sum] = "7c7b90e2ad59befc2a3e57af6d5fb939aef44556a648c9c6c204634a41cf0d38"

URI_aarch64_python3-wxpython4-webview = "${EPEL_MIRROR}/aarch64/Packages/p/python3-wxpython4-webview-4.2.2-2.el10_0.aarch64.rpm;name=aarch64_python3-wxpython4-webview;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wxpython4-webview}"
SRC_URI[aarch64_python3-wxpython4-webview.sha256sum] = "dedb70993a4ffb461dc0143e84affc769d2c645e92f48d1dc6ee71963c225bb3"

RDEPENDS:python-wxpython4-doc = " \
 "
RDEPENDS:python3-wxpython4 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-pillow \
 python3-six \
 wxBase \
 wxGTK \
 wxGTK-gl \
 "
RDEPENDS:python3-wxpython4-media = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-wxpython4 \
 wxBase \
 wxGTK \
 wxGTK-media \
 "
RDEPENDS:python3-wxpython4-webview = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-wxpython4 \
 wxBase \
 wxGTK \
 wxGTK-webview \
 "
