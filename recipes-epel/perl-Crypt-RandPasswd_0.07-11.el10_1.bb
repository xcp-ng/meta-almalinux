# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-RandPasswd"
PV = "0.07"
PR = "11.el10_1"
PACKAGES = " \
 perl-Crypt-RandPasswd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-RandPasswd-0.07-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2d8f8ac4997e8a788dc98a964d34660a9039579dfea60a5144be11c318a9d105"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-RandPasswd-0.07-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-RandPasswd;unpack=0"
SRC_URI[x86_64_v2_perl-Crypt-RandPasswd.sha256sum] = "ac6c689b2ebba8e7812cab1f27be3003520603ceab356a7616fa449925394a44"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-RandPasswd-0.07-11.el10_1.noarch.rpm;name=aarch64_perl-Crypt-RandPasswd;unpack=0"
SRC_URI[aarch64_perl-Crypt-RandPasswd.sha256sum] = "23435acf323f995b107475b90b21df9675e7fa2fb1d4d273bf2ab7dfbdde2b6f"

RDEPENDS:perl-Crypt-RandPasswd = " \
 perl-Getopt-Long \
 perl-constant \
 perl-libs \
 perl-vars \
 "
