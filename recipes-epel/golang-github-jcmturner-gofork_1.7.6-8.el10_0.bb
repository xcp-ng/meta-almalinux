# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jcmturner-gofork"
PV = "1.7.6"
PR = "8.el10_0"
PACKAGES = " \
 golang-github-jcmturner-gofork-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-jcmturner-gofork-1.7.6-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0eb85a739e6b3ca6c91b6b6afac9fad5a1a2ed9672ae352045fba5b174a35e5f"

URI_x86_64_v2_golang-github-jcmturner-gofork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jcmturner-gofork-devel-1.7.6-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-jcmturner-gofork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jcmturner-gofork-devel}"
SRC_URI[x86_64_v2_golang-github-jcmturner-gofork-devel.sha256sum] = "54569f64dc203c54fb257b3846986b778169710925756491be685b95f3efbbbc"

URI_aarch64_golang-github-jcmturner-gofork-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jcmturner-gofork-devel-1.7.6-8.el10_0.noarch.rpm;name=aarch64_golang-github-jcmturner-gofork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jcmturner-gofork-devel}"
SRC_URI[aarch64_golang-github-jcmturner-gofork-devel.sha256sum] = "d4373578592e428f423eb034378a2e63a5108f098e60439d6cfa04f8ba8dcad5"

RDEPENDS:golang-github-jcmturner-gofork-devel = " \
 go-filesystem \
 "
