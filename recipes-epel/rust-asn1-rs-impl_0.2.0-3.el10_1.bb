# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-asn1-rs-impl"
PV = "0.2.0"
PR = "3.el10_1"
PACKAGES = " \
 rust-asn1-rs-impl+default-devel \
 rust-asn1-rs-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-asn1-rs-impl-0.2.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4996a2420311d84a84bd7c9f2abee701a2af7380848e0a6c1d96e9b47fef67a4"

URI_x86_64_v2_rust-asn1-rs-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-impl+default-devel-0.2.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs-impl+default-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs-impl+default-devel.sha256sum] = "84ff6d283827d2b524d061feb6848617881ba7cac0e7f73669e8840814506099"

URI_x86_64_v2_rust-asn1-rs-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-impl-devel-0.2.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs-impl-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs-impl-devel.sha256sum] = "c375fbee56c135c496dbfec98b9ec5931c91b12c3028f2197a4f13a71a46ec5b"

URI_aarch64_rust-asn1-rs-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-impl+default-devel-0.2.0-3.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs-impl+default-devel}"
SRC_URI[aarch64_rust-asn1-rs-impl+default-devel.sha256sum] = "6199edb8816a5e572b6d4e2dd55e205285acbe1f83d789898eb312834a95d321"

URI_aarch64_rust-asn1-rs-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-impl-devel-0.2.0-3.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs-impl-devel}"
SRC_URI[aarch64_rust-asn1-rs-impl-devel.sha256sum] = "7a7ef6c464080fa1ef3ddc5adf1e052f8b4f7bbca44549ea33636ea98d8f866b"

RDEPENDS:rust-asn1-rs-impl+default-devel = " \
 cargo \
 rust-asn1-rs-impl-devel \
 "
RDEPENDS:rust-asn1-rs-impl-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
