# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gifsicle"
PV = "1.96"
PR = "1.el10_2"
PACKAGES = " \
 gifsicle \
 gifview \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gifsicle-1.96-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5993c35cc02da56257d8559d8152cbc3aad3ccbc10b72adeb80e2369ed6d93b1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gifsicle-1.96-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gifsicle;unpack=0"
SRC_URI[x86_64_v2_gifsicle.sha256sum] = "0cb417cc6b775feb5dc9be257be2b4bd02fa0ca08ef0408190f1e182e02565c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gifview-1.96-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gifview;unpack=0"
SRC_URI[x86_64_v2_gifview.sha256sum] = "276e43a1b2ef2cafaf097c56850873b4c02af7b75681d02dca042dd04989e294"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gifsicle-1.96-1.el10_2.aarch64.rpm;name=aarch64_gifsicle;unpack=0"
SRC_URI[aarch64_gifsicle.sha256sum] = "ca735adbe7eb0a581858cc11ec38614da2890bdf34eeae478e0e3bc02af54c50"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gifview-1.96-1.el10_2.aarch64.rpm;name=aarch64_gifview;unpack=0"
SRC_URI[aarch64_gifview.sha256sum] = "22e14485c21d73f12370d384f026361ca33f945e16f866a9dde24b65fd042a7b"

RDEPENDS:gifsicle = " \
 glibc \
 "
RDEPENDS:gifview = " \
 glibc \
 libX11 \
 "
