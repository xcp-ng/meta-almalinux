# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-discover"
PV = "0.53.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-discover+default-devel \
 rust-gix-discover+sha1-devel \
 rust-gix-discover+sha256-devel \
 rust-gix-discover-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-discover-0.53.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a790fdb8e80022324fbde9cd3ee62f1858993f07f4df49140c4f49e2f0fbb38c"

URI_x86_64_v2_rust-gix-discover+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-discover+default-devel-0.53.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-discover+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-discover+default-devel}"
SRC_URI[x86_64_v2_rust-gix-discover+default-devel.sha256sum] = "ba8e76fe431d5d514409386958142ae13359b1c715d78aa427b138acad274abc"

URI_x86_64_v2_rust-gix-discover+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-discover+sha1-devel-0.53.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-discover+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-discover+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-discover+sha1-devel.sha256sum] = "7605add3b98612d73f4e86f5c0909b38f5a6b5b7dc7670125281e96086f7a01e"

URI_x86_64_v2_rust-gix-discover+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-discover+sha256-devel-0.53.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-discover+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-discover+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-discover+sha256-devel.sha256sum] = "af5009c0fb9396d6ad50dbc195f6063e25eb82f4d09116d89f593dc8825c634d"

URI_x86_64_v2_rust-gix-discover-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-discover-devel-0.53.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-discover-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-discover-devel}"
SRC_URI[x86_64_v2_rust-gix-discover-devel.sha256sum] = "830453fc23e7631e53c32484f08c3a0fb97ec96ad08f07538a29394e62d6718a"

URI_aarch64_rust-gix-discover+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-discover+default-devel-0.53.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-discover+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-discover+default-devel}"
SRC_URI[aarch64_rust-gix-discover+default-devel.sha256sum] = "75208c0745acac7e2bd9972077ace3f3d1dcc01fb1dee026587ffdf5c74452f6"

URI_aarch64_rust-gix-discover+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-discover+sha1-devel-0.53.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-discover+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-discover+sha1-devel}"
SRC_URI[aarch64_rust-gix-discover+sha1-devel.sha256sum] = "9bff6b6086d46a3e70eae64047cb29fa90669fc793ac7d683e4ec011385f042c"

URI_aarch64_rust-gix-discover+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-discover+sha256-devel-0.53.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-discover+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-discover+sha256-devel}"
SRC_URI[aarch64_rust-gix-discover+sha256-devel.sha256sum] = "6855c9b9200549414a12785bf0772f8e73175548d44181437325301e5e59a64e"

URI_aarch64_rust-gix-discover-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-discover-devel-0.53.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-discover-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-discover-devel}"
SRC_URI[aarch64_rust-gix-discover-devel.sha256sum] = "f0deab2061c10360750c87502226edec456922aea07e0184e44b32143afab875"

RDEPENDS:rust-gix-discover+default-devel = " \
 cargo \
 rust-gix-discover-devel \
 "
RDEPENDS:rust-gix-discover+sha1-devel = " \
 cargo \
 rust-gix-discover-devel \
 rust-gix-ref+sha1-devel \
 "
RDEPENDS:rust-gix-discover+sha256-devel = " \
 cargo \
 rust-gix-discover-devel \
 rust-gix-ref+sha256-devel \
 "
RDEPENDS:rust-gix-discover-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-fs+default-devel \
 rust-gix-path+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-sec+default-devel \
 rust-thiserror+default-devel \
 "
