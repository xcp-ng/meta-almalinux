# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiten"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kiten \
 kiten-devel \
 kiten-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiten-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e01013ff8998c761da47e1d8e15ecd149bfca33688926781185b9ea55746c4f"

URI_x86_64_v2_kiten = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiten-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiten;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiten}"
SRC_URI[x86_64_v2_kiten.sha256sum] = "830d83ab16c4c377acf5b29572674b92bebf8b47d56b42e2ab070e303a4d7104"

URI_x86_64_v2_kiten-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiten-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiten-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiten-devel}"
SRC_URI[x86_64_v2_kiten-devel.sha256sum] = "048e31367b68145a920bb2ea85fb81502cbf7512a351918b6974152d342d82b0"

URI_x86_64_v2_kiten-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiten-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiten-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiten-libs}"
SRC_URI[x86_64_v2_kiten-libs.sha256sum] = "d0773e281912dfac563515f8080606795a9d9360e7e058fbd08e02d8e9872431"

URI_aarch64_kiten = "${EPEL_MIRROR}/aarch64/Packages/k/kiten-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kiten;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiten}"
SRC_URI[aarch64_kiten.sha256sum] = "9be28fa5b632d9433fdf77dd32257c6c153d563147c2189f5aae8925a424b49c"

URI_aarch64_kiten-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kiten-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kiten-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiten-devel}"
SRC_URI[aarch64_kiten-devel.sha256sum] = "5f010cc439552106d268ae4507a197a4263455bcb6361450d44e85ad42ad9bce"

URI_aarch64_kiten-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kiten-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kiten-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiten-libs}"
SRC_URI[aarch64_kiten-libs.sha256sum] = "9b0ce7ba2d7e21c07fa50425ad61e56ac323f488db101d5dc97d8ccb7c6a0bd9"

RDEPENDS:kiten = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kiten-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kiten-devel = " \
 kiten-libs \
 "
RDEPENDS:kiten-libs = " \
 glibc \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kiten \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
