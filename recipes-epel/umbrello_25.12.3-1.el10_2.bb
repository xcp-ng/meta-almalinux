# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "umbrello"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 umbrello \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/umbrello-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e224d82de5b4fc24f2e210f18fde2a5f8d4767251ee056b6b5186d759c9e37d"

URI_x86_64_v2_umbrello = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/umbrello-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_umbrello;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_umbrello}"
SRC_URI[x86_64_v2_umbrello.sha256sum] = "b1a5355d64002a0d745cff1d48142a451a96b207c047d4092e6b06792b49dde8"

URI_aarch64_umbrello = "${EPEL_MIRROR}/aarch64/Packages/u/umbrello-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_umbrello;unpack=0"
SRC_URI:append = " ${URI_aarch64_umbrello}"
SRC_URI[aarch64_umbrello.sha256sum] = "dc809f066803ededa03fb23126311c337e6ffbc985f7c8c749869653eced3b6d"

RDEPENDS:umbrello = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 libxml2 \
 libxslt \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
