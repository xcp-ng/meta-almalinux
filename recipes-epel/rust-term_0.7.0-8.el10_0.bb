# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-term"
PV = "0.7.0"
PR = "8.el10_0"
PACKAGES = " \
 rust-term+default-devel \
 rust-term-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-term-0.7.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80925b6772ac443252f9acb11fbb25f94e956d6afb9e17cc0b68e99d9a409f2a"

URI_x86_64_v2_rust-term+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term+default-devel-0.7.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term+default-devel}"
SRC_URI[x86_64_v2_rust-term+default-devel.sha256sum] = "436ec3022df58ead8c3b3425b82ff66af9edd1fb5650cfc19edc857aa6bf9195"

URI_x86_64_v2_rust-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term-devel-0.7.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term-devel}"
SRC_URI[x86_64_v2_rust-term-devel.sha256sum] = "07b1147d371c2908f74e35f28eb0a905991f8acced1239b58ec85cecb163030f"

URI_aarch64_rust-term+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term+default-devel-0.7.0-8.el10_0.noarch.rpm;name=aarch64_rust-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term+default-devel}"
SRC_URI[aarch64_rust-term+default-devel.sha256sum] = "944ba19a8171f310235890ddad1a1a56d1d76f0b7c05da0913dfad36aa8fd3bf"

URI_aarch64_rust-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term-devel-0.7.0-8.el10_0.noarch.rpm;name=aarch64_rust-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term-devel}"
SRC_URI[aarch64_rust-term-devel.sha256sum] = "fda1a503dc03a80a7773d7fc14f1108420612b2506736f4a130deddae3500aaa"

RDEPENDS:rust-term+default-devel = " \
 cargo \
 rust-term-devel \
 "
RDEPENDS:rust-term-devel = " \
 cargo \
 rust-dirs-next+default-devel \
 "
