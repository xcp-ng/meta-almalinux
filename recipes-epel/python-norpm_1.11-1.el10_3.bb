# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-norpm"
PV = "1.11"
PR = "1.el10_3"
PACKAGES = " \
 python3-norpm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-norpm-1.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af96282008726558cbbb1860fadfd8f40d0f28b60bec59fdde827b02dc942485"

URI_x86_64_v2_python3-norpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-norpm-1.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-norpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-norpm}"
SRC_URI[x86_64_v2_python3-norpm.sha256sum] = "338a839ea9f18c960f9bb29d938887de0bab6a213e0941c6412290d916b3ca3a"

URI_aarch64_python3-norpm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-norpm-1.11-1.el10_3.noarch.rpm;name=aarch64_python3-norpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-norpm}"
SRC_URI[aarch64_python3-norpm.sha256sum] = "14c8c70d2420014d8508b26f38a80f531ff89eb961441df34a75c578182e76cc"

RDEPENDS:python3-norpm = " \
 python3 \
 python3-lark \
 "
