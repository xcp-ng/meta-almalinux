# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-wot"
PV = "0.15.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-sequoia-wot+default-devel \
 rust-sequoia-wot-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-sequoia-wot-0.15.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a9cd9172a2478daebf2a5b735a62a178ebf1dab38fb6262b33583277933112a4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-wot+default-devel-0.15.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-wot+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-wot+default-devel.sha256sum] = "fe382c9218f374cb7ae703feef17e16e963a51f415429e82036883f4ccc1b731"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-wot-devel-0.15.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-wot-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-wot-devel.sha256sum] = "e244c47b9f09f279254da86d9f8821dfe440f41030b43bb1602b7fb5a24755dd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-wot+default-devel-0.15.3-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-wot+default-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-wot+default-devel.sha256sum] = "4b02f67edb041092f06c73481b1e1464b52c6c906251e962d1287800876a3abc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-wot-devel-0.15.3-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-wot-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-wot-devel.sha256sum] = "52b6d1d2eb460ee3c592f8dc8a74a648c13044fce2bd052d1ef8c1cc8046ea6b"

RDEPENDS:rust-sequoia-wot+default-devel = " \
 cargo \
 rust-sequoia-wot-devel \
 "
RDEPENDS:rust-sequoia-wot-devel = " \
 bash \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-chrono+default-devel \
 rust-crossbeam+default-devel \
 rust-sequoia-cert-store-devel \
 rust-sequoia-openpgp-devel \
 virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ \
 "
