# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-krunner"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-krunner \
 kf6-krunner-devel \
 kf6-krunner-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-krunner-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "422c264093ac955ceb13fcdb0d8e3cbb11ae11f9eb00f88fb99a9591a3bbc54d"

URI_x86_64_v2_kf6-krunner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-krunner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner}"
SRC_URI[x86_64_v2_kf6-krunner.sha256sum] = "9ad27740a7bcbbb37b3f0e007046ecf1c34990033aaa109aaf463932e5c9356d"

URI_x86_64_v2_kf6-krunner-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-krunner-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner-devel}"
SRC_URI[x86_64_v2_kf6-krunner-devel.sha256sum] = "e69706f38a89732cbe1ba5f61bf0f6926364248fd3275b82e4f9e2739603e956"

URI_x86_64_v2_kf6-krunner-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-krunner-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner-doc}"
SRC_URI[x86_64_v2_kf6-krunner-doc.sha256sum] = "c1f2c5fd39b188122b0a7b1ffe18676f71b475a6d329c7bf1c4f182e6d439f51"

URI_aarch64_kf6-krunner = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-krunner;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner}"
SRC_URI[aarch64_kf6-krunner.sha256sum] = "07ee6da4ae961b45ca6b792e7347313a062b9c291a4e36177c2681f76b98205d"

URI_aarch64_kf6-krunner-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-krunner-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner-devel}"
SRC_URI[aarch64_kf6-krunner-devel.sha256sum] = "7889f372e55a79988594cc4edd586122f785511e369da1da147ce1cf059bd8e5"

URI_aarch64_kf6-krunner-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-krunner-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner-doc}"
SRC_URI[aarch64_kf6-krunner-doc.sha256sum] = "bd08ba19787caf1d944930c1c1a59665c303451893dadb6e7ac423600b85086d"

RDEPENDS:kf6-krunner = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-krunner-devel = " \
 cmake-filesystem \
 kf6-krunner \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-krunner-doc = " \
 "
