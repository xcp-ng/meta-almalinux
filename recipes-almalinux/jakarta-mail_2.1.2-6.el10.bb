# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jakarta-mail"
PV = "2.1.2"
PR = "6.el10"
PACKAGES = " \
 jakarta-mail \
 jakarta-mail-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jakarta-mail-2.1.2-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "349733024cab92d35d3aa8c3fbbf7dfba6a03fd411e33fa54d5e02d5cef52406"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jakarta-mail-2.1.2-6.el10.noarch.rpm;name=x86_64_v2_jakarta-mail;unpack=0"
SRC_URI[x86_64_v2_jakarta-mail.sha256sum] = "fe535bceb4fe529735bdbed81f9479003443d75a8f0aad389e7ee07a853ce0f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jakarta-mail-javadoc-2.1.2-6.el10.noarch.rpm;name=x86_64_v2_jakarta-mail-javadoc;unpack=0"
SRC_URI[x86_64_v2_jakarta-mail-javadoc.sha256sum] = "2e5fd31535ebe52a9d7ed2fb0f825b30997c9f74062524296a50e59662838507"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jakarta-mail-2.1.2-6.el10.noarch.rpm;name=aarch64_jakarta-mail;unpack=0"
SRC_URI[aarch64_jakarta-mail.sha256sum] = "fe535bceb4fe529735bdbed81f9479003443d75a8f0aad389e7ee07a853ce0f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jakarta-mail-javadoc-2.1.2-6.el10.noarch.rpm;name=aarch64_jakarta-mail-javadoc;unpack=0"
SRC_URI[aarch64_jakarta-mail-javadoc.sha256sum] = "2e5fd31535ebe52a9d7ed2fb0f825b30997c9f74062524296a50e59662838507"

RDEPENDS:jakarta-mail = " \
 jakarta-activation \
 javapackages-filesystem \
 "
RDEPENDS:jakarta-mail-javadoc = " \
 javapackages-filesystem \
 "
