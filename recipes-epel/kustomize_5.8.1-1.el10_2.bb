# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kustomize"
PV = "5.8.1"
PR = "1.el10_2"
PACKAGES = " \
 kustomize \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kustomize-5.8.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd1b8ba6c3bf006eae0c50a9145d2768680b5b2d3669ed171ba21f4814d47a2c"

URI_x86_64_v2_kustomize = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kustomize-5.8.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kustomize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kustomize}"
SRC_URI[x86_64_v2_kustomize.sha256sum] = "ab8593e8a183f427d7e544198c2d798f369322f3e9eadfcdd685cc86acab9d96"

URI_aarch64_kustomize = "${EPEL_MIRROR}/aarch64/Packages/k/kustomize-5.8.1-1.el10_2.aarch64.rpm;name=aarch64_kustomize;unpack=0"
SRC_URI:append = " ${URI_aarch64_kustomize}"
SRC_URI[aarch64_kustomize.sha256sum] = "18d2687e80effff03d216f79ff95f032db748f44c4c7b1b068b35e5521fd4e07"

RDEPENDS:kustomize = " \
 git-core \
 glibc \
 "
