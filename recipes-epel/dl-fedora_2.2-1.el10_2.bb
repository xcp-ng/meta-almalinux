# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dl-fedora"
PV = "2.2"
PR = "1.el10_2"
PACKAGES = " \
 dl-fedora \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dl-fedora-2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec3585802da4fe9bc033019192b2753e1c8801d30e64ca86da980faae05d4e76"

URI_x86_64_v2_dl-fedora = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dl-fedora-2.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dl-fedora;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dl-fedora}"
SRC_URI[x86_64_v2_dl-fedora.sha256sum] = "b3f74241a9f72eac2540eebd31384778bb9139683c3515ef9779c718c1336e4d"

URI_aarch64_dl-fedora = "${EPEL_MIRROR}/aarch64/Packages/d/dl-fedora-2.2-1.el10_2.aarch64.rpm;name=aarch64_dl-fedora;unpack=0"
SRC_URI:append = " ${URI_aarch64_dl-fedora}"
SRC_URI[aarch64_dl-fedora.sha256sum] = "cc00cec57a44c37580490ec9a5feeaf32a5f548724980ea61dc2d73e37b4225e"

RDEPENDS:dl-fedora = " \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 zlib-ng-compat \
 "
