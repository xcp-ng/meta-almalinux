# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-stack-0"
PV = "0"
PR = "16.20190626git9b43fce.el10_0"
PACKAGES = " \
 golang-gopkg-stack-0-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-stack-0-0-16.20190626git9b43fce.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd1f8ba4bb1a81c602c698d0d216a05748ae0a6aaa967731637f0e2e41964205"

URI_aarch64_golang-gopkg-stack-0-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-stack-0-devel-0-16.20190626git9b43fce.el10_0.noarch.rpm;name=aarch64_golang-gopkg-stack-0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-stack-0-devel}"
SRC_URI[aarch64_golang-gopkg-stack-0-devel.sha256sum] = "31fd39f72ee8e2c51be41ad37d83757dc344a0c9c7c01dc2913b226db9782f3b"

RDEPENDS:golang-gopkg-stack-0-devel = " \
 go-filesystem \
 "
