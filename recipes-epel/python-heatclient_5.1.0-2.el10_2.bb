# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-heatclient"
PV = "5.1.0"
PR = "2.el10_2"
PACKAGES = " \
 python-heatclient-doc \
 python3-heatclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-heatclient-5.1.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e428bd7e144ed755d42946189bf447195e875387792529665cd496f608c2e097"

URI_x86_64_v2_python-heatclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-heatclient-doc-5.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-heatclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-heatclient-doc}"
SRC_URI[x86_64_v2_python-heatclient-doc.sha256sum] = "f3c42e4e8c984f137525a327c2c7d650f0685469298771a951d8653c9645d992"

URI_x86_64_v2_python3-heatclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-heatclient-5.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-heatclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-heatclient}"
SRC_URI[x86_64_v2_python3-heatclient.sha256sum] = "2fa3218d835d2fb7e54a490a890cf9c1adada771f3f511be085cbdc8c57dc085"

URI_aarch64_python-heatclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-heatclient-doc-5.1.0-2.el10_2.noarch.rpm;name=aarch64_python-heatclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-heatclient-doc}"
SRC_URI[aarch64_python-heatclient-doc.sha256sum] = "63f54f6b2e3e6782694a55142a2473a5ce43a77d2655d0b6719580ef24a56533"

URI_aarch64_python3-heatclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-heatclient-5.1.0-2.el10_2.noarch.rpm;name=aarch64_python3-heatclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-heatclient}"
SRC_URI[aarch64_python3-heatclient.sha256sum] = "3d614d1392f96ebc9b515c45f22ab1acf68cd06eda29265c49be43d6afdce5b9"

RDEPENDS:python-heatclient-doc = " \
 "
RDEPENDS:python3-heatclient = " \
 python3 \
 python3-cliff \
 python3-iso8601 \
 python3-keystoneauth1 \
 python3-osc-lib \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-prettytable \
 python3-pyyaml \
 python3-requests \
 python3-swiftclient \
 "
