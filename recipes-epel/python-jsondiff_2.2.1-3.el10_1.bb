# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jsondiff"
PV = "2.2.1"
PR = "3.el10_1"
PACKAGES = " \
 python3-jsondiff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jsondiff-2.2.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "201b3043dd37583c164e2adf199902357e7c1130933a99fa8242f506473ffef1"

URI_x86_64_v2_python3-jsondiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jsondiff-2.2.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jsondiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jsondiff}"
SRC_URI[x86_64_v2_python3-jsondiff.sha256sum] = "3bdd4cee7890990c6cf478c1a9fbe4d6ca0ea1a048d6429a11d53a7def3f16f5"

URI_aarch64_python3-jsondiff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jsondiff-2.2.1-3.el10_1.noarch.rpm;name=aarch64_python3-jsondiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jsondiff}"
SRC_URI[aarch64_python3-jsondiff.sha256sum] = "d8afe385ab07063888011111f166429dcafef98bfc587c69ca061a8bef832eba"

RDEPENDS:python3-jsondiff = " \
 python3 \
 python3-pyyaml \
 "
