# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtlanguageserver"
PV = "6.9.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtlanguageserver \
 qt6-qtlanguageserver-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtlanguageserver-6.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf6dce4dc3379f7415ccd6b02a3889809c1ac7f3c1a8a036fdc35b042983b89b"

URI_x86_64_v2_qt6-qtlanguageserver = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlanguageserver-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlanguageserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlanguageserver}"
SRC_URI[x86_64_v2_qt6-qtlanguageserver.sha256sum] = "0297ef63c5dc82fb32fc23a1a2b28c858fe53003ade14925ef1d7a81244a7ef7"

URI_x86_64_v2_qt6-qtlanguageserver-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlanguageserver-devel-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlanguageserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlanguageserver-devel}"
SRC_URI[x86_64_v2_qt6-qtlanguageserver-devel.sha256sum] = "af82c016e7476c4bee93a2aa05476c358b0475d938ee17b59b1864ee67c22a2d"

URI_aarch64_qt6-qtlanguageserver = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlanguageserver-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlanguageserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlanguageserver}"
SRC_URI[aarch64_qt6-qtlanguageserver.sha256sum] = "5dd20242a57fce68ba397d2bc9f1344b4a53dd47de31d4481905bc4c7d0a8a8c"

URI_aarch64_qt6-qtlanguageserver-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlanguageserver-devel-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlanguageserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlanguageserver-devel}"
SRC_URI[aarch64_qt6-qtlanguageserver-devel.sha256sum] = "0ae505dcae4054edc61a1adec28f4aad9b4aeb95a25a1b15df87812e349b1cc0"

RDEPENDS:qt6-qtlanguageserver = " \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtlanguageserver-devel = " \
 cmake-filesystem \
 qt6-qtbase-devel \
 qt6-qtlanguageserver \
 "
