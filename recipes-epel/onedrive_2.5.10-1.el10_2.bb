# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "onedrive"
PV = "2.5.10"
PR = "1.el10_2"
PACKAGES = " \
 onedrive \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/onedrive-2.5.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fdb911d827d05ee8ae91688a03967b59ae080717ce8774ef875b0a61e79db79"

URI_x86_64_v2_onedrive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/onedrive-2.5.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_onedrive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_onedrive}"
SRC_URI[x86_64_v2_onedrive.sha256sum] = "732d7067acb57757ae2345f720240a5226a6eefde28ae8ac567bcee80c125ca4"

URI_aarch64_onedrive = "${EPEL_MIRROR}/aarch64/Packages/o/onedrive-2.5.10-1.el10_2.aarch64.rpm;name=aarch64_onedrive;unpack=0"
SRC_URI:append = " ${URI_aarch64_onedrive}"
SRC_URI[aarch64_onedrive.sha256sum] = "d5f1b5676c23ef8ecbcbebb6bb527f1fbb72a7059a21b527dc5f901a7c8d1945"

RDEPENDS:onedrive = " \
 bash \
 dbus-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 ldc-libs \
 libgcc \
 libnotify \
 sqlite-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
