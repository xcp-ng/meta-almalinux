# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "korganizer"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 korganizer \
 korganizer-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/korganizer-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "975905d87a085e02fdbc3b74152c0e14c6832d3b2e3c837b1686c2fc98e0b8e5"

URI_x86_64_v2_korganizer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/korganizer-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_korganizer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_korganizer}"
SRC_URI[x86_64_v2_korganizer.sha256sum] = "a33b42e1045636c8fb4c8314d0f5067171c595aa9d5fb1cb52048c2812cc70dd"

URI_x86_64_v2_korganizer-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/korganizer-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_korganizer-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_korganizer-libs}"
SRC_URI[x86_64_v2_korganizer-libs.sha256sum] = "312254ec8dc668f12116cf79d53e167bb7ba758e6f650ab642860c4b55a6fbcd"

URI_aarch64_korganizer = "${EPEL_MIRROR}/aarch64/Packages/k/korganizer-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_korganizer;unpack=0"
SRC_URI:append = " ${URI_aarch64_korganizer}"
SRC_URI[aarch64_korganizer.sha256sum] = "ab36c37a0fa2f0af835ac18b1adb5b3e53cbbee240d73e39bd344d187d60817c"

URI_aarch64_korganizer-libs = "${EPEL_MIRROR}/aarch64/Packages/k/korganizer-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_korganizer-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_korganizer-libs}"
SRC_URI[aarch64_korganizer-libs.sha256sum] = "e1f557ecfe0c48424038103cb94081911ff4e6deb9edccf39cd0a5d447c06ef2"

RDEPENDS:korganizer = " \
 akonadi-server \
 glibc \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kparts \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontactinterface \
 korganizer-libs \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:korganizer-libs = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-server \
 calendarsupport \
 eventviews \
 glibc \
 incidenceeditor \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kmailtransport \
 kmime \
 kontactinterface \
 korganizer \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
