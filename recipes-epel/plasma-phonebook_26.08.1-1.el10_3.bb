# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-phonebook"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 plasma-phonebook \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-phonebook-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9747a6351035626a8ec5abf6da4639cf190f9cdf7dfca8a1202dd8244a9a7950"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-phonebook-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-phonebook;unpack=0"
SRC_URI[x86_64_v2_plasma-phonebook.sha256sum] = "ab922bd0e0794dc66faeb0f97f3c83fe92d6d7098e0dafbf9c2a94eb6373b36c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-phonebook-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_plasma-phonebook;unpack=0"
SRC_URI[aarch64_plasma-phonebook.sha256sum] = "5c6831a701dae56fbc3b435841f6fee6b47cbcebb3e4047784b1187e1c497189"

RDEPENDS:plasma-phonebook = " \
 glibc \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kpeople \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
