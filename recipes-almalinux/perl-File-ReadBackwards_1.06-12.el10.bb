# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-ReadBackwards"
PV = "1.06"
PR = "12.el10"
PACKAGES = " \
 perl-File-ReadBackwards \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-File-ReadBackwards-1.06-12.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f70e62c93eed8509f5ff5842815c617ad60b0e62581427232c582086d16125d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-File-ReadBackwards-1.06-12.el10.noarch.rpm;name=x86_64_v2_perl-File-ReadBackwards;unpack=0"
SRC_URI[x86_64_v2_perl-File-ReadBackwards.sha256sum] = "0a13a3a46122fd23530f16f59669ad9b4c77cbf5ca5d676aecf588d4202ac336"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-File-ReadBackwards-1.06-12.el10.noarch.rpm;name=aarch64_perl-File-ReadBackwards;unpack=0"
SRC_URI[aarch64_perl-File-ReadBackwards.sha256sum] = "0a13a3a46122fd23530f16f59669ad9b4c77cbf5ca5d676aecf588d4202ac336"

RDEPENDS:perl-File-ReadBackwards = " \
 perl-Carp \
 perl-Fcntl \
 perl-Symbol \
 perl-libs \
 "
