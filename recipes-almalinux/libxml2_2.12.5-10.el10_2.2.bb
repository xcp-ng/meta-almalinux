# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxml2"
PV = "2.12.5"
PR = "10.el10_2.2"
PACKAGES = " \
 libxml2 \
 libxml2-devel \
 libxml2-static \
 python3-libxml2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libxml2-2.12.5-10.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2d4d60033e34acd1c0dce964f2c83721679366c56796e2c12ed850d108392aa"

URI_x86_64_v2_libxml2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libxml2-2.12.5-10.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_libxml2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxml2}"
SRC_URI[x86_64_v2_libxml2.sha256sum] = "4988d6e784133c108ccf491eb2066fee8576da60f3c762ca3eaa7b407c36abb4"

URI_x86_64_v2_libxml2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxml2-devel-2.12.5-10.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_libxml2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxml2-devel}"
SRC_URI[x86_64_v2_libxml2-devel.sha256sum] = "0d4f565cac1bdc27b73a3a740b4724b33a6913784d8c9c89062a04a5ba040890"

URI_x86_64_v2_libxml2-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxml2-static-2.12.5-10.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_libxml2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxml2-static}"
SRC_URI[x86_64_v2_libxml2-static.sha256sum] = "16846632d15bfeba0dd2b820e3e7de55769979120e0430e63484f4ea441fdbc6"

URI_x86_64_v2_python3-libxml2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libxml2-2.12.5-10.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_python3-libxml2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libxml2}"
SRC_URI[x86_64_v2_python3-libxml2.sha256sum] = "3927dd2b5f7755651d26096f37da34e16fe56fcf5f19c323bd4a4669dcbff9a7"

URI_aarch64_libxml2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libxml2-2.12.5-10.el10_2.2.aarch64.rpm;name=aarch64_libxml2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxml2}"
SRC_URI[aarch64_libxml2.sha256sum] = "cfcc1b95684df4852d35a23afdca80d8fad7e31d8b974bba3bdd564e85368ea2"

URI_aarch64_libxml2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxml2-devel-2.12.5-10.el10_2.2.aarch64.rpm;name=aarch64_libxml2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxml2-devel}"
SRC_URI[aarch64_libxml2-devel.sha256sum] = "4c3ac3d39453fe1d14a81a27c8b6f5ceb1c424322d907e67b0e93425f56f3fc9"

URI_aarch64_libxml2-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxml2-static-2.12.5-10.el10_2.2.aarch64.rpm;name=aarch64_libxml2-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxml2-static}"
SRC_URI[aarch64_libxml2-static.sha256sum] = "028b23e3751d22ff2d44cba474e853a792c75309eec36006dca24eca9c147382"

URI_aarch64_python3-libxml2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libxml2-2.12.5-10.el10_2.2.aarch64.rpm;name=aarch64_python3-libxml2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libxml2}"
SRC_URI[aarch64_python3-libxml2.sha256sum] = "10ca6fffd2296a4c2ef1cf2756a9aa2b9ef1289971b6df3485a5ee7d9dbfddee"

RDEPENDS:libxml2 = " \
 glibc \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libxml2-devel = " \
 bash \
 cmake-filesystem \
 libxml2 \
 pkgconf-pkg-config \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:libxml2-static = " \
 "
RDEPENDS:python3-libxml2 = " \
 glibc \
 libxml2 \
 python3 \
 "
