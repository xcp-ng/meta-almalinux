# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtsvg"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtsvg \
 qt6-qtsvg-devel \
 qt6-qtsvg-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtsvg-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e29c8a882c93ee3f28ec128b62cbda79f5b488364080ff3126dd43eddffd9bc"

URI_x86_64_v2_qt6-qtsvg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtsvg-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsvg}"
SRC_URI[x86_64_v2_qt6-qtsvg.sha256sum] = "d07088a01ca337d08662370d1c674229f758aa5ab386d566b54cd95a155ea66a"

URI_x86_64_v2_qt6-qtsvg-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtsvg-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsvg-devel}"
SRC_URI[x86_64_v2_qt6-qtsvg-devel.sha256sum] = "8b5e26b631b3096287bab10d9203ae2f9f1422305856107a6a41a9921f542ac5"

URI_x86_64_v2_qt6-qtsvg-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtsvg-examples-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsvg-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsvg-examples}"
SRC_URI[x86_64_v2_qt6-qtsvg-examples.sha256sum] = "70091c17e420857ae7664329ab0fcf93ad0d5ba97af222a81ebaee6d4289e6f5"

URI_aarch64_qt6-qtsvg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtsvg-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtsvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsvg}"
SRC_URI[aarch64_qt6-qtsvg.sha256sum] = "53211fc38c8095058c442f2ecb6e9d911afdf62fda391839948647faba279e54"

URI_aarch64_qt6-qtsvg-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtsvg-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtsvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsvg-devel}"
SRC_URI[aarch64_qt6-qtsvg-devel.sha256sum] = "7b3eb6a1577553cf06e06c68f7011d4db536217cc30a0e0cc081bd51977dfe75"

URI_aarch64_qt6-qtsvg-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtsvg-examples-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtsvg-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsvg-examples}"
SRC_URI[aarch64_qt6-qtsvg-examples.sha256sum] = "5499653c5bd8c0ba96b8b77c8906c3f8fcad48da71ca1a687f3afbc3b8b0cc4a"

RDEPENDS:qt6-qtsvg = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:qt6-qtsvg-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtsvg \
 qt6-qtsvg-devel \
 "
RDEPENDS:qt6-qtsvg-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
