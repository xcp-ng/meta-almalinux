# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-minus"
PV = "5.6.1"
PR = "5.el10_3"
PACKAGES = " \
 rust-minus+default-devel \
 rust-minus+dynamic_output-devel \
 rust-minus+regex-devel \
 rust-minus+search-devel \
 rust-minus+static_output-devel \
 rust-minus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-minus-5.6.1-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "508bdc3b7c7cf9b2764cd03338b5db5c7123a666cc28ea6566c2dad3a2763232"

URI_x86_64_v2_rust-minus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minus+default-devel-5.6.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minus+default-devel}"
SRC_URI[x86_64_v2_rust-minus+default-devel.sha256sum] = "311fa99ec60471b08abfbc7de9e689fbb5e0368f869a6b47416dea26b9b1368e"

URI_x86_64_v2_rust-minus+dynamic_output-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minus+dynamic_output-devel-5.6.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minus+dynamic_output-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minus+dynamic_output-devel}"
SRC_URI[x86_64_v2_rust-minus+dynamic_output-devel.sha256sum] = "740b09bd7a07378e264be2fab1b7eb1c27c728ae0d6372256c0d5906ea321cd9"

URI_x86_64_v2_rust-minus+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minus+regex-devel-5.6.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minus+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minus+regex-devel}"
SRC_URI[x86_64_v2_rust-minus+regex-devel.sha256sum] = "6e1653551173372cd328505270cd020fd18164b103ff0a7b1d07e9c0eef2bab5"

URI_x86_64_v2_rust-minus+search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minus+search-devel-5.6.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minus+search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minus+search-devel}"
SRC_URI[x86_64_v2_rust-minus+search-devel.sha256sum] = "eae26f865041e22411fa535c391f8644caed9c3a43f5087e57b3b35dee14701e"

URI_x86_64_v2_rust-minus+static_output-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minus+static_output-devel-5.6.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minus+static_output-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minus+static_output-devel}"
SRC_URI[x86_64_v2_rust-minus+static_output-devel.sha256sum] = "0a4ec084de283abc161e35209c27bae5e8a95af644ef80f1873d4a3dc9990016"

URI_x86_64_v2_rust-minus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minus-devel-5.6.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minus-devel}"
SRC_URI[x86_64_v2_rust-minus-devel.sha256sum] = "bbf1bc284b913d57a5962d50cfe146d09f38150d9030678786f1b22691118e49"

URI_aarch64_rust-minus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minus+default-devel-5.6.1-5.el10_3.noarch.rpm;name=aarch64_rust-minus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minus+default-devel}"
SRC_URI[aarch64_rust-minus+default-devel.sha256sum] = "7337f4a189d3391282bef23c90799766fe99c26de9ebe5956cf94bc73c892548"

URI_aarch64_rust-minus+dynamic_output-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minus+dynamic_output-devel-5.6.1-5.el10_3.noarch.rpm;name=aarch64_rust-minus+dynamic_output-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minus+dynamic_output-devel}"
SRC_URI[aarch64_rust-minus+dynamic_output-devel.sha256sum] = "8879d5730c073d9779b8dc3b7868b81dc606c74f2d8262ebe1a4a979f13be4c6"

URI_aarch64_rust-minus+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minus+regex-devel-5.6.1-5.el10_3.noarch.rpm;name=aarch64_rust-minus+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minus+regex-devel}"
SRC_URI[aarch64_rust-minus+regex-devel.sha256sum] = "80ffe94a9fb509c7acb96384df6c1142459b8c5a5cb26b196543a5ffc1ab60de"

URI_aarch64_rust-minus+search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minus+search-devel-5.6.1-5.el10_3.noarch.rpm;name=aarch64_rust-minus+search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minus+search-devel}"
SRC_URI[aarch64_rust-minus+search-devel.sha256sum] = "4b1090fa67fd31ade32d7d6813297c6737832c62557e990ba15616a711acec6c"

URI_aarch64_rust-minus+static_output-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minus+static_output-devel-5.6.1-5.el10_3.noarch.rpm;name=aarch64_rust-minus+static_output-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minus+static_output-devel}"
SRC_URI[aarch64_rust-minus+static_output-devel.sha256sum] = "64081f1b4fbd5beb2964acba7d540a9914f1f5cc41784d3c86fa7439eb788292"

URI_aarch64_rust-minus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minus-devel-5.6.1-5.el10_3.noarch.rpm;name=aarch64_rust-minus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minus-devel}"
SRC_URI[aarch64_rust-minus-devel.sha256sum] = "20862eda87eb4394a752d8d9a8e0c92d9c871ba456f4389ea93d30ae05ec41e0"

RDEPENDS:rust-minus+default-devel = " \
 cargo \
 rust-minus-devel \
 "
RDEPENDS:rust-minus+dynamic_output-devel = " \
 cargo \
 rust-minus-devel \
 "
RDEPENDS:rust-minus+regex-devel = " \
 cargo \
 rust-minus-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-minus+search-devel = " \
 cargo \
 rust-minus+regex-devel \
 rust-minus-devel \
 "
RDEPENDS:rust-minus+static_output-devel = " \
 cargo \
 rust-minus-devel \
 "
RDEPENDS:rust-minus-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-crossterm0.27+default-devel \
 rust-once_cell+default-devel \
 rust-once_cell+parking_lot-devel \
 rust-parking_lot+default-devel \
 rust-textwrap+unicode-width-devel \
 rust-textwrap-devel \
 rust-thiserror1+default-devel \
 "
