# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osbuild-composer"
PV = "149"
PR = "6.el10_1.alma.3"
PACKAGES = " \
 osbuild-composer \
 osbuild-composer-core \
 osbuild-composer-worker \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osbuild-composer-149-6.el10_1.alma.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14742090b0c59fb30b09b3e6626eee73215ce9fbef44f16149ab127287b6b0b4"

URI_x86_64_v2_osbuild-composer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-composer-149-6.el10_1.alma.3.x86_64_v2.rpm;name=x86_64_v2_osbuild-composer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-composer}"
SRC_URI[x86_64_v2_osbuild-composer.sha256sum] = "2e45c124f73f07c6eeea2e50a3caae2aee9ec2462b0b13d3e6568227346003ef"

URI_x86_64_v2_osbuild-composer-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-composer-core-149-6.el10_1.alma.3.x86_64_v2.rpm;name=x86_64_v2_osbuild-composer-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-composer-core}"
SRC_URI[x86_64_v2_osbuild-composer-core.sha256sum] = "310ec9310bb7399445e8e43f03c63cdf0dab00037dc6fb698dbc54904bcfefd3"

URI_x86_64_v2_osbuild-composer-worker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-composer-worker-149-6.el10_1.alma.3.x86_64_v2.rpm;name=x86_64_v2_osbuild-composer-worker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-composer-worker}"
SRC_URI[x86_64_v2_osbuild-composer-worker.sha256sum] = "53b2fb8e9e92ed0e52d2909b8488cf2db6f636bb83080fad66e286b6fdb84bd4"

URI_aarch64_osbuild-composer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-composer-149-6.el10_1.alma.3.aarch64.rpm;name=aarch64_osbuild-composer;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-composer}"
SRC_URI[aarch64_osbuild-composer.sha256sum] = "e1110b9b020b7859e67b9df4803e257dfc0226122371a47a0503ab55f253d63e"

URI_aarch64_osbuild-composer-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-composer-core-149-6.el10_1.alma.3.aarch64.rpm;name=aarch64_osbuild-composer-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-composer-core}"
SRC_URI[aarch64_osbuild-composer-core.sha256sum] = "3427b98c25c8ed4da71a6b656a4200b7972a0dd69bea769687872aea30157570"

URI_aarch64_osbuild-composer-worker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-composer-worker-149-6.el10_1.alma.3.aarch64.rpm;name=aarch64_osbuild-composer-worker;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-composer-worker}"
SRC_URI[aarch64_osbuild-composer-worker.sha256sum] = "89058db201b99fcd94f0c26581aefa175cfd59bcbfd19078a30ada97fc5c2c17"

RDEPENDS:osbuild-composer = " \
 bash \
 osbuild-composer-core \
 osbuild-composer-worker \
 systemd \
 "
RDEPENDS:osbuild-composer-core = " \
 glibc \
 gpgme \
 libxcrypt \
 osbuild-depsolve-dnf \
 "
RDEPENDS:osbuild-composer-worker = " \
 bash \
 glibc \
 gpgme \
 krb5-libs \
 libcom_err \
 libxcrypt \
 osbuild \
 osbuild-depsolve-dnf \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 qemu-img \
 systemd \
 "
