# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cliff"
PV = "4.13.3"
PR = "1.el10_3"
PACKAGES = " \
 python3-cliff \
 python3-cliff-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cliff-4.13.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "126e7255849f8f5570fab0acf3948097082ae0ff9826ad03450fd82e3d230c77"

URI_x86_64_v2_python3-cliff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cliff-4.13.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cliff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cliff}"
SRC_URI[x86_64_v2_python3-cliff.sha256sum] = "f56a7ff75980e3db1631bebdf86491d9c983f00a41f238389fed4d2a11e7910c"

URI_x86_64_v2_python3-cliff-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cliff-tests-4.13.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cliff-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cliff-tests}"
SRC_URI[x86_64_v2_python3-cliff-tests.sha256sum] = "c282153a0318e4056291353a45669cab05f85a25443639b945e8f86b44e30f20"

URI_aarch64_python3-cliff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cliff-4.13.3-1.el10_3.noarch.rpm;name=aarch64_python3-cliff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cliff}"
SRC_URI[aarch64_python3-cliff.sha256sum] = "ee189597034b9202e600d5da48798c49a563fa78fdc2f4de5993e0de6c343281"

URI_aarch64_python3-cliff-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cliff-tests-4.13.3-1.el10_3.noarch.rpm;name=aarch64_python3-cliff-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cliff-tests}"
SRC_URI[aarch64_python3-cliff-tests.sha256sum] = "e4857429e63acf1f4c3984210186f0ca723ad78927106cc77d7d66a2cd100863"

RDEPENDS:python3-cliff = " \
 python3 \
 python3-autopage \
 python3-cmd2 \
 python3-prettytable \
 python3-pyyaml \
 python3-stevedore \
 "
RDEPENDS:python3-cliff-tests = " \
 bash \
 python3 \
 python3-cliff \
 python3-fixtures \
 python3-pyyaml \
 python3-subunit \
 python3-testscenarios \
 python3-testtools \
 which \
 "
