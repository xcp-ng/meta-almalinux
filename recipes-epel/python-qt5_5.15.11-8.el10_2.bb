# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-qt5"
PV = "5.15.11"
PR = "8.el10_2"
PACKAGES = " \
 python-qt5-doc \
 python-qt5-rpm-macros \
 python3-qt5 \
 python3-qt5-base \
 python3-qt5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-qt5-5.15.11-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79dd2c59d9149c120270d9393116c2265fbf5ecb41eaca98772481232d0a40b4"

URI_x86_64_v2_python-qt5-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-qt5-doc-5.15.11-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-qt5-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-qt5-doc}"
SRC_URI[x86_64_v2_python-qt5-doc.sha256sum] = "671101fa9e03aa79bf516b6ebd33c19470539c8207520b5ee8e6eeccbe166523"

URI_x86_64_v2_python-qt5-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-qt5-rpm-macros-5.15.11-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-qt5-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-qt5-rpm-macros}"
SRC_URI[x86_64_v2_python-qt5-rpm-macros.sha256sum] = "110c75ef79ce99feb92aa6742108129f84186aee0de0e11d52c951a63ea92dd0"

URI_x86_64_v2_python3-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-qt5-5.15.11-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-qt5}"
SRC_URI[x86_64_v2_python3-qt5.sha256sum] = "2c2658b1fe5f7a0046279a81dd48955579ccf4380f5a968cca49a4499fb266fd"

URI_x86_64_v2_python3-qt5-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-qt5-base-5.15.11-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-qt5-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-qt5-base}"
SRC_URI[x86_64_v2_python3-qt5-base.sha256sum] = "80eb10644dcb20cb3bc1950cc971b0ca32acb0e378404ad31a2d9153256d391c"

URI_x86_64_v2_python3-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-qt5-devel-5.15.11-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-qt5-devel}"
SRC_URI[x86_64_v2_python3-qt5-devel.sha256sum] = "6cf9b59a1a9da55c5b4a110a2e7fd41eda89c6ecff30c78372337c4671d24946"

URI_aarch64_python-qt5-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-qt5-doc-5.15.11-8.el10_2.noarch.rpm;name=aarch64_python-qt5-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-qt5-doc}"
SRC_URI[aarch64_python-qt5-doc.sha256sum] = "74f7ce49cf32a4ca728223d86984771a40b32812c72610b25a3bf328455703ea"

URI_aarch64_python-qt5-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/p/python-qt5-rpm-macros-5.15.11-8.el10_2.noarch.rpm;name=aarch64_python-qt5-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-qt5-rpm-macros}"
SRC_URI[aarch64_python-qt5-rpm-macros.sha256sum] = "f89814e595a4270bf90ed90851151ff422ae322d6eccdb1bb123981165e8ec17"

URI_aarch64_python3-qt5 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-qt5-5.15.11-8.el10_2.aarch64.rpm;name=aarch64_python3-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-qt5}"
SRC_URI[aarch64_python3-qt5.sha256sum] = "e6698f71e4c64067c12f9ead15c8e1f2b991752a362aa84638035ee3b23e2a63"

URI_aarch64_python3-qt5-base = "${EPEL_MIRROR}/aarch64/Packages/p/python3-qt5-base-5.15.11-8.el10_2.aarch64.rpm;name=aarch64_python3-qt5-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-qt5-base}"
SRC_URI[aarch64_python3-qt5-base.sha256sum] = "7501b13c1e61bbb3c209dc2da614af15544485943c512da9cb0e34275622f8b8"

URI_aarch64_python3-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-qt5-devel-5.15.11-8.el10_2.aarch64.rpm;name=aarch64_python3-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-qt5-devel}"
SRC_URI[aarch64_python3-qt5-devel.sha256sum] = "c40884df0c9c25f1464ce8cf58e9909cdca349e604036c099a7144b089042c92"

RDEPENDS:python-qt5-doc = " \
 "
RDEPENDS:python-qt5-rpm-macros = " \
 "
RDEPENDS:python3-qt5 = " \
 glibc \
 libstdc++ \
 python3 \
 python3-qt5-base \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtconnectivity \
 qt5-qtdeclarative \
 qt5-qtlocation \
 qt5-qtmultimedia \
 qt5-qtsensors \
 qt5-qtserialport \
 qt5-qtsvg \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-help \
 qt5-qtwebchannel \
 qt5-qtwebsockets \
 qt5-qtx11extras \
 qt5-qtxmlpatterns \
 "
RDEPENDS:python3-qt5-base = " \
 bash \
 dbus-libs \
 glibc \
 libgcc \
 libstdc++ \
 python-qt5-rpm-macros \
 python3 \
 python3-dbus \
 python3-libs \
 python3-pyqt5-sip \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:python3-qt5-devel = " \
 python3-qt5 \
 qt5-qtbase-devel \
 "
