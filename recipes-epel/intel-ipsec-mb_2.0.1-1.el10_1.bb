# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-ipsec-mb"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 intel-ipsec-mb \
 intel-ipsec-mb-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-ipsec-mb-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d1d0b6b14e67bfda82a7b7ad704f5e73cf3c1b6ee158a0afd778b3d22cc32dc"

URI_x86_64_v2_intel-ipsec-mb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-ipsec-mb-2.0.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-ipsec-mb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-ipsec-mb}"
SRC_URI[x86_64_v2_intel-ipsec-mb.sha256sum] = "8f37706f44e8ae9b842504060ce8e4822c2405fe2f205fd70402d7c114a3a1ce"

URI_x86_64_v2_intel-ipsec-mb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-ipsec-mb-devel-2.0.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-ipsec-mb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-ipsec-mb-devel}"
SRC_URI[x86_64_v2_intel-ipsec-mb-devel.sha256sum] = "32ca6aba08b36d1fed0e052fdeda484812f176201eb25a2eeef3e3c2bb387805"

RDEPENDS:intel-ipsec-mb = " \
 glibc \
 "
RDEPENDS:intel-ipsec-mb-devel = " \
 intel-ipsec-mb \
 "
