# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kirigami-addons"
PV = "1.13.1"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kirigami-addons \
 kf6-kirigami-addons-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kirigami-addons-1.13.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f573104139bae833c45e96bf0b32a3c53a60bcccef26939b80707f33899cf0b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-addons-1.13.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-addons;unpack=0"
SRC_URI[x86_64_v2_kf6-kirigami-addons.sha256sum] = "3c64b97ddba7a0f2afd9573251d50ee44c6481f8e635920e8c9326c4a579a47f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-addons-devel-1.13.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-addons-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kirigami-addons-devel.sha256sum] = "6d1b292965fb107a64d6834da03df7266254fb6be5e9830fddf8606621e9dc43"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-addons-1.13.1-1.el10_3.aarch64.rpm;name=aarch64_kf6-kirigami-addons;unpack=0"
SRC_URI[aarch64_kf6-kirigami-addons.sha256sum] = "e0a871563f145482a8c2e74c02e8a0b0724b936d8e78850a66f0c1da70ecce21"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-addons-devel-1.13.1-1.el10_3.aarch64.rpm;name=aarch64_kf6-kirigami-addons-devel;unpack=0"
SRC_URI[aarch64_kf6-kirigami-addons-devel.sha256sum] = "fcb1f11be78b2d38c21e23479c94604e2f9f9f773476ec3605476a8efebdda09"

RDEPENDS:kf6-kirigami-addons = " \
 glibc \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kirigami-addons-devel = " \
 cmake-filesystem \
 kf6-kirigami-addons \
 "
