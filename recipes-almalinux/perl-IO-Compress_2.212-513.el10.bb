# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Compress"
PV = "2.212"
PR = "513.el10"
PACKAGES = " \
 perl-IO-Compress \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-IO-Compress-2.212-513.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "73aba47b7f3dbc6101d3375ba977e87141a3340c9fa76db93a7221d6a060e185"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IO-Compress-2.212-513.el10.noarch.rpm;name=x86_64_v2_perl-IO-Compress;unpack=0"
SRC_URI[x86_64_v2_perl-IO-Compress.sha256sum] = "7da36b61edd405e4edace3be355ab0bec59a259eda3a7c83b4407cc21c2841bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IO-Compress-2.212-513.el10.noarch.rpm;name=aarch64_perl-IO-Compress;unpack=0"
SRC_URI[aarch64_perl-IO-Compress.sha256sum] = "7da36b61edd405e4edace3be355ab0bec59a259eda3a7c83b4407cc21c2841bd"

RDEPENDS:perl-IO-Compress = " \
 perl-Carp \
 perl-Compress-Raw-Bzip2 \
 perl-Compress-Raw-Zlib \
 perl-Data-Dumper \
 perl-Encode \
 perl-Exporter \
 perl-Fcntl \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-Compress \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-Time-Local \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-parent \
 "
