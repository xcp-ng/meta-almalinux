# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libosinfo"
PV = "1.11.0"
PR = "8.el10"
PACKAGES = " \
 libosinfo \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libosinfo-1.11.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "420cec299c20393b344039976486f4d0d3dbf3ec3176a70584d85ad716c21b95"

URI_x86_64_v2_libosinfo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libosinfo-1.11.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_libosinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libosinfo}"
SRC_URI[x86_64_v2_libosinfo.sha256sum] = "3d34c159318d044514638cabe4a78564455112515fdbd5e099b2f67b1784b1f9"

URI_aarch64_libosinfo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libosinfo-1.11.0-8.el10.aarch64.rpm;name=aarch64_libosinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libosinfo}"
SRC_URI[aarch64_libosinfo.sha256sum] = "d814551accf121b5ebe66b4d7c42bf7fd09a4de30f9c13c99937ac7efad8ee3c"

RDEPENDS:libosinfo = " \
 glib2 \
 glibc \
 hwdata \
 libgcc \
 libsoup3 \
 libxml2 \
 libxslt \
 osinfo-db \
 osinfo-db-tools \
 "
