# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-loader"
PV = "1.4.341.0"
PR = "1.el10"
PACKAGES = " \
 vulkan-loader \
 vulkan-loader-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-loader-1.4.341.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df9750218f21128a7b16f261be30f698b500e148761d522c9e9b7fc8b8819c36"

URI_x86_64_v2_vulkan-loader = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-loader-1.4.341.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-loader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-loader}"
SRC_URI[x86_64_v2_vulkan-loader.sha256sum] = "6257b1aa5d24645197bbd687c07377ab2512dc0435e7ec86f9f5633ca13416e1"

URI_x86_64_v2_vulkan-loader-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-loader-devel-1.4.341.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-loader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-loader-devel}"
SRC_URI[x86_64_v2_vulkan-loader-devel.sha256sum] = "3b677806d7c2cac16ef85fd5973731ab670259f64fc478557bf37224a6214923"

URI_aarch64_vulkan-loader = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-loader-1.4.341.0-1.el10.aarch64.rpm;name=aarch64_vulkan-loader;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-loader}"
SRC_URI[aarch64_vulkan-loader.sha256sum] = "5a81b8390b6a68d9a232eae6dd57a47385937dd2242dcb5755d44bb03db1901f"

URI_aarch64_vulkan-loader-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-loader-devel-1.4.341.0-1.el10.aarch64.rpm;name=aarch64_vulkan-loader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-loader-devel}"
SRC_URI[aarch64_vulkan-loader-devel.sha256sum] = "c822196b30f5ac024f59b0ab6328948730ed88ea57f6eff29e4371b073546559"

RDEPENDS:vulkan-loader = " \
 glibc \
 "
RDEPENDS:vulkan-loader-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 vulkan-headers \
 vulkan-loader \
 "
