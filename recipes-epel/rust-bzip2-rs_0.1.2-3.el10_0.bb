# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bzip2-rs"
PV = "0.1.2"
PR = "3.el10_0"
PACKAGES = " \
 rust-bzip2-rs+default-devel \
 rust-bzip2-rs+rustc_1_37-devel \
 rust-bzip2-rs+rustc_1_40-devel \
 rust-bzip2-rs+rustc_1_51-devel \
 rust-bzip2-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bzip2-rs-0.1.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be7ff2db2c0e90ddb7ab58093d5f029b62b219a455c638ea48e55665c3a8254d"

URI_x86_64_v2_rust-bzip2-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-rs+default-devel-0.1.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-rs+default-devel}"
SRC_URI[x86_64_v2_rust-bzip2-rs+default-devel.sha256sum] = "54b5fa5e1049197cdf85f1fffb378d5c0c65fc96f5418737faa2d92041647084"

URI_x86_64_v2_rust-bzip2-rs+rustc_1_37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-rs+rustc_1_37-devel-0.1.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-rs+rustc_1_37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-rs+rustc_1_37-devel}"
SRC_URI[x86_64_v2_rust-bzip2-rs+rustc_1_37-devel.sha256sum] = "871877d94c9ade2afc5088199ca6c5e437bdeb9f70d03af8baacddd11edff42b"

URI_x86_64_v2_rust-bzip2-rs+rustc_1_40-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-rs+rustc_1_40-devel-0.1.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-rs+rustc_1_40-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-rs+rustc_1_40-devel}"
SRC_URI[x86_64_v2_rust-bzip2-rs+rustc_1_40-devel.sha256sum] = "dc94c1132a5aee19eb3cc9c1d9a5e9f70fc6742f894c850bd2983f68403ec38d"

URI_x86_64_v2_rust-bzip2-rs+rustc_1_51-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-rs+rustc_1_51-devel-0.1.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-rs+rustc_1_51-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-rs+rustc_1_51-devel}"
SRC_URI[x86_64_v2_rust-bzip2-rs+rustc_1_51-devel.sha256sum] = "4861a2e7ae58f0983a8b32b4d81711a15a143f35b3fb0f5aa3d8af3e102c6195"

URI_x86_64_v2_rust-bzip2-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-rs-devel-0.1.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-rs-devel}"
SRC_URI[x86_64_v2_rust-bzip2-rs-devel.sha256sum] = "715360fd411a45e7f6de1a9f7fbff1778647fd216e23a80e4c9af6e38100c04f"

URI_aarch64_rust-bzip2-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-rs+default-devel-0.1.2-3.el10_0.noarch.rpm;name=aarch64_rust-bzip2-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-rs+default-devel}"
SRC_URI[aarch64_rust-bzip2-rs+default-devel.sha256sum] = "5b4ef35ac0d174c78e3ecd9d1e0984ff09189c3deefd60dbf0f0159e56a92a4a"

URI_aarch64_rust-bzip2-rs+rustc_1_37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-rs+rustc_1_37-devel-0.1.2-3.el10_0.noarch.rpm;name=aarch64_rust-bzip2-rs+rustc_1_37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-rs+rustc_1_37-devel}"
SRC_URI[aarch64_rust-bzip2-rs+rustc_1_37-devel.sha256sum] = "0d6d43c65f0c0f5a072bfdeec297e8ca601955001a915a234a74ebcbc7cf84cf"

URI_aarch64_rust-bzip2-rs+rustc_1_40-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-rs+rustc_1_40-devel-0.1.2-3.el10_0.noarch.rpm;name=aarch64_rust-bzip2-rs+rustc_1_40-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-rs+rustc_1_40-devel}"
SRC_URI[aarch64_rust-bzip2-rs+rustc_1_40-devel.sha256sum] = "cc4822269022e3b31a1d3dcd0dc8b1b795c5c708cb894bf864f9907e68d26c3f"

URI_aarch64_rust-bzip2-rs+rustc_1_51-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-rs+rustc_1_51-devel-0.1.2-3.el10_0.noarch.rpm;name=aarch64_rust-bzip2-rs+rustc_1_51-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-rs+rustc_1_51-devel}"
SRC_URI[aarch64_rust-bzip2-rs+rustc_1_51-devel.sha256sum] = "31d18e50a70a09b781310e49042c3ece63ab19b205eb9840ec5ad13b3f19bc19"

URI_aarch64_rust-bzip2-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-rs-devel-0.1.2-3.el10_0.noarch.rpm;name=aarch64_rust-bzip2-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-rs-devel}"
SRC_URI[aarch64_rust-bzip2-rs-devel.sha256sum] = "d26010aff9c02db18c5a37726eee1e6315f93645ed7dcc95267b3013796b5b00"

RDEPENDS:rust-bzip2-rs+default-devel = " \
 cargo \
 rust-bzip2-rs-devel \
 "
RDEPENDS:rust-bzip2-rs+rustc_1_37-devel = " \
 cargo \
 rust-bzip2-rs-devel \
 "
RDEPENDS:rust-bzip2-rs+rustc_1_40-devel = " \
 cargo \
 rust-bzip2-rs+rustc_1_37-devel \
 rust-bzip2-rs-devel \
 rust-tinyvec+rustc_1_40-devel \
 "
RDEPENDS:rust-bzip2-rs+rustc_1_51-devel = " \
 cargo \
 rust-bzip2-rs-devel \
 "
RDEPENDS:rust-bzip2-rs-devel = " \
 cargo \
 rust-crc32fast+default-devel \
 rust-tinyvec+default-devel \
 "
