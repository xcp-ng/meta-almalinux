# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-bitarray"
PV = "3.10.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-bitarray \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-bitarray-3.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "edb777dd65f2b9afc3b0974565a694a821f40e1850f7b3af4780574dc7dd3ab7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bitarray-3.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-bitarray;unpack=0"
SRC_URI[x86_64_v2_python3-bitarray.sha256sum] = "f9db71193c4f5ce31eb9bc06f14b1401f5516bd0348d066e77419d195b86356d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-bitarray-3.10.1-1.el10_2.aarch64.rpm;name=aarch64_python3-bitarray;unpack=0"
SRC_URI[aarch64_python3-bitarray.sha256sum] = "4a4a766fbaa99ece2533564e535a01e4decdaa7c926cbc192dfcc715a89138be"

RDEPENDS:python3-bitarray = " \
 glibc \
 python3 \
 "
