# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ncftp"
PE = "2"
PV = "3.3.0"
PR = "1.el10_1"
PACKAGES = " \
 ncftp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ncftp-3.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27eaae024297313b684c978ca7c1178f792b4f358ed1ccb007c1da86615c5143"

URI_x86_64_v2_ncftp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ncftp-3.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ncftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncftp}"
SRC_URI[x86_64_v2_ncftp.sha256sum] = "9bfc4693ea737bb2084137660b78db3954ffd201d2cac9105c46e2b89ce12fa5"

URI_aarch64_ncftp = "${EPEL_MIRROR}/aarch64/Packages/n/ncftp-3.3.0-1.el10_1.aarch64.rpm;name=aarch64_ncftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncftp}"
SRC_URI[aarch64_ncftp.sha256sum] = "221ee4b08803040b29b1b2f2b00538da11cc80573e8c39467f2068b140c9ee42"

RDEPENDS:ncftp = " \
 glibc \
 ncurses-libs \
 "
