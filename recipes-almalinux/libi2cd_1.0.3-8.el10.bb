# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libi2cd"
PV = "1.0.3"
PR = "8.el10"
PACKAGES = " \
 libi2cd \
 libi2cd-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libi2cd-1.0.3-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f113efc938aee39c35c3f856c7f0024734a3b14c003ac7d25e3d87c35ae2d666"

URI_x86_64_v2_libi2cd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libi2cd-1.0.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_libi2cd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libi2cd}"
SRC_URI[x86_64_v2_libi2cd.sha256sum] = "1e8f63984facfd35a9eaa21bbc7133f3fd0ac0d5d3a805ec0219e1eeda019732"

URI_x86_64_v2_libi2cd-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libi2cd-devel-1.0.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_libi2cd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libi2cd-devel}"
SRC_URI[x86_64_v2_libi2cd-devel.sha256sum] = "1d1204deac47d0b60ab93762e067c96907f320a09b48498a6b3d862e60c95f67"

URI_aarch64_libi2cd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libi2cd-1.0.3-8.el10.aarch64.rpm;name=aarch64_libi2cd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libi2cd}"
SRC_URI[aarch64_libi2cd.sha256sum] = "6d18816deb3a95f2376833af05cb24da6941e5ec35547d5f3660949389423558"

URI_aarch64_libi2cd-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libi2cd-devel-1.0.3-8.el10.aarch64.rpm;name=aarch64_libi2cd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libi2cd-devel}"
SRC_URI[aarch64_libi2cd-devel.sha256sum] = "631143058e4841d5004f1c8531373083cc340d71b3a3628e638c8c75cdb09050"

RDEPENDS:libi2cd = " \
 glibc \
 "
RDEPENDS:libi2cd-devel = " \
 libi2cd \
 pkgconf-pkg-config \
 "
