# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "memcached"
PV = "1.6.23"
PR = "7.el10"
PACKAGES = " \
 memcached \
 memcached-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/memcached-1.6.23-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e72859b4660d02a7cfc4b3d6feb1e7f94b128d50a2608581161bb58f2acbc2a"

URI_x86_64_v2_memcached = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/memcached-1.6.23-7.el10.x86_64_v2.rpm;name=x86_64_v2_memcached;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_memcached}"
SRC_URI[x86_64_v2_memcached.sha256sum] = "f9427301df951253811e9e63a1414a09a106d7daf9a6914777dd47b19615e626"

URI_x86_64_v2_memcached-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/memcached-selinux-1.6.23-7.el10.x86_64_v2.rpm;name=x86_64_v2_memcached-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_memcached-selinux}"
SRC_URI[x86_64_v2_memcached-selinux.sha256sum] = "b36a7a21dc10f1d8459f46874ebd9eea040cc08b9fa1f67d1362a2e6c0eda762"

URI_aarch64_memcached = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/memcached-1.6.23-7.el10.aarch64.rpm;name=aarch64_memcached;unpack=0"
SRC_URI:append = " ${URI_aarch64_memcached}"
SRC_URI[aarch64_memcached.sha256sum] = "3cdbc7c94c0f8cfdf6f816c1b4b868dc0ae437ae8845dbe62e2fcf92447157b5"

URI_aarch64_memcached-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/memcached-selinux-1.6.23-7.el10.aarch64.rpm;name=aarch64_memcached-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_memcached-selinux}"
SRC_URI[aarch64_memcached-selinux.sha256sum] = "9fdcae404c2f4e6cb0a9727119e2514c52129da73a2b6e4e631ec8dc4930e4a0"

RDEPENDS:memcached = " \
 bash \
 cyrus-sasl-lib \
 glibc \
 libevent \
 memcached-selinux \
 openssl-libs \
 perl-IO \
 perl-interpreter \
 perl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:memcached-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
