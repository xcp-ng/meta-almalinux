# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libquotient"
PV = "0.9.2"
PR = "2.el10_1"
PACKAGES = " \
 libquotient-qt6 \
 libquotient-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libquotient-0.9.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3236f9b727cad07f019b19fcb0f20e178f8e508570f0ff0476163c22070894d"

URI_x86_64_v2_libquotient-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquotient-qt6-0.9.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquotient-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquotient-qt6}"
SRC_URI[x86_64_v2_libquotient-qt6.sha256sum] = "768c7f10eec22c608c8329e472ca88a028a0340c151f56539a68b0d2c0d72c0e"

URI_x86_64_v2_libquotient-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquotient-qt6-devel-0.9.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquotient-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquotient-qt6-devel}"
SRC_URI[x86_64_v2_libquotient-qt6-devel.sha256sum] = "6ceb6e27a1abb5966c35cd11c5e9b0bd2fe9233233be3e5ad87adf5498a04cbb"

URI_aarch64_libquotient-qt6 = "${EPEL_MIRROR}/aarch64/Packages/l/libquotient-qt6-0.9.2-2.el10_1.aarch64.rpm;name=aarch64_libquotient-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquotient-qt6}"
SRC_URI[aarch64_libquotient-qt6.sha256sum] = "f2e8aaa67f2eef72e94a3d9dbfb8c09b0409098e63d3ec72daa7f7cca503c4fe"

URI_aarch64_libquotient-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libquotient-qt6-devel-0.9.2-2.el10_1.aarch64.rpm;name=aarch64_libquotient-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquotient-qt6-devel}"
SRC_URI[aarch64_libquotient-qt6-devel.sha256sum] = "80bf23ccc070951173810ec089ffe69c567facc7fabe2cbedb9b418bdb2665e6"

RDEPENDS:libquotient-qt6 = " \
 glibc \
 libolm \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:libquotient-qt6-devel = " \
 cmake-filesystem \
 libolm-devel \
 libquotient-qt6 \
 openssl-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qtkeychain-qt6-devel \
 "
