# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mongodb"
PV = "1.21.5"
PR = "1.el10_2"
PACKAGES = " \
 php-pecl-mongodb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mongodb-1.21.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0081a898bdfc00cb99ab6725b1454cb4045391bf2bb772c8b10b4bb2b79719d"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - php-pecl-mongodb: libbson-1.0.so.0()(64bit)
# - php-pecl-mongodb: libmongoc-1.0.so.0()(64bit)

URI_x86_64_v2_php-pecl-mongodb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mongodb-1.21.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mongodb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-mongodb}"
SRC_URI[x86_64_v2_php-pecl-mongodb.sha256sum] = "f5b5070997635d1c1ed460573ce45d72a0d0b4baf7a8a7a11504d961555f4a4f"

URI_aarch64_php-pecl-mongodb = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mongodb-1.21.5-1.el10_2.aarch64.rpm;name=aarch64_php-pecl-mongodb;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-mongodb}"
SRC_URI[aarch64_php-pecl-mongodb.sha256sum] = "b9d0dbbf5099479830812cdb2d47712d14f8831a07c75d8b30774610946b6a82"

RDEPENDS:php-pecl-mongodb:x86_64_v2 = " \
 glibc \
 libmongocrypt \
 php8.4-common \
 virtual/php-json_x86-64_ \
"
RDEPENDS:php-pecl-mongodb:aarch64 = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php8.4-common \
 virtual/php-json_aarch-64_ \
"
