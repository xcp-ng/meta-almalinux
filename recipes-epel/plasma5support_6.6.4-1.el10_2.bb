# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma5support"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma5support \
 plasma5support-devel \
 plasma5support-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma5support-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d5d860da00e4d5c4289bb5c5272a4ff3666f8036e39961a6cd21b75d973634f"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - plasma5support: libgps.so.31()(64bit)

URI_x86_64_v2_plasma5support = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma5support;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma5support}"
SRC_URI[x86_64_v2_plasma5support.sha256sum] = "33aed989b7a7a7ac53029e2c7f282997ade3e6ae9be18c85078daddf8e3da482"

URI_x86_64_v2_plasma5support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma5support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma5support-devel}"
SRC_URI[x86_64_v2_plasma5support-devel.sha256sum] = "fba27b85caff63f24a128635f27b22ced7d2aff73ce79f27e8ae7c202ef3fbb4"

URI_x86_64_v2_plasma5support-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-doc-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_plasma5support-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma5support-doc}"
SRC_URI[x86_64_v2_plasma5support-doc.sha256sum] = "4971d820c8a19c1359922ab3d58878c433dda2d52dcfc1cd5eaedc2d258ec464"

URI_aarch64_plasma5support = "${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma5support;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma5support}"
SRC_URI[aarch64_plasma5support.sha256sum] = "25f5661e79bddc6b504dbc5669139a676847a4c2ac8e73885e0de32f9b727384"

URI_aarch64_plasma5support-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma5support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma5support-devel}"
SRC_URI[aarch64_plasma5support-devel.sha256sum] = "8f76b0a6c25cd3066c38d5ceb0dc832a12a84d1b88e209316f6040604ade9820"

URI_aarch64_plasma5support-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-doc-6.6.4-1.el10_2.noarch.rpm;name=aarch64_plasma5support-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma5support-doc}"
SRC_URI[aarch64_plasma5support-doc.sha256sum] = "3301e43b46384d5545ffc76e167a825f5a961223aa989195e75b849701ec172d"

RDEPENDS:plasma5support:x86_64_v2 = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kunitconversion \
 kf6-networkmanager-qt \
 kf6-solid \
 libX11 \
 libXfixes \
 libksysguard \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
"
RDEPENDS:plasma5support:aarch64 = " \
 glibc \
 gpsd-libs \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kunitconversion \
 kf6-networkmanager-qt \
 kf6-solid \
 libX11 \
 libXfixes \
 libksysguard \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
"
RDEPENDS:plasma5support-devel = " \
 cmake-filesystem \
 plasma5support \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma5support-doc = " \
 "
