# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_with"
PV = "3.12.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde_with+alloc-devel \
 rust-serde_with+base64-devel \
 rust-serde_with+chrono-devel \
 rust-serde_with+chrono_0_4-devel \
 rust-serde_with+default-devel \
 rust-serde_with+guide-devel \
 rust-serde_with+hashbrown_0_14-devel \
 rust-serde_with+hex-devel \
 rust-serde_with+indexmap-devel \
 rust-serde_with+indexmap_1-devel \
 rust-serde_with+indexmap_2-devel \
 rust-serde_with+json-devel \
 rust-serde_with+macros-devel \
 rust-serde_with+schemars_0_8-devel \
 rust-serde_with+std-devel \
 rust-serde_with+time_0_3-devel \
 rust-serde_with-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_with-3.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f729b2195531e3206a8edca42cac0e5a5c71daf13efc7e098c83a81093377d7"

URI_x86_64_v2_rust-serde_with+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+alloc-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_with+alloc-devel.sha256sum] = "1a91f3085aa34bc3792990529d17045865e942e722298847fdcc1c76a2f296ef"

URI_x86_64_v2_rust-serde_with+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+base64-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+base64-devel}"
SRC_URI[x86_64_v2_rust-serde_with+base64-devel.sha256sum] = "656bf64bff2a41c157789885c55dff56e140ce8fb439bec26fa7f70070166d2b"

URI_x86_64_v2_rust-serde_with+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+chrono-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+chrono-devel}"
SRC_URI[x86_64_v2_rust-serde_with+chrono-devel.sha256sum] = "a0a9fefed0069e226c8dea612ca2330b2402aae3a4f7a571e6676104fc4244c8"

URI_x86_64_v2_rust-serde_with+chrono_0_4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+chrono_0_4-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+chrono_0_4-devel}"
SRC_URI[x86_64_v2_rust-serde_with+chrono_0_4-devel.sha256sum] = "f6810297601e0418cdf2a9c32752bd96ba5db3e3f286e083c3d2509687670b5d"

URI_x86_64_v2_rust-serde_with+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+default-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+default-devel}"
SRC_URI[x86_64_v2_rust-serde_with+default-devel.sha256sum] = "dece7a8cb7550017150c0c6d97e48e1ab6f330a01c67c267b5357a3e6c027ee0"

URI_x86_64_v2_rust-serde_with+guide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+guide-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+guide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+guide-devel}"
SRC_URI[x86_64_v2_rust-serde_with+guide-devel.sha256sum] = "22231411b495f2081987c52e33d4b932efdaaeabbb6fd0705e4e8dc03feb6208"

URI_x86_64_v2_rust-serde_with+hashbrown_0_14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+hashbrown_0_14-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+hashbrown_0_14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+hashbrown_0_14-devel}"
SRC_URI[x86_64_v2_rust-serde_with+hashbrown_0_14-devel.sha256sum] = "740a97e9865e99f8de6ac71380cee6ffa1f03a80b9366c103b41770542fb7e2f"

URI_x86_64_v2_rust-serde_with+hex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+hex-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+hex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+hex-devel}"
SRC_URI[x86_64_v2_rust-serde_with+hex-devel.sha256sum] = "d0c4687c88e2cc346077c7d865a7f7ef8b6944e63c4d07f90fe85951c08010b4"

URI_x86_64_v2_rust-serde_with+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+indexmap-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+indexmap-devel}"
SRC_URI[x86_64_v2_rust-serde_with+indexmap-devel.sha256sum] = "03f301e8a41f625c9826d7f75ddfcd1e418df6779a520d69283b288ed694a970"

URI_x86_64_v2_rust-serde_with+indexmap_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+indexmap_1-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+indexmap_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+indexmap_1-devel}"
SRC_URI[x86_64_v2_rust-serde_with+indexmap_1-devel.sha256sum] = "79549aa99d8a8d4a0c010539933e4b3a04a3b7a7892ad600025706a2bcfe2596"

URI_x86_64_v2_rust-serde_with+indexmap_2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+indexmap_2-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+indexmap_2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+indexmap_2-devel}"
SRC_URI[x86_64_v2_rust-serde_with+indexmap_2-devel.sha256sum] = "dd7c28c72e51104c1fc060282bdbe95337c0a845a3ad1ea530f59faf8eb4d47d"

URI_x86_64_v2_rust-serde_with+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+json-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+json-devel}"
SRC_URI[x86_64_v2_rust-serde_with+json-devel.sha256sum] = "aea72364a29970adb96b4f4d1fcfabac6411c178450e4d5daf4ac9920e91dda4"

URI_x86_64_v2_rust-serde_with+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+macros-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+macros-devel}"
SRC_URI[x86_64_v2_rust-serde_with+macros-devel.sha256sum] = "ff6d05b6c4f2fe4c9150fe715346a5445f9c21fbcc8cd808eff2b039a4e1736b"

URI_x86_64_v2_rust-serde_with+schemars_0_8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+schemars_0_8-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+schemars_0_8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+schemars_0_8-devel}"
SRC_URI[x86_64_v2_rust-serde_with+schemars_0_8-devel.sha256sum] = "25b26bf143e6d1dfa863bc9ef4131f218c81681f06dbd582f49a558e50b5fca1"

URI_x86_64_v2_rust-serde_with+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+std-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+std-devel}"
SRC_URI[x86_64_v2_rust-serde_with+std-devel.sha256sum] = "b3fa5e891c5a1382f5f809569987723a9f55834f68327f48d43463f6ba09b4b7"

URI_x86_64_v2_rust-serde_with+time_0_3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+time_0_3-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+time_0_3-devel}"
SRC_URI[x86_64_v2_rust-serde_with+time_0_3-devel.sha256sum] = "62402934b9ad2ee2096943ef12b276bb149247986dd4853a2772a9394ce25c8c"

URI_x86_64_v2_rust-serde_with-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with-devel}"
SRC_URI[x86_64_v2_rust-serde_with-devel.sha256sum] = "4545fe98dfd21fb3553544bad441dc115778a379ece4c3d7b61ee23a7c5289bb"

URI_aarch64_rust-serde_with+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+alloc-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+alloc-devel}"
SRC_URI[aarch64_rust-serde_with+alloc-devel.sha256sum] = "f33f03854bf118dbdb12ffe83dd6ff881c2ce884cfb5f9ec00c04a7d78736c63"

URI_aarch64_rust-serde_with+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+base64-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+base64-devel}"
SRC_URI[aarch64_rust-serde_with+base64-devel.sha256sum] = "4061dadb149cbfe6a4a2d05513360f0bfcdb96b5d1704dfa0131d18ecac89c73"

URI_aarch64_rust-serde_with+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+chrono-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+chrono-devel}"
SRC_URI[aarch64_rust-serde_with+chrono-devel.sha256sum] = "916cb7bd80d7d3d2e98ec5d00f987e75e00ec7ce294a2ae739988d250754d0ec"

URI_aarch64_rust-serde_with+chrono_0_4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+chrono_0_4-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+chrono_0_4-devel}"
SRC_URI[aarch64_rust-serde_with+chrono_0_4-devel.sha256sum] = "44a0c6b78b75bb159e91322d8e9a2577fbd03ff69c2600895267ae873b7f9492"

URI_aarch64_rust-serde_with+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+default-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+default-devel}"
SRC_URI[aarch64_rust-serde_with+default-devel.sha256sum] = "1e23dbbd10880b86b4fb48b4861468e24e0d1818f135afd8c4e49c4cb67a3eef"

URI_aarch64_rust-serde_with+guide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+guide-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+guide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+guide-devel}"
SRC_URI[aarch64_rust-serde_with+guide-devel.sha256sum] = "fa8f0ed51ccbd5ffb6cbdeaca046409861afecfe5e60c9e548eb66b528e132c5"

URI_aarch64_rust-serde_with+hashbrown_0_14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+hashbrown_0_14-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+hashbrown_0_14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+hashbrown_0_14-devel}"
SRC_URI[aarch64_rust-serde_with+hashbrown_0_14-devel.sha256sum] = "6cb5a2c80b362ad603103abb905f3ab30368a83c60369acba24b91b3edbc35cf"

URI_aarch64_rust-serde_with+hex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+hex-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+hex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+hex-devel}"
SRC_URI[aarch64_rust-serde_with+hex-devel.sha256sum] = "2cdf1deece5ec0ebeba120575c46641af160850ac001d2d90b85812803dddbb2"

URI_aarch64_rust-serde_with+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+indexmap-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+indexmap-devel}"
SRC_URI[aarch64_rust-serde_with+indexmap-devel.sha256sum] = "87dcb9104513c295b79cbddd91dbdb9c7637da59f929713dfdce2aa75bcc32c0"

URI_aarch64_rust-serde_with+indexmap_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+indexmap_1-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+indexmap_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+indexmap_1-devel}"
SRC_URI[aarch64_rust-serde_with+indexmap_1-devel.sha256sum] = "e2ce2eaecdb00ab0ff208941b57f2b676259d89672d5d7819ed6a810da3e300e"

URI_aarch64_rust-serde_with+indexmap_2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+indexmap_2-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+indexmap_2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+indexmap_2-devel}"
SRC_URI[aarch64_rust-serde_with+indexmap_2-devel.sha256sum] = "db8ae7215dfe57635f5cc41004be913c44c2308bfcf6b60032cc05556cba942d"

URI_aarch64_rust-serde_with+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+json-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+json-devel}"
SRC_URI[aarch64_rust-serde_with+json-devel.sha256sum] = "eafbebc5ce1ce4f0941330d6c394418902335ec3961d4206191436515e3158cf"

URI_aarch64_rust-serde_with+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+macros-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+macros-devel}"
SRC_URI[aarch64_rust-serde_with+macros-devel.sha256sum] = "245b86befc7ee1e73f4fb45bb5186179fcc0c7ab26ec4fda8acd40b156020948"

URI_aarch64_rust-serde_with+schemars_0_8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+schemars_0_8-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+schemars_0_8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+schemars_0_8-devel}"
SRC_URI[aarch64_rust-serde_with+schemars_0_8-devel.sha256sum] = "b8bb3dc8eecbbca293e518c8bcccbdef1ec7ca04faa379c3cb75ce0568d352ca"

URI_aarch64_rust-serde_with+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+std-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+std-devel}"
SRC_URI[aarch64_rust-serde_with+std-devel.sha256sum] = "10b8c0b04564e7a7467fc5d29e3a2c056963c0c8d7291cdf8739e3ff39f4bac0"

URI_aarch64_rust-serde_with+time_0_3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+time_0_3-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with+time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+time_0_3-devel}"
SRC_URI[aarch64_rust-serde_with+time_0_3-devel.sha256sum] = "42d54709a1f58949eefd3c82e41e757b7a0d01fbff7f6968fc62ddfb249aae5a"

URI_aarch64_rust-serde_with-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with-devel}"
SRC_URI[aarch64_rust-serde_with-devel.sha256sum] = "98ebf8820cb68dd0ef39754005d5cd92661ff1cfed4ff0935dc2888a433bc605"

RDEPENDS:rust-serde_with+alloc-devel = " \
 cargo \
 rust-base64+alloc-devel \
 rust-base64-devel \
 rust-chrono+alloc-devel \
 rust-chrono+serde-devel \
 rust-chrono-devel \
 rust-hex+alloc-devel \
 rust-hex-devel \
 rust-serde+alloc-devel \
 rust-serde_json+alloc-devel \
 rust-serde_json-devel \
 rust-serde_with-devel \
 rust-time+alloc-devel \
 rust-time-devel \
 "
RDEPENDS:rust-serde_with+base64-devel = " \
 cargo \
 rust-base64-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+chrono-devel = " \
 cargo \
 rust-serde_with+chrono_0_4-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+chrono_0_4-devel = " \
 cargo \
 rust-chrono+serde-devel \
 rust-chrono-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+default-devel = " \
 cargo \
 rust-serde_with+macros-devel \
 rust-serde_with+std-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+guide-devel = " \
 cargo \
 rust-doc-comment+default-devel \
 rust-document-features+default-devel \
 rust-serde_with+macros-devel \
 rust-serde_with+std-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+hashbrown_0_14-devel = " \
 cargo \
 rust-hashbrown0.14+serde-devel \
 rust-hashbrown0.14-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+hex-devel = " \
 cargo \
 rust-hex-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+indexmap-devel = " \
 cargo \
 rust-serde_with+indexmap_1-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+indexmap_1-devel = " \
 cargo \
 rust-indexmap1+serde-1-devel \
 rust-indexmap1-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+indexmap_2-devel = " \
 cargo \
 rust-indexmap+serde-devel \
 rust-indexmap-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+json-devel = " \
 cargo \
 rust-serde_json-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+macros-devel = " \
 cargo \
 rust-serde_with-devel \
 rust-serde_with_macros+default-devel \
 "
RDEPENDS:rust-serde_with+schemars_0_8-devel = " \
 cargo \
 rust-schemars-devel \
 rust-serde_with+std-devel \
 rust-serde_with-devel \
 rust-serde_with_macros+default-devel \
 rust-serde_with_macros+schemars_0_8-devel \
 "
RDEPENDS:rust-serde_with+std-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+serde-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-indexmap+serde-devel \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-indexmap1+serde-1-devel \
 rust-indexmap1+std-devel \
 rust-indexmap1-devel \
 rust-serde+std-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 rust-time+serde-well-known-devel \
 rust-time+std-devel \
 rust-time-devel \
 "
RDEPENDS:rust-serde_with+time_0_3-devel = " \
 cargo \
 rust-serde_with-devel \
 rust-time-devel \
 "
RDEPENDS:rust-serde_with-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 rust-serde_derive+default-devel \
 "
