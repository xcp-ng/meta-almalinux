# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgeotiff"
PV = "1.7.3"
PR = "3.el10_0"
PACKAGES = " \
 libgeotiff \
 libgeotiff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgeotiff-1.7.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1b5a381be31c40174d074de6ee070fa2c3c86d7b713204cf7f4ebd42b06afa7"

URI_x86_64_v2_libgeotiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgeotiff-1.7.3-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgeotiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgeotiff}"
SRC_URI[x86_64_v2_libgeotiff.sha256sum] = "4d3d2aed9a29e1148285ffa0f30ba11eb022d65b7f7d661bcf711f7e52bdfcc7"

URI_x86_64_v2_libgeotiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgeotiff-devel-1.7.3-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgeotiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgeotiff-devel}"
SRC_URI[x86_64_v2_libgeotiff-devel.sha256sum] = "17b1586918c0f81122dff247433d9913aa58384c3efe0dbe8fd5c5f6c4f5f5d8"

URI_aarch64_libgeotiff = "${EPEL_MIRROR}/aarch64/Packages/l/libgeotiff-1.7.3-3.el10_0.aarch64.rpm;name=aarch64_libgeotiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgeotiff}"
SRC_URI[aarch64_libgeotiff.sha256sum] = "b7d30cd39a882180bc0894a0abb8278233f1b7a2eb6038e912c2fc36fb71c685"

URI_aarch64_libgeotiff-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgeotiff-devel-1.7.3-3.el10_0.aarch64.rpm;name=aarch64_libgeotiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgeotiff-devel}"
SRC_URI[aarch64_libgeotiff-devel.sha256sum] = "31180a73292c6137383aedde6c8700ba8221803af321a8ec20e69aad3ae92bce"

RDEPENDS:libgeotiff = " \
 glibc \
 libtiff \
 proj \
 "
RDEPENDS:libgeotiff-devel = " \
 cmake-filesystem \
 libgeotiff \
 libtiff-devel \
 pkgconf-pkg-config \
 "
