# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemd"
PV = "257"
PR = "34.el10.alma.1"
PACKAGES = " \
 systemd \
 systemd-boot-unsigned \
 systemd-container \
 systemd-devel \
 systemd-journal-remote \
 systemd-libs \
 systemd-oomd \
 systemd-pam \
 systemd-resolved \
 systemd-rpm-macros \
 systemd-udev \
 systemd-ukify \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/systemd-257-34.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f39ce081522fd66c7270aa436f5e68c9af98a25de6c2f0689d40fab6c50a0196"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - systemd-container: libcap.so.2()(64bit)
# - systemd-libs: libcap.so.2()(64bit)
# - systemd-pam: libcap.so.2()(64bit)
# - systemd: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-257-34.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd;unpack=0"
SRC_URI[x86_64_v2_systemd.sha256sum] = "bfc0e137f1f26c0beb2190bf8ff96efbb3ac3117c90c6edb7d35a2e940708b0a"
RPROVIDES:systemd:append:x86_64_v2 = " virtual/group_dialout_ virtual/group_tty_ virtual/syslog"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-boot-unsigned-257-34.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-boot-unsigned;unpack=0"
SRC_URI[x86_64_v2_systemd-boot-unsigned.sha256sum] = "de4f9d845f68d39f3c15617616cf3ee0c2df068c0e591c1533c7339c209ee9ca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-container-257-34.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-container;unpack=0"
SRC_URI[x86_64_v2_systemd-container.sha256sum] = "f22de8f4e1803ad9090ed9b277e470a7558077e193a4dfbcf5a7be47b719ab3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-devel-257-34.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-devel;unpack=0"
SRC_URI[x86_64_v2_systemd-devel.sha256sum] = "9120cd189f67beff6d90747aa21dfa10466f53a8101f9c8a776c1b946a94760a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-journal-remote-257-34.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-journal-remote;unpack=0"
SRC_URI[x86_64_v2_systemd-journal-remote.sha256sum] = "41f1eccb60426cacf133cde6ce9f43e03a2815eb9fd9d7ed6061b34728488354"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-libs-257-34.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-libs;unpack=0"
SRC_URI[x86_64_v2_systemd-libs.sha256sum] = "65ac747a1bfa2f2e0285094a35fb1470711dd1f3190ec4e2305200eec2924841"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-oomd-257-34.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-oomd;unpack=0"
SRC_URI[x86_64_v2_systemd-oomd.sha256sum] = "42e0b096c839f6c33a32c51dd05accfec4f14c11a74c161e51837ac59a840120"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-pam-257-34.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-pam;unpack=0"
SRC_URI[x86_64_v2_systemd-pam.sha256sum] = "182c2c01ecffacb3e623cf698f143807f4d676f52649e6d78937ee4e676b6323"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-resolved-257-34.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-resolved;unpack=0"
SRC_URI[x86_64_v2_systemd-resolved.sha256sum] = "38fb64603c6adc36eec7c524e4b5e4d1552cb0fe619cc06d31e1bb80aadcb1da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-rpm-macros-257-34.el10.alma.1.noarch.rpm;name=x86_64_v2_systemd-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_systemd-rpm-macros.sha256sum] = "bc9f68648fd7e68ed48f83ca562ee4dd82b3f8c88ebbfb26e60a32361841bbe5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-udev-257-34.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-udev;unpack=0"
SRC_URI[x86_64_v2_systemd-udev.sha256sum] = "c2a0ca62b472f3df044357cea98c837756e6c4e3fc076af64b0e9076f2dfaef7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-ukify-257-34.el10.alma.1.noarch.rpm;name=x86_64_v2_systemd-ukify;unpack=0"
SRC_URI[x86_64_v2_systemd-ukify.sha256sum] = "6e741b3b3a009b9214640931853cd9de89cb18c9685086f4089ad1c1e9b9adbd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-257-34.el10.alma.1.aarch64.rpm;name=aarch64_systemd;unpack=0"
SRC_URI[aarch64_systemd.sha256sum] = "230a33e31e11c0c24dbab86b2132fc8d2e60925de5436a918efe3e9ab5753494"
RPROVIDES:systemd:append:aarch64 = " virtual/group_dialout_ virtual/group_tty_ virtual/syslog"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-boot-unsigned-257-34.el10.alma.1.aarch64.rpm;name=aarch64_systemd-boot-unsigned;unpack=0"
SRC_URI[aarch64_systemd-boot-unsigned.sha256sum] = "0b6fc3aedd0f74d302e5e22039c4ddc1e192c7ee5cc81876a932cf132a894f88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-container-257-34.el10.alma.1.aarch64.rpm;name=aarch64_systemd-container;unpack=0"
SRC_URI[aarch64_systemd-container.sha256sum] = "716475a0bf4021a330f4127281f1e50f4c0edb51d7965fed6b4d07a7277ac704"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-devel-257-34.el10.alma.1.aarch64.rpm;name=aarch64_systemd-devel;unpack=0"
SRC_URI[aarch64_systemd-devel.sha256sum] = "be94d4aa0c55d070c6b8332138079798f661a1269c1e96ad26f44c618de77d55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-journal-remote-257-34.el10.alma.1.aarch64.rpm;name=aarch64_systemd-journal-remote;unpack=0"
SRC_URI[aarch64_systemd-journal-remote.sha256sum] = "d7c903582e6344fb6c56f8bafcd9734d615283aea2284e5795449caf66749d23"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-libs-257-34.el10.alma.1.aarch64.rpm;name=aarch64_systemd-libs;unpack=0"
SRC_URI[aarch64_systemd-libs.sha256sum] = "1489271ea350c0702516135a27a45886e6e7761a278b6070cb1fc8cecb467c22"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-oomd-257-34.el10.alma.1.aarch64.rpm;name=aarch64_systemd-oomd;unpack=0"
SRC_URI[aarch64_systemd-oomd.sha256sum] = "4720ba034d0d7bb597ef2da525cfd38a4367cc4981ef982ea29ca1a1409b4127"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-pam-257-34.el10.alma.1.aarch64.rpm;name=aarch64_systemd-pam;unpack=0"
SRC_URI[aarch64_systemd-pam.sha256sum] = "255589ad331bef78d9ed98b79b1e5d3ca5515a06350e478e71b2b24b4539d562"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-resolved-257-34.el10.alma.1.aarch64.rpm;name=aarch64_systemd-resolved;unpack=0"
SRC_URI[aarch64_systemd-resolved.sha256sum] = "95d1837cbd3ab1f38d02ed24a7cb73215adbb8b58c78d8c661f1d529c16f6ce7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-rpm-macros-257-34.el10.alma.1.noarch.rpm;name=aarch64_systemd-rpm-macros;unpack=0"
SRC_URI[aarch64_systemd-rpm-macros.sha256sum] = "bc9f68648fd7e68ed48f83ca562ee4dd82b3f8c88ebbfb26e60a32361841bbe5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-udev-257-34.el10.alma.1.aarch64.rpm;name=aarch64_systemd-udev;unpack=0"
SRC_URI[aarch64_systemd-udev.sha256sum] = "2203f0008ec74741bcca49fbeb6cb215a20cde5b02552e84a57594325412b165"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-ukify-257-34.el10.alma.1.noarch.rpm;name=aarch64_systemd-ukify;unpack=0"
SRC_URI[aarch64_systemd-ukify.sha256sum] = "6e741b3b3a009b9214640931853cd9de89cb18c9685086f4089ad1c1e9b9adbd"

RDEPENDS:systemd:x86_64_v2 = " \
 audit-libs \
 bash \
 bzip2-libs \
 dbus \
 glibc \
 grep \
 libacl \
 libblkid \
 libcap \
 libfdisk \
 libgcc \
 libmount \
 libseccomp \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 systemd-libs \
 systemd-pam \
 systemd-rpm-macros \
 virtual/coreutils \
 virtual/util-linux-core_or_util-linux \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd:aarch64 = " \
 audit-libs \
 bash \
 bzip2-libs \
 dbus \
 glibc \
 grep \
 libacl \
 libblkid \
 libfdisk \
 libgcc \
 libmount \
 libseccomp \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 systemd-libs \
 systemd-pam \
 systemd-rpm-macros \
 virtual/coreutils \
 virtual/util-linux-core_or_util-linux \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd-boot-unsigned = " \
 "
RDEPENDS:systemd-container:x86_64_v2 = " \
 bzip2-libs \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd-container:aarch64 = " \
 bzip2-libs \
 glibc \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd-devel = " \
 systemd-libs \
 systemd-rpm-macros \
 "
RDEPENDS:systemd-journal-remote = " \
 bash \
 firewalld-filesystem \
 glibc \
 libgcc \
 libmicrohttpd \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:systemd-libs:x86_64_v2 = " \
 glibc \
 libcap \
 libgcc \
"
RDEPENDS:systemd-libs:aarch64 = " \
 glibc \
 libgcc \
"
RDEPENDS:systemd-oomd = " \
 bash \
 glibc \
 libgcc \
 systemd \
 systemd-udev \
 "
RDEPENDS:systemd-pam:x86_64_v2 = " \
 glibc \
 libcap \
 libgcc \
 pam-libs \
 systemd \
"
RDEPENDS:systemd-pam:aarch64 = " \
 glibc \
 libgcc \
 pam-libs \
 systemd \
"
RDEPENDS:systemd-resolved = " \
 bash \
 glibc \
 grep \
 libgcc \
 libidn2 \
 openssl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:systemd-rpm-macros = " \
 bash \
 "
RDEPENDS:systemd-udev = " \
 bash \
 cryptsetup-libs \
 glibc \
 grep \
 grubby \
 kbd \
 kmod \
 kmod-libs \
 libblkid \
 libfdisk \
 libgcc \
 openssl-libs \
 sdubby \
 systemd \
 "
RDEPENDS:systemd-ukify = " \
 python3 \
 python3-cryptography \
 python3-pefile \
 python3-zstandard \
 systemd \
 systemd-boot-unsigned \
 "
