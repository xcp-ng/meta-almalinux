# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "imhex"
PV = "1.37.4"
PR = "3.el10_2"
PACKAGES = " \
 imhex \
 imhex-devel \
 imhex-patterns \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/imhex-1.37.4-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "384d00ecbf90034c0afee7e0b9bfe703d5743d137169911c79e621906623e53a"

URI_x86_64_v2_imhex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/imhex-1.37.4-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_imhex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_imhex}"
SRC_URI[x86_64_v2_imhex.sha256sum] = "b8e55446b204d1aa24a7857b7b0b25eff9a211e1fb95b377fede4cd728881ac1"

URI_x86_64_v2_imhex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/imhex-devel-1.37.4-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_imhex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_imhex-devel}"
SRC_URI[x86_64_v2_imhex-devel.sha256sum] = "8ca95b9ebb862469e53af78e4639ea79ed0293146a2cf4d7fa3079eea72dc91e"

URI_x86_64_v2_imhex-patterns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/imhex-patterns-1.37.4-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_imhex-patterns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_imhex-patterns}"
SRC_URI[x86_64_v2_imhex-patterns.sha256sum] = "7086c3230ef02bdcaea93155092567507f42f75ae55f011d9cc451b58a4457ac"

URI_aarch64_imhex = "${EPEL_MIRROR}/aarch64/Packages/i/imhex-1.37.4-3.el10_2.aarch64.rpm;name=aarch64_imhex;unpack=0"
SRC_URI:append = " ${URI_aarch64_imhex}"
SRC_URI[aarch64_imhex.sha256sum] = "23725475394983517ed8d63876ae6c5b806b4d55c8463d1f743da777ebc459ab"

URI_aarch64_imhex-devel = "${EPEL_MIRROR}/aarch64/Packages/i/imhex-devel-1.37.4-3.el10_2.aarch64.rpm;name=aarch64_imhex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_imhex-devel}"
SRC_URI[aarch64_imhex-devel.sha256sum] = "4d8cf4acd07b2217701e8c4a73485a8ca7822031adfb88c8c0a8eb139a3f9b13"

URI_aarch64_imhex-patterns = "${EPEL_MIRROR}/aarch64/Packages/i/imhex-patterns-1.37.4-3.el10_2.aarch64.rpm;name=aarch64_imhex-patterns;unpack=0"
SRC_URI:append = " ${URI_aarch64_imhex-patterns}"
SRC_URI[aarch64_imhex-patterns.sha256sum] = "280967acc79bdc988f758c77f28a17f2813cc4f384914c068c9ec96af8b05fa4"

RDEPENDS:imhex = " \
 bzip2-libs \
 capstone \
 file-libs \
 fmt \
 fontconfig \
 freetype \
 glfw \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lunasvg \
 lz4-libs \
 mbedtls \
 nativefiledialog-extended \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 yara \
 zlib-ng-compat \
 "
RDEPENDS:imhex-devel = " \
 imhex \
 "
RDEPENDS:imhex-patterns = " \
 imhex \
 "
