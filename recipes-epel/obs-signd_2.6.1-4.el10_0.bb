# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "obs-signd"
PV = "2.6.1"
PR = "4.el10_0"
PACKAGES = " \
 obs-signd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/obs-signd-2.6.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9f3a0ad7a450f34b2a68623521ee69336f346512de113cc37aa745588001c1a"

URI_x86_64_v2_obs-signd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/obs-signd-2.6.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_obs-signd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_obs-signd}"
SRC_URI[x86_64_v2_obs-signd.sha256sum] = "4589650626172fc73065cdcaaf74bdfe025669b34d03aef2a12dd09ca52310d9"

URI_aarch64_obs-signd = "${EPEL_MIRROR}/aarch64/Packages/o/obs-signd-2.6.1-4.el10_0.aarch64.rpm;name=aarch64_obs-signd;unpack=0"
SRC_URI:append = " ${URI_aarch64_obs-signd}"
SRC_URI[aarch64_obs-signd.sha256sum] = "38dd0f0ebdb252b1fa7d664c27f88ef548fec9ec35407e117e725cff35fc7625"

RDEPENDS:obs-signd = " \
 bash \
 glibc \
 gnupg2 \
 perl-Digest-SHA \
 perl-Encode \
 perl-File-Path \
 perl-File-Temp \
 perl-MIME-Base64 \
 perl-Math-BigInt \
 perl-POSIX \
 perl-Socket \
 perl-interpreter \
 perl-libs \
 shadow-utils \
 "
