# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytemuck_derive"
PV = "1.10.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-bytemuck_derive+default-devel \
 rust-bytemuck_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytemuck_derive-1.10.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2452fbf3cc853b9f2e37dbe46a1c6ed3103b80e8f0a84690d690f6358fd0a669"

URI_x86_64_v2_rust-bytemuck_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck_derive+default-devel-1.10.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck_derive+default-devel}"
SRC_URI[x86_64_v2_rust-bytemuck_derive+default-devel.sha256sum] = "ddd394aabf0ebae425c411a800c1b7ff366b727d53e00d014d4eb85cd037733d"

URI_x86_64_v2_rust-bytemuck_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck_derive-devel-1.10.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck_derive-devel}"
SRC_URI[x86_64_v2_rust-bytemuck_derive-devel.sha256sum] = "44ddf20e3e211359f7f6335ec80ac5b102e0e1834c9c23c9f74723549cc27316"

URI_aarch64_rust-bytemuck_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck_derive+default-devel-1.10.2-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck_derive+default-devel}"
SRC_URI[aarch64_rust-bytemuck_derive+default-devel.sha256sum] = "eb8ff7af59d68f20bcf9b1c98f38e84525a4aac4330a4b7346accf74ce8b67e9"

URI_aarch64_rust-bytemuck_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck_derive-devel-1.10.2-1.el10_0.noarch.rpm;name=aarch64_rust-bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck_derive-devel}"
SRC_URI[aarch64_rust-bytemuck_derive-devel.sha256sum] = "358ad1a16fdd2362a8b19179baa4047ceadb594766441085921b0116ea0aebda"

RDEPENDS:rust-bytemuck_derive+default-devel = " \
 cargo \
 rust-bytemuck_derive-devel \
 "
RDEPENDS:rust-bytemuck_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
