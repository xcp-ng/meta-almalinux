# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "haveged"
PV = "1.9.26"
PR = "1.el10_2"
PACKAGES = " \
 haveged \
 haveged-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/haveged-1.9.26-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bb9b6b4cde26f9e185e266aebba0f34f7f9c8f727b986ff5e23f57a0a5845c2"

URI_x86_64_v2_haveged = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/haveged-1.9.26-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_haveged;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_haveged}"
SRC_URI[x86_64_v2_haveged.sha256sum] = "4b037cd5a240fc0549338172931be4b0900d331d7d43510f5ea091a28484b922"

URI_x86_64_v2_haveged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/haveged-devel-1.9.26-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_haveged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_haveged-devel}"
SRC_URI[x86_64_v2_haveged-devel.sha256sum] = "f50e29461fd858be227e5ef489112ba8ffc492ca807a617fa475c4b42803a9ea"

URI_aarch64_haveged = "${EPEL_MIRROR}/aarch64/Packages/h/haveged-1.9.26-1.el10_2.aarch64.rpm;name=aarch64_haveged;unpack=0"
SRC_URI:append = " ${URI_aarch64_haveged}"
SRC_URI[aarch64_haveged.sha256sum] = "b4f4249d80b75bc221c15d43c9eeb9bb3bdfebe45f1faa24daebef9036cf53f1"

URI_aarch64_haveged-devel = "${EPEL_MIRROR}/aarch64/Packages/h/haveged-devel-1.9.26-1.el10_2.aarch64.rpm;name=aarch64_haveged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_haveged-devel}"
SRC_URI[aarch64_haveged-devel.sha256sum] = "9fb57a912ed3507c425800286ec9fcb0041bccaf08249b1d94e3d3d00bb63924"

RDEPENDS:haveged = " \
 bash \
 glibc \
 systemd \
 "
RDEPENDS:haveged-devel = " \
 haveged \
 "
