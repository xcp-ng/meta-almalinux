# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-settings-daemon"
PV = "47.2"
PR = "10.el10.alma.6"
PACKAGES = " \
 gnome-settings-daemon \
 gnome-settings-daemon-devel \
 gnome-settings-daemon-server-defaults \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-settings-daemon-47.2-10.el10.alma.6.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c78023cff90f8c6bb3fc8e3b26013818fcdf927314067d2e2d8fb9b2c0318cec"

URI_x86_64_v2_gnome-settings-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-settings-daemon-47.2-10.el10.alma.6.x86_64_v2.rpm;name=x86_64_v2_gnome-settings-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-settings-daemon}"
SRC_URI[x86_64_v2_gnome-settings-daemon.sha256sum] = "8f58437b43691ba8c12913daae27d5786daae52e8f8f7621347eb6c206918898"

URI_x86_64_v2_gnome-settings-daemon-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-settings-daemon-devel-47.2-10.el10.alma.6.x86_64_v2.rpm;name=x86_64_v2_gnome-settings-daemon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-settings-daemon-devel}"
SRC_URI[x86_64_v2_gnome-settings-daemon-devel.sha256sum] = "ef68be30bce836fa404fec68c7b5db2c8e276029392b8856c5db8482e253fa03"

URI_x86_64_v2_gnome-settings-daemon-server-defaults = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-settings-daemon-server-defaults-47.2-10.el10.alma.6.x86_64_v2.rpm;name=x86_64_v2_gnome-settings-daemon-server-defaults;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-settings-daemon-server-defaults}"
SRC_URI[x86_64_v2_gnome-settings-daemon-server-defaults.sha256sum] = "b8e2f4d0c7b9c441ab2ba16980c00ab6fb4b9c573af3734b0641e285a0d5f041"

URI_aarch64_gnome-settings-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-settings-daemon-47.2-10.el10.alma.6.aarch64.rpm;name=aarch64_gnome-settings-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-settings-daemon}"
SRC_URI[aarch64_gnome-settings-daemon.sha256sum] = "48ee579c4ebbc619e817cbde37e8a3821a2f4528bf7eb01346210604780275bb"

URI_aarch64_gnome-settings-daemon-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-settings-daemon-devel-47.2-10.el10.alma.6.aarch64.rpm;name=aarch64_gnome-settings-daemon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-settings-daemon-devel}"
SRC_URI[aarch64_gnome-settings-daemon-devel.sha256sum] = "9fd75ecaade8be25138b7e5257cc449fc79433522aa6e9de725365733338e013"

URI_aarch64_gnome-settings-daemon-server-defaults = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-settings-daemon-server-defaults-47.2-10.el10.alma.6.aarch64.rpm;name=aarch64_gnome-settings-daemon-server-defaults;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-settings-daemon-server-defaults}"
SRC_URI[aarch64_gnome-settings-daemon-server-defaults.sha256sum] = "df21ed24c0f3f84994f2280d71ca312ea670c5b416365c0a04f1fdc9f0d1fa79"

RDEPENDS:gnome-settings-daemon = " \
 ModemManager-glib \
 NetworkManager-libnm \
 alsa-lib \
 bash \
 cairo \
 colord \
 colord-libs \
 cups-libs \
 fontconfig \
 gcr-libs \
 geoclue2 \
 geoclue2-libs \
 geocode-glib \
 glib2 \
 glibc \
 gnome-desktop3 \
 gsettings-desktop-schemas \
 gtk3 \
 iio-sensor-proxy \
 libX11 \
 libXext \
 libXfixes \
 libXi \
 libcanberra \
 libcanberra-gtk3 \
 libgcc \
 libgudev \
 libgweather \
 libnotify \
 libwacom \
 libwayland-client \
 p11-kit \
 pango \
 polkit-libs \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 systemd-libs \
 upower-libs \
 "
RDEPENDS:gnome-settings-daemon-devel = " \
 gnome-settings-daemon \
 pkgconf-pkg-config \
 "
RDEPENDS:gnome-settings-daemon-server-defaults = " \
 gnome-settings-daemon \
 "
