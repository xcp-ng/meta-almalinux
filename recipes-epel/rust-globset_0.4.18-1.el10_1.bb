# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-globset"
PV = "0.4.18"
PR = "1.el10_1"
PACKAGES = " \
 rust-globset+arbitrary-devel \
 rust-globset+default-devel \
 rust-globset+log-devel \
 rust-globset+serde-devel \
 rust-globset+serde1-devel \
 rust-globset+simd-accel-devel \
 rust-globset-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-globset-0.4.18-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a0aeddba16964156757771913c3bf426e9eb47676b96e6f2d258597d06b507b"

URI_x86_64_v2_rust-globset+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+arbitrary-devel-0.4.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-globset+arbitrary-devel.sha256sum] = "96b34fae3a458c516ace2b843494d0c41311a0173377ce2d19a8c7301332ca41"

URI_x86_64_v2_rust-globset+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+default-devel-0.4.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+default-devel}"
SRC_URI[x86_64_v2_rust-globset+default-devel.sha256sum] = "ee372e91102904c8d14a0149f79ac613c351167fc2eb6e655062f83672ef81de"

URI_x86_64_v2_rust-globset+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+log-devel-0.4.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+log-devel}"
SRC_URI[x86_64_v2_rust-globset+log-devel.sha256sum] = "d5d554c4996cd90818f2750c98130d544b1232ec45195bcb083056b0f0171f1f"

URI_x86_64_v2_rust-globset+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+serde-devel-0.4.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+serde-devel}"
SRC_URI[x86_64_v2_rust-globset+serde-devel.sha256sum] = "8ec4c2881123773ab2e61104ca98610e8f75118e3e4f601015b0fa1b91e3f34a"

URI_x86_64_v2_rust-globset+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+serde1-devel-0.4.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+serde1-devel}"
SRC_URI[x86_64_v2_rust-globset+serde1-devel.sha256sum] = "585c56c444029123f64344a7a6d9c1059ee72004ff78772f73b6fa5c44dad283"

URI_x86_64_v2_rust-globset+simd-accel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+simd-accel-devel-0.4.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+simd-accel-devel}"
SRC_URI[x86_64_v2_rust-globset+simd-accel-devel.sha256sum] = "ab419b2cadb11ec19a69c7c4dcb8393222d5c344798e58c28601fe6348511043"

URI_x86_64_v2_rust-globset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset-devel-0.4.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset-devel}"
SRC_URI[x86_64_v2_rust-globset-devel.sha256sum] = "109db33740dbed10ae25938d4700ea328f3b418ecc962ebae211876c96a1715c"

URI_aarch64_rust-globset+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+arbitrary-devel-0.4.18-1.el10_1.noarch.rpm;name=aarch64_rust-globset+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+arbitrary-devel}"
SRC_URI[aarch64_rust-globset+arbitrary-devel.sha256sum] = "613c1b2cb32419e3439afaecef304e040501455bd2a508fc5363f3b4ff67f590"

URI_aarch64_rust-globset+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+default-devel-0.4.18-1.el10_1.noarch.rpm;name=aarch64_rust-globset+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+default-devel}"
SRC_URI[aarch64_rust-globset+default-devel.sha256sum] = "dc585cb45e1c34dda5318018b3d23d51ccbdc5470a0e406896a334d32affb8c5"

URI_aarch64_rust-globset+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+log-devel-0.4.18-1.el10_1.noarch.rpm;name=aarch64_rust-globset+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+log-devel}"
SRC_URI[aarch64_rust-globset+log-devel.sha256sum] = "1b0c8cbb4a8e3ab2c8d11984ac37803d2aa537d5c8a93d10a97824b17c32b95e"

URI_aarch64_rust-globset+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+serde-devel-0.4.18-1.el10_1.noarch.rpm;name=aarch64_rust-globset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+serde-devel}"
SRC_URI[aarch64_rust-globset+serde-devel.sha256sum] = "4a38a758f8627ec24801228d607ebfdf3926f042bdd6a49b1a1c00e1efc782ab"

URI_aarch64_rust-globset+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+serde1-devel-0.4.18-1.el10_1.noarch.rpm;name=aarch64_rust-globset+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+serde1-devel}"
SRC_URI[aarch64_rust-globset+serde1-devel.sha256sum] = "e65edf58b67fca056b5958cec17d1cf504a9750abf9930263ecadcb13fa7d371"

URI_aarch64_rust-globset+simd-accel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+simd-accel-devel-0.4.18-1.el10_1.noarch.rpm;name=aarch64_rust-globset+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+simd-accel-devel}"
SRC_URI[aarch64_rust-globset+simd-accel-devel.sha256sum] = "11780574129477ec06965edf42f4e675cdf1efb9ac50b4ed2235cb994afdbf26"

URI_aarch64_rust-globset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset-devel-0.4.18-1.el10_1.noarch.rpm;name=aarch64_rust-globset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset-devel}"
SRC_URI[aarch64_rust-globset-devel.sha256sum] = "27e1803e1ac17567f6e26a023ac3d12ce9eb74dc28520000edd1cbdc9612617d"

RDEPENDS:rust-globset+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-globset-devel \
 "
RDEPENDS:rust-globset+default-devel = " \
 cargo \
 rust-globset+log-devel \
 rust-globset-devel \
 "
RDEPENDS:rust-globset+log-devel = " \
 cargo \
 rust-globset-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-globset+serde-devel = " \
 cargo \
 rust-globset-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-globset+serde1-devel = " \
 cargo \
 rust-globset+serde-devel \
 rust-globset-devel \
 "
RDEPENDS:rust-globset+simd-accel-devel = " \
 cargo \
 rust-globset-devel \
 "
RDEPENDS:rust-globset-devel = " \
 cargo \
 rust-aho-corasick+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 rust-regex-syntax+std-devel \
 rust-regex-syntax-devel \
 "
