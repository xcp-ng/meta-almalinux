# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yoke"
PV = "0.8.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-yoke+alloc-devel \
 rust-yoke+default-devel \
 rust-yoke+derive-devel \
 rust-yoke+serde-devel \
 rust-yoke+zerofrom-devel \
 rust-yoke-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-yoke-0.8.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d6949f95f5908266171ad7e4dcc33ece75866e52c8c9f871f0bc56fa43ca3f9"

URI_x86_64_v2_rust-yoke+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+alloc-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+alloc-devel}"
SRC_URI[x86_64_v2_rust-yoke+alloc-devel.sha256sum] = "9f527ae67411485ed94b3141f4c6981da2835c0a19c003d8342bbc1b9c91ebfc"

URI_x86_64_v2_rust-yoke+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+default-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+default-devel}"
SRC_URI[x86_64_v2_rust-yoke+default-devel.sha256sum] = "d26050348f1eccc82f17437b8d6e77434f61f6d94d759566a2237c92feb72974"

URI_x86_64_v2_rust-yoke+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+derive-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+derive-devel}"
SRC_URI[x86_64_v2_rust-yoke+derive-devel.sha256sum] = "995b4fa614ca53eccbb9624c9b6bff6b57d26bfc7dd1c4e66b7ba36d61467571"

URI_x86_64_v2_rust-yoke+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+serde-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+serde-devel}"
SRC_URI[x86_64_v2_rust-yoke+serde-devel.sha256sum] = "bdceac9d45072f7fa2b08f83996a1e28dd1de9b0c9f2df2ffc22c38161575ca1"

URI_x86_64_v2_rust-yoke+zerofrom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+zerofrom-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+zerofrom-devel}"
SRC_URI[x86_64_v2_rust-yoke+zerofrom-devel.sha256sum] = "9b5cb621051e151c3cc5be91235a17f826ca69c21ea9ad8a4474a6ad9c89671e"

URI_x86_64_v2_rust-yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke-devel}"
SRC_URI[x86_64_v2_rust-yoke-devel.sha256sum] = "f1a8e470e259b61ef40327e7d4859aa0c3d7547154ef5c5d1c94e53f85952c6f"

URI_aarch64_rust-yoke+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+alloc-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-yoke+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+alloc-devel}"
SRC_URI[aarch64_rust-yoke+alloc-devel.sha256sum] = "c5fc20dee13e1ec9778a5e8c43cd22f950a26c11cf9fcb3edfd2f1eab1d784a9"

URI_aarch64_rust-yoke+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+default-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-yoke+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+default-devel}"
SRC_URI[aarch64_rust-yoke+default-devel.sha256sum] = "e0fd61034bfff9f09a3b194fdf0e24cbc2c4d99221a1c997c8e4aa20d5b35a7f"

URI_aarch64_rust-yoke+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+derive-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-yoke+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+derive-devel}"
SRC_URI[aarch64_rust-yoke+derive-devel.sha256sum] = "cda81393ae4bb37f5dcbf1b133a4296d8ab5ba5cf6d8a4c0a31b2b4b7f6a7713"

URI_aarch64_rust-yoke+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+serde-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-yoke+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+serde-devel}"
SRC_URI[aarch64_rust-yoke+serde-devel.sha256sum] = "88af7976fd0ee56330932cc2a53a5776ef4a17baf3dd51ddc2b07b8019dac1b5"

URI_aarch64_rust-yoke+zerofrom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+zerofrom-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-yoke+zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+zerofrom-devel}"
SRC_URI[aarch64_rust-yoke+zerofrom-devel.sha256sum] = "212aec5dfb67d0cc3a006d2d2e712ed1db7acae38c0762847af956e0ef4c7fa2"

URI_aarch64_rust-yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke-devel}"
SRC_URI[aarch64_rust-yoke-devel.sha256sum] = "c96ea5c8235e5d4da8ae711b965ab44c79cac5fd8a269304a0f20194c6b154e3"

RDEPENDS:rust-yoke+alloc-devel = " \
 cargo \
 rust-stable_deref_trait+alloc-devel \
 rust-yoke-devel \
 rust-zerofrom+alloc-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-yoke+default-devel = " \
 cargo \
 rust-yoke+alloc-devel \
 rust-yoke+zerofrom-devel \
 rust-yoke-devel \
 "
RDEPENDS:rust-yoke+derive-devel = " \
 cargo \
 rust-yoke-derive-devel \
 rust-yoke-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-yoke+serde-devel = " \
 cargo \
 rust-yoke-devel \
 "
RDEPENDS:rust-yoke+zerofrom-devel = " \
 cargo \
 rust-yoke-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-yoke-devel = " \
 cargo \
 rust \
 rust-stable_deref_trait-devel \
 "
