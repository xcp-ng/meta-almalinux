# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluedevil"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 bluedevil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bluedevil-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb25ca6addfbe4126b22e606e813e505b85eb2bf035e07f38ecce7f2d2a8bcd6"

URI_x86_64_v2_bluedevil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluedevil-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluedevil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluedevil}"
SRC_URI[x86_64_v2_bluedevil.sha256sum] = "84472ff6d7d7ac50a993a8c4815def100fedca928e4c57705df2f7cb8158e3c8"

URI_aarch64_bluedevil = "${EPEL_MIRROR}/aarch64/Packages/b/bluedevil-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_bluedevil;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluedevil}"
SRC_URI[aarch64_bluedevil.sha256sum] = "e0c978e94a9e80ee40fe37781633030e5c17ee47806bc9fd6cbee47c9d28dcc0"

RDEPENDS:bluedevil = " \
 bluez \
 bluez-obexd \
 glibc \
 kf6-bluez-qt \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kded \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libplasma \
 libstdc++ \
 pipewire-pulseaudio \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
