# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "PEGTL"
PV = "2.8.3"
PR = "11.el10_1"
PACKAGES = " \
 PEGTL-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/PEGTL-2.8.3-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9c7f38e29ea0002917287feadf43434583761f68cb1f2644e99e8006182e586d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/PEGTL-devel-2.8.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_PEGTL-devel;unpack=0"
SRC_URI[x86_64_v2_PEGTL-devel.sha256sum] = "f5f2612148ded604f5c846d7daa5d036d31c83c70ee4e663c5392941a52da9b7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/PEGTL-devel-2.8.3-11.el10_1.aarch64.rpm;name=aarch64_PEGTL-devel;unpack=0"
SRC_URI[aarch64_PEGTL-devel.sha256sum] = "7d4310792c55642e94103f3ff3c64231023dfccc54fb84ec0eb9ba6ce241231b"

RDEPENDS:PEGTL-devel = " \
 cmake-filesystem \
 libstdc++-devel \
 "
