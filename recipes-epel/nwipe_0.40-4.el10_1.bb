# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nwipe"
PV = "0.40"
PR = "4.el10_1"
PACKAGES = " \
 nwipe \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nwipe-0.40-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22c541241f6f0eab6d31bd4827cb6fd2bc51fc4eefdfd31d27e790fbfe13f821"

URI_x86_64_v2_nwipe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nwipe-0.40-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nwipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nwipe}"
SRC_URI[x86_64_v2_nwipe.sha256sum] = "92d1f178dd9cfed01c7786145adc83fa87e973dbf2aabaf56f8c46ea071fa311"

URI_aarch64_nwipe = "${EPEL_MIRROR}/aarch64/Packages/n/nwipe-0.40-4.el10_1.aarch64.rpm;name=aarch64_nwipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_nwipe}"
SRC_URI[aarch64_nwipe.sha256sum] = "81c0298ec1e0b7fc3d18f92a6911c30c5171383aaf6e0ac5bbb91dab6a6094ff"

RDEPENDS:nwipe = " \
 dmidecode \
 glibc \
 hdparm \
 kmod \
 libconfig \
 ncurses-libs \
 parted \
 smartmontools \
 virtual//usr/bin/readlink \
 "
