# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dulwich"
PV = "0.22.7"
PR = "2.el10_1"
PACKAGES = " \
 python-dulwich-doc \
 python3-dulwich \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-dulwich-0.22.7-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fee3f5ecf261f74aba4b677da75aeb48915b5b4608518ca6408af686a3c9aa4f"

URI_x86_64_v2_python-dulwich-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-dulwich-doc-0.22.7-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-dulwich-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-dulwich-doc}"
SRC_URI[x86_64_v2_python-dulwich-doc.sha256sum] = "605417db3bdedaa68ddc63cee5f39129d0efcf0b891c59f1d9282dd5537dfc18"

URI_x86_64_v2_python3-dulwich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dulwich-0.22.7-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-dulwich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dulwich}"
SRC_URI[x86_64_v2_python3-dulwich.sha256sum] = "2b0ccd82bb665a441a36889257b4a4328e986c130e831567a31d6cffbc310364"

URI_aarch64_python-dulwich-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-dulwich-doc-0.22.7-2.el10_1.aarch64.rpm;name=aarch64_python-dulwich-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-dulwich-doc}"
SRC_URI[aarch64_python-dulwich-doc.sha256sum] = "9274b0f2a83b2091647fc564b393cec2d8ffd5dd3cd312f4e696182525773133"

URI_aarch64_python3-dulwich = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dulwich-0.22.7-2.el10_1.aarch64.rpm;name=aarch64_python3-dulwich;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dulwich}"
SRC_URI[aarch64_python3-dulwich.sha256sum] = "f3120f123f5767deb08da31bb9f157b52b5f35d52ee57e0e56e9a5e6ae624389"

RDEPENDS:python-dulwich-doc = " \
 "
RDEPENDS:python3-dulwich:x86_64_v2 = " \
 glibc \
 libgcc \
 python3 \
 python3-urllib3 \
"
RDEPENDS:python3-dulwich:aarch64 = " \
 python3 \
 python3-urllib3 \
"
