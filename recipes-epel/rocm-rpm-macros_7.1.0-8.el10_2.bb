# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-rpm-macros"
PV = "7.1.0"
PR = "8.el10_2"
PACKAGES:x86_64_v2 = " \
 rocm-rpm-macros \
 rocm-rpm-macros-modules \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rocm-rpm-macros-7.1.0-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "81a804a64894f8aba83987d484ca11750af3f4257c32a5bd854470d001127c45"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-rpm-macros-7.1.0-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rocm-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_rocm-rpm-macros.sha256sum] = "c882624bacbee60cca3a7d67bcec12724a90177633dab47759e822e6705b08ae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-rpm-macros-modules-7.1.0-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rocm-rpm-macros-modules;unpack=0"
SRC_URI[x86_64_v2_rocm-rpm-macros-modules.sha256sum] = "8e088425a344924721c032c797647e94ac277bb775a6417bc7f753ab6c1bc1d2"

RDEPENDS:rocm-rpm-macros = " \
 environment-modules \
 rpm \
 "
RDEPENDS:rocm-rpm-macros-modules = " \
 cmake-filesystem \
 rocm-llvm-filesystem \
 virtual/environment_modules_ \
 "
