# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-azure-mgmt-core"
PE = "1"
PV = "1.5.0"
PR = "3.el10_2"
PACKAGES = " \
 python3-azure-mgmt-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-azure-mgmt-core-1.5.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f22babda29f4aff4cea8f1cb3900e479b22c296176b89a6cb65de4fe6faccc14"

URI_x86_64_v2_python3-azure-mgmt-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-azure-mgmt-core-1.5.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-azure-mgmt-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-azure-mgmt-core}"
SRC_URI[x86_64_v2_python3-azure-mgmt-core.sha256sum] = "3ee1911059f92a341a114d500dee28b6fb10d1b72bafc70d83c7ddc7018927bc"

URI_aarch64_python3-azure-mgmt-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-azure-mgmt-core-1.5.0-3.el10_2.noarch.rpm;name=aarch64_python3-azure-mgmt-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-azure-mgmt-core}"
SRC_URI[aarch64_python3-azure-mgmt-core.sha256sum] = "ccbb2763dc8301b04a1c26c30988f96a5d14b2a51adf299bfd5c08313c59cbda"

RDEPENDS:python3-azure-mgmt-core = " \
 python3 \
 python3-azure-core \
 "
