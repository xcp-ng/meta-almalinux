# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-signal"
PV = "0.2.13"
PR = "1.el10_2"
PACKAGES = " \
 rust-async-signal+default-devel \
 rust-async-signal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-signal-0.2.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ef2da0ee2d69502ea33685317434cb7c0e0f5f4555a8d7b55f417766063fd71"

URI_x86_64_v2_rust-async-signal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-signal+default-devel-0.2.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-signal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-signal+default-devel}"
SRC_URI[x86_64_v2_rust-async-signal+default-devel.sha256sum] = "2de26883f70382a6cc36ab97c245feac7cf6c0002a7841ecabc049f7b1818a66"

URI_x86_64_v2_rust-async-signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-signal-devel-0.2.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-signal-devel}"
SRC_URI[x86_64_v2_rust-async-signal-devel.sha256sum] = "3bd519913486d1773747da8e229e9872a2cde3e3fb07d9b737d13ef29c663f2e"

URI_aarch64_rust-async-signal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-signal+default-devel-0.2.13-1.el10_2.noarch.rpm;name=aarch64_rust-async-signal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-signal+default-devel}"
SRC_URI[aarch64_rust-async-signal+default-devel.sha256sum] = "466b0991dc948cf60dffdf5af73d38c1def1ddeb313fc6a28ceda3a12c9b9aca"

URI_aarch64_rust-async-signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-signal-devel-0.2.13-1.el10_2.noarch.rpm;name=aarch64_rust-async-signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-signal-devel}"
SRC_URI[aarch64_rust-async-signal-devel.sha256sum] = "7cad21e9c81012b8b87215e6829ed97ee5bf942c0c280c3ea84482398482401a"

RDEPENDS:rust-async-signal+default-devel = " \
 cargo \
 rust-async-signal-devel \
 "
RDEPENDS:rust-async-signal-devel = " \
 cargo \
 rust \
 rust-async-io+default-devel \
 rust-cfg-if+default-devel \
 rust-futures-core+default-devel \
 rust-futures-io+default-devel \
 rust-rustix+process-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-signal-hook-registry+default-devel \
 "
