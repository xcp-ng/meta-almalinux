# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pycurl"
PV = "7.45.3"
PR = "4.el10_0"
PACKAGES = " \
 python3-pycurl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pycurl-7.45.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6acf6da9f181c4605b3aa1abf8b1e1c6e1b45038b839990e25dafbd9fdad7e2e"

URI_x86_64_v2_python3-pycurl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pycurl-7.45.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pycurl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pycurl}"
SRC_URI[x86_64_v2_python3-pycurl.sha256sum] = "379013c374a94c7ccca5eea50be11f6adb3f2f7629196c5d1b1285e9836c21f5"

URI_aarch64_python3-pycurl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pycurl-7.45.3-4.el10_0.aarch64.rpm;name=aarch64_python3-pycurl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pycurl}"
SRC_URI[aarch64_python3-pycurl.sha256sum] = "9fda00a07550aec7295bad052725fb7f578863a213c14b4788ce56be3a276ef4"

RDEPENDS:python3-pycurl:x86_64_v2 = " \
 glibc \
 openssl-libs \
 python3 \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__ge_8.9.1 \
"
RDEPENDS:python3-pycurl:aarch64 = " \
 glibc \
 openssl-libs \
 python3 \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__ge_8.9.1 \
"
