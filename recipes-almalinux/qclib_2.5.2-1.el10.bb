# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qclib"
PV = "2.5.2"
PR = "1.el10"
PACKAGES = " \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qclib-2.5.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2fcff1ef60ca2af5a452346f87ebf65404e0f69eb95a7000dfa45d71f9c02e76"

