# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "reproc"
PV = "14.2.4"
PR = "1.20230609git1c07bdb.el10_0"
PACKAGES = " \
 reproc \
 reproc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/reproc-14.2.4-1.20230609git1c07bdb.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3a122cd0612ed79ed9009421d7b426c8387660fa0839400ac498e11629b5d7f"

URI_x86_64_v2_reproc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/reproc-14.2.4-1.20230609git1c07bdb.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_reproc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_reproc}"
SRC_URI[x86_64_v2_reproc.sha256sum] = "e0dde60e8bdb6775829e2ca930ebd5344b5b6efbc63577aa6a7ca46b2be58f46"

URI_x86_64_v2_reproc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/reproc-devel-14.2.4-1.20230609git1c07bdb.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_reproc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_reproc-devel}"
SRC_URI[x86_64_v2_reproc-devel.sha256sum] = "60fbf554c220ba92278a30c3b7e50691b15a9f26a650cc8d664addbbb3123d3e"

URI_aarch64_reproc = "${EPEL_MIRROR}/aarch64/Packages/r/reproc-14.2.4-1.20230609git1c07bdb.el10_0.aarch64.rpm;name=aarch64_reproc;unpack=0"
SRC_URI:append = " ${URI_aarch64_reproc}"
SRC_URI[aarch64_reproc.sha256sum] = "d40032127bdcbb64aa4726eabce97aed904c4e6335d4aecfd029f3fb7dae0ac9"

URI_aarch64_reproc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/reproc-devel-14.2.4-1.20230609git1c07bdb.el10_0.aarch64.rpm;name=aarch64_reproc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_reproc-devel}"
SRC_URI[aarch64_reproc-devel.sha256sum] = "557e9d804728ab181546ca061681d8c47799fe5db25c188d1f8be055da8ba78c"

RDEPENDS:reproc = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:reproc-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 reproc \
 "
