# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libliftoff"
PV = "0.5.0"
PR = "1.el10_0"
PACKAGES = " \
 libliftoff \
 libliftoff-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libliftoff-0.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a193d35691904d83367c3299277cdefc84b6f9627343373a97315e8055c87e32"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libliftoff-0.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libliftoff;unpack=0"
SRC_URI[x86_64_v2_libliftoff.sha256sum] = "2d9292e1636f976f0a04c90ca3ff2ff90af39028e4b1f887381c0124f92ef542"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libliftoff-devel-0.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libliftoff-devel;unpack=0"
SRC_URI[x86_64_v2_libliftoff-devel.sha256sum] = "65217908664b9188781a3aedaa7d0bf8e531f21c4c4868b3abe7b7d27851bf67"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libliftoff-0.5.0-1.el10_0.aarch64.rpm;name=aarch64_libliftoff;unpack=0"
SRC_URI[aarch64_libliftoff.sha256sum] = "f8bd5f398f20f0e55d60363913f8a01004663a5f6b3520ee8df53194d557decc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libliftoff-devel-0.5.0-1.el10_0.aarch64.rpm;name=aarch64_libliftoff-devel;unpack=0"
SRC_URI[aarch64_libliftoff-devel.sha256sum] = "640735993bfb5a642c60381da134b33a16693cfc9211b96c4fd7454c1c486cfa"

RDEPENDS:libliftoff = " \
 glibc \
 libdrm \
 "
RDEPENDS:libliftoff-devel = " \
 libdrm-devel \
 libliftoff \
 pkgconf-pkg-config \
 "
