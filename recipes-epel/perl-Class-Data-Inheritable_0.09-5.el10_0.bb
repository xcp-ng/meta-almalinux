# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Data-Inheritable"
PV = "0.09"
PR = "5.el10_0"
PACKAGES = " \
 perl-Class-Data-Inheritable \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Data-Inheritable-0.09-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "945ddb68d9bc969c8f2a4c9216448dbc70f660503367bff3175bc570bbfa936e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Data-Inheritable-0.09-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Data-Inheritable;unpack=0"
SRC_URI[x86_64_v2_perl-Class-Data-Inheritable.sha256sum] = "dcaa7aa497ea7d68848558c1a759c3740426800b925d0326f5167d9c4fce915e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Data-Inheritable-0.09-5.el10_0.noarch.rpm;name=aarch64_perl-Class-Data-Inheritable;unpack=0"
SRC_URI[aarch64_perl-Class-Data-Inheritable.sha256sum] = "0e85ae9d326141db94b29fdbd06d19074628830a3ed094661829db5998154365"

RDEPENDS:perl-Class-Data-Inheritable = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
