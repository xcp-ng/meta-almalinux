# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "x3270"
PV = "4.3ga8"
PR = "8.el10"
PACKAGES = " \
 x3270 \
 x3270-text \
 x3270-x11 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/x3270-4.3ga8-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05e479ccb5365e6d5b39f518ee9d7936355c2d55aa3e0dd19e4e094f1cfb6676"

URI_x86_64_v2_x3270 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/x3270-4.3ga8-8.el10.x86_64_v2.rpm;name=x86_64_v2_x3270;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_x3270}"
SRC_URI[x86_64_v2_x3270.sha256sum] = "bd5d3c539cacd42a31306bb0c956c839eeb264d32e615acca9b40480c18f6700"

URI_x86_64_v2_x3270-text = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/x3270-text-4.3ga8-8.el10.x86_64_v2.rpm;name=x86_64_v2_x3270-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_x3270-text}"
SRC_URI[x86_64_v2_x3270-text.sha256sum] = "387c299169577c859698b7812c4ce0e2632a84214a034a8817dd7303f87782b6"

URI_x86_64_v2_x3270-x11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/x3270-x11-4.3ga8-8.el10.x86_64_v2.rpm;name=x86_64_v2_x3270-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_x3270-x11}"
SRC_URI[x86_64_v2_x3270-x11.sha256sum] = "df69001a2c4314c44cf4bae0398c6b56f667d5492f13109862dede49d6dff01f"

URI_aarch64_x3270 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/x3270-4.3ga8-8.el10.aarch64.rpm;name=aarch64_x3270;unpack=0"
SRC_URI:append = " ${URI_aarch64_x3270}"
SRC_URI[aarch64_x3270.sha256sum] = "3d848f145243186787c70af6a778eaa5c579a08b0b2f70e32116cba8ded6b9ae"

URI_aarch64_x3270-text = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/x3270-text-4.3ga8-8.el10.aarch64.rpm;name=aarch64_x3270-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_x3270-text}"
SRC_URI[aarch64_x3270-text.sha256sum] = "a160da29b0c7c7ea11e1320bb1da73ce834abe4faf3bf3e71b4c67953c5b9080"

URI_aarch64_x3270-x11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/x3270-x11-4.3ga8-8.el10.aarch64.rpm;name=aarch64_x3270-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_x3270-x11}"
SRC_URI[aarch64_x3270-x11.sha256sum] = "a293fcdc9d2bad3cbb929a3ff4670ee731193b792ba7bbd9c104663702997b10"

RDEPENDS:x3270 = " \
 bash \
 glibc \
 ncurses-libs \
 openssl-libs \
 readline \
 "
RDEPENDS:x3270-text = " \
 glibc \
 ncurses-libs \
 openssl-libs \
 readline \
 x3270 \
 "
RDEPENDS:x3270-x11 = " \
 bash \
 glibc \
 libX11 \
 libXaw \
 libXmu \
 libXt \
 openssl-libs \
 x3270 \
 xrdb \
 "
