# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbounce"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kbounce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbounce-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd9d4ecc1be78148a08af0a630d4d062b08b395d5d931c86adf126aff79c0096"

URI_x86_64_v2_kbounce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbounce-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbounce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbounce}"
SRC_URI[x86_64_v2_kbounce.sha256sum] = "285e64772ef2bbcaf43ceaaa7dfc21cd13b7b97da88e525b1d89661a1bd93bb1"

URI_aarch64_kbounce = "${EPEL_MIRROR}/aarch64/Packages/k/kbounce-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kbounce;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbounce}"
SRC_URI[aarch64_kbounce.sha256sum] = "aeb286731729b81e968e64c7d6178d093e1012a1c66bac51c30ee72e7a8f20d3"

RDEPENDS:kbounce = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
