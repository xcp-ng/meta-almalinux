# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-packetline-blocking"
PV = "0.18.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-packetline-blocking+async-io-devel \
 rust-gix-packetline-blocking+blocking-io-devel \
 rust-gix-packetline-blocking+default-devel \
 rust-gix-packetline-blocking+document-features-devel \
 rust-gix-packetline-blocking+serde-devel \
 rust-gix-packetline-blocking-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-packetline-blocking-0.18.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "734a4300ca22cbcdb3fcf9111680677b1f592314b059117b495fd2de2f847551"

URI_x86_64_v2_rust-gix-packetline-blocking+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+async-io-devel-0.18.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+async-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+async-io-devel.sha256sum] = "4a5ee6a70554fe37a947f0b2ce211b731b4c699d234065a6ad52795ae37e69ec"

URI_x86_64_v2_rust-gix-packetline-blocking+blocking-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+blocking-io-devel-0.18.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+blocking-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+blocking-io-devel.sha256sum] = "b3664c65f43ee137c7270917f302edf3750ceaea2bcce223f8ba5834b0feef6a"

URI_x86_64_v2_rust-gix-packetline-blocking+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+default-devel-0.18.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+default-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+default-devel.sha256sum] = "4dc57e6e65fe250c9eab72d99cbcdd98bef09cb49e57fcbfd28e82a445abe6b9"

URI_x86_64_v2_rust-gix-packetline-blocking+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+document-features-devel-0.18.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+document-features-devel.sha256sum] = "342f265c96b7405d31b4ffd4a07b2f2253a1acf6e10cf8345fc0c6d2e8da3b0a"

URI_x86_64_v2_rust-gix-packetline-blocking+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+serde-devel-0.18.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+serde-devel.sha256sum] = "75ea438cd01c062d2322d16f8f5a773a2abfd9a9c36be401450536308729f31c"

URI_x86_64_v2_rust-gix-packetline-blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking-devel-0.18.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking-devel.sha256sum] = "8754ac5f70d21bddb4c6bccb01b0208b163abb3231f77a216ffd58f9a136a066"

URI_aarch64_rust-gix-packetline-blocking+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+async-io-devel-0.18.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+async-io-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+async-io-devel.sha256sum] = "8a2dbad7cade5063585370b111620930b65bf1e908177ab0e6e068d3bb160312"

URI_aarch64_rust-gix-packetline-blocking+blocking-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+blocking-io-devel-0.18.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+blocking-io-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+blocking-io-devel.sha256sum] = "ec389901472caefef0d25d4245edf8ae5f1393db0ed356394867996a527e6bf1"

URI_aarch64_rust-gix-packetline-blocking+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+default-devel-0.18.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+default-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+default-devel.sha256sum] = "448a83c22f1a9bb626b88e3e70a6833ae510771e2af865410def8dea5cd40a37"

URI_aarch64_rust-gix-packetline-blocking+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+document-features-devel-0.18.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+document-features-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+document-features-devel.sha256sum] = "0144b25e15cc4c19d37744a8a332ceab5c0f89344aa5afe10684f29a30dc0257"

URI_aarch64_rust-gix-packetline-blocking+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+serde-devel-0.18.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+serde-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+serde-devel.sha256sum] = "1f260f9b6b7eac34771be5b1997dab2f1f805d0c593cb99eae58ebc5156e94f6"

URI_aarch64_rust-gix-packetline-blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking-devel-0.18.2-1.el10_0.noarch.rpm;name=aarch64_rust-gix-packetline-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking-devel.sha256sum] = "27d2544c0a3a96275056d5f30007e33dc09c0f70ab6818244e0323e174095a87"

RDEPENDS:rust-gix-packetline-blocking+async-io-devel = " \
 cargo \
 rust-gix-packetline-blocking-devel \
 "
RDEPENDS:rust-gix-packetline-blocking+blocking-io-devel = " \
 cargo \
 rust-gix-packetline-blocking-devel \
 "
RDEPENDS:rust-gix-packetline-blocking+default-devel = " \
 cargo \
 rust-gix-packetline-blocking+blocking-io-devel \
 rust-gix-packetline-blocking-devel \
 "
RDEPENDS:rust-gix-packetline-blocking+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-packetline-blocking-devel \
 "
RDEPENDS:rust-gix-packetline-blocking+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-packetline-blocking-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-packetline-blocking-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-faster-hex+default-devel \
 rust-gix-trace+default-devel \
 rust-thiserror+default-devel \
 "
