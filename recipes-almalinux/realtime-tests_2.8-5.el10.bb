# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "realtime-tests"
PV = "2.8"
PR = "5.el10"
PACKAGES = " \
 realtime-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/realtime-tests-2.8-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cdd4069d00781fbd7f2332cfe3b8f7ad5f60bdffd7620a898bbadd09389a63c"

URI_x86_64_v2_realtime-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/realtime-tests-2.8-5.el10.x86_64_v2.rpm;name=x86_64_v2_realtime-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_realtime-tests}"
SRC_URI[x86_64_v2_realtime-tests.sha256sum] = "2690cdbd3fefb4cc7e9295cea422e1452415280cf5e65d949bab8275f0531932"

URI_aarch64_realtime-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/realtime-tests-2.8-5.el10.aarch64.rpm;name=aarch64_realtime-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_realtime-tests}"
SRC_URI[aarch64_realtime-tests.sha256sum] = "c9f3384241e5c29736287e9ccb2486c24e896f558fcd1570ab98b9b22e8b7f03"

RDEPENDS:realtime-tests = " \
 bash \
 bc \
 glibc \
 kernel-tools-libs \
 numactl-libs \
 python3 \
 "
