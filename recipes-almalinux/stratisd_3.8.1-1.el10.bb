# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stratisd"
PV = "3.8.1"
PR = "1.el10"
PACKAGES = " \
 stratisd \
 stratisd-dracut \
 stratisd-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/stratisd-3.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f34b606dc967551bc504be45c4fb39fd96788e533c0627ed715e23d4d73b297"

URI_x86_64_v2_stratisd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stratisd-3.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_stratisd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stratisd}"
SRC_URI[x86_64_v2_stratisd.sha256sum] = "5c1472c0b4f5562a828b22ec6f12d5d86c903144da10b05fb8e9cbe25ad3b485"

URI_x86_64_v2_stratisd-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stratisd-dracut-3.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_stratisd-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stratisd-dracut}"
SRC_URI[x86_64_v2_stratisd-dracut.sha256sum] = "58a9fdd9253fb7b07c970a640f0f1940540429ddea78423c64693319ab6aad4d"

URI_x86_64_v2_stratisd-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stratisd-tools-3.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_stratisd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stratisd-tools}"
SRC_URI[x86_64_v2_stratisd-tools.sha256sum] = "b3a2e0df50a1d0f6e098effe09e01c800a3a8acdeaeecf3ab0ddc9274ad5a98f"

URI_aarch64_stratisd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stratisd-3.8.1-1.el10.aarch64.rpm;name=aarch64_stratisd;unpack=0"
SRC_URI:append = " ${URI_aarch64_stratisd}"
SRC_URI[aarch64_stratisd.sha256sum] = "fcdb29303bdd91c53cdfe0871f009640bf552a2928fbca4598e6463d0de21143"

URI_aarch64_stratisd-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stratisd-dracut-3.8.1-1.el10.aarch64.rpm;name=aarch64_stratisd-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_stratisd-dracut}"
SRC_URI[aarch64_stratisd-dracut.sha256sum] = "39c282b6afc5789cee6cf0669fbc25cfc39b3b78e47a43078918906990f3ea73"

URI_aarch64_stratisd-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stratisd-tools-3.8.1-1.el10.aarch64.rpm;name=aarch64_stratisd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_stratisd-tools}"
SRC_URI[aarch64_stratisd-tools.sha256sum] = "c673e0ef10af1ccc7ea259bb59c778846b6870bdc7873ad7549ca3b560679d26"

RDEPENDS:stratisd = " \
 bash \
 cryptsetup-libs \
 dbus-libs \
 device-mapper-persistent-data \
 glibc \
 libblkid \
 libgcc \
 python3 \
 systemd-libs \
 xfsprogs \
 "
RDEPENDS:stratisd-dracut = " \
 bash \
 cryptsetup-libs \
 dracut \
 glibc \
 libblkid \
 libgcc \
 stratisd \
 systemd \
 systemd-libs \
 "
RDEPENDS:stratisd-tools = " \
 cryptsetup-libs \
 glibc \
 libblkid \
 libgcc \
 stratisd \
 systemd-libs \
 "
