# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-colorchoice"
PV = "1.0.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-colorchoice+default-devel \
 rust-colorchoice-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-colorchoice-1.0.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90dae9f674f804c06fc59e8d0410e301549e1cedf82ecb8c7cb510ab595ae025"

URI_x86_64_v2_rust-colorchoice+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colorchoice+default-devel-1.0.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colorchoice+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colorchoice+default-devel}"
SRC_URI[x86_64_v2_rust-colorchoice+default-devel.sha256sum] = "567617e6d43de07c2e7ded0f9a3794a557db734564f994d7c7502ce9e44914e8"

URI_x86_64_v2_rust-colorchoice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colorchoice-devel-1.0.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colorchoice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colorchoice-devel}"
SRC_URI[x86_64_v2_rust-colorchoice-devel.sha256sum] = "2250b23f4743a46866caac4eb04e2bd726f5dd971dcf473bd8c82aca459f2b6f"

URI_aarch64_rust-colorchoice+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colorchoice+default-devel-1.0.5-1.el10_2.noarch.rpm;name=aarch64_rust-colorchoice+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colorchoice+default-devel}"
SRC_URI[aarch64_rust-colorchoice+default-devel.sha256sum] = "c99bfd46fcf75a0da0d6b778d48586822d94073dd80d4034a6c88e1566ecc201"

URI_aarch64_rust-colorchoice-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colorchoice-devel-1.0.5-1.el10_2.noarch.rpm;name=aarch64_rust-colorchoice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colorchoice-devel}"
SRC_URI[aarch64_rust-colorchoice-devel.sha256sum] = "3ae2eb1745ff0f491f75897ebd7fc03a6c5f295761aaa3598edb0fe6b2f7f3d9"

RDEPENDS:rust-colorchoice+default-devel = " \
 cargo \
 rust-colorchoice-devel \
 "
RDEPENDS:rust-colorchoice-devel = " \
 cargo \
 rust \
 "
