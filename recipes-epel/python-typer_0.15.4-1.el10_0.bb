# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-typer"
PV = "0.15.4"
PR = "1.el10_0"
PACKAGES = " \
 python3-typer \
 python3-typer-cli \
 python3-typer-slim \
 python3-typer-slim+standard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-typer-0.15.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c0b2156a914b83f19f6185a003eef51e65201401b027ca2fa221cc9d26de299"

URI_x86_64_v2_python3-typer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-typer-0.15.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-typer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typer}"
SRC_URI[x86_64_v2_python3-typer.sha256sum] = "5dd60c0de5880636c682e484d3c1f3d7a438bd7525f445df753176e796f26545"

URI_x86_64_v2_python3-typer-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-typer-cli-0.15.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-typer-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typer-cli}"
SRC_URI[x86_64_v2_python3-typer-cli.sha256sum] = "0443e4bb778c5948ae2f248b9d60490f528a76c60a3dd5f72589420930554e77"

URI_x86_64_v2_python3-typer-slim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-typer-slim-0.15.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-typer-slim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typer-slim}"
SRC_URI[x86_64_v2_python3-typer-slim.sha256sum] = "f089fa35bbd96f62574cbb1527a18078aa50db37955b49134c784fde2f999a21"

URI_x86_64_v2_python3-typer-slim+standard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-typer-slim+standard-0.15.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-typer-slim+standard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typer-slim+standard}"
SRC_URI[x86_64_v2_python3-typer-slim+standard.sha256sum] = "9c6f4bfcf47b486089586c976411dd0f0082ac90b8c7cc3147f0fa522caf45e5"

URI_aarch64_python3-typer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-typer-0.15.4-1.el10_0.noarch.rpm;name=aarch64_python3-typer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typer}"
SRC_URI[aarch64_python3-typer.sha256sum] = "33ab3bb117331f9865fd8d69f0d078207f34e54400b9621f0bac3055ccf15439"

URI_aarch64_python3-typer-cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-typer-cli-0.15.4-1.el10_0.noarch.rpm;name=aarch64_python3-typer-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typer-cli}"
SRC_URI[aarch64_python3-typer-cli.sha256sum] = "2eee671fd8ca2b447a4a96edd0a69c470b3ad62330ed53954a3425198b907f8d"

URI_aarch64_python3-typer-slim = "${EPEL_MIRROR}/aarch64/Packages/p/python3-typer-slim-0.15.4-1.el10_0.noarch.rpm;name=aarch64_python3-typer-slim;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typer-slim}"
SRC_URI[aarch64_python3-typer-slim.sha256sum] = "4927fbb0caec13c6014584e7f8d7abcac85960c8eaab8e0659c0be2d13f773b6"

URI_aarch64_python3-typer-slim+standard = "${EPEL_MIRROR}/aarch64/Packages/p/python3-typer-slim+standard-0.15.4-1.el10_0.noarch.rpm;name=aarch64_python3-typer-slim+standard;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typer-slim+standard}"
SRC_URI[aarch64_python3-typer-slim+standard.sha256sum] = "57c209bbaac33d39f2e67c948401c5262da661cf79fabb8800aa335d05816921"

RDEPENDS:python3-typer = " \
 python3 \
 python3-click \
 python3-rich \
 python3-shellingham \
 python3-typer-cli \
 python3-typer-slim \
 python3-typing-extensions \
 "
RDEPENDS:python3-typer-cli = " \
 python3 \
 python3-typer \
 python3-typer-slim \
 "
RDEPENDS:python3-typer-slim = " \
 python3 \
 python3-click \
 python3-typing-extensions \
 "
RDEPENDS:python3-typer-slim+standard = " \
 python3 \
 python3-rich \
 python3-shellingham \
 python3-typer-slim \
 "
