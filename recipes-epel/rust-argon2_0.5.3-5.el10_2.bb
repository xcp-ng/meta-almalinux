# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-argon2"
PV = "0.5.3"
PR = "5.el10_2"
PACKAGES = " \
 rust-argon2+alloc-devel \
 rust-argon2+default-devel \
 rust-argon2+password-hash-devel \
 rust-argon2+rand-devel \
 rust-argon2+simple-devel \
 rust-argon2+std-devel \
 rust-argon2+zeroize-devel \
 rust-argon2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-argon2-0.5.3-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a62b28f9bbe626439f41bf0a714a444595fdacff0b0ded59c71d157c620468a6"

URI_x86_64_v2_rust-argon2+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+alloc-devel-0.5.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+alloc-devel}"
SRC_URI[x86_64_v2_rust-argon2+alloc-devel.sha256sum] = "879920e78f7d5c4fc3001274e27dfc1e11d0782e74e52b66515ca19ebabdc1ce"

URI_x86_64_v2_rust-argon2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+default-devel-0.5.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+default-devel}"
SRC_URI[x86_64_v2_rust-argon2+default-devel.sha256sum] = "6f2ebe0654632df95fe614747c0941d7b3327c5057e3d55c03a070c7e4da5a4c"

URI_x86_64_v2_rust-argon2+password-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+password-hash-devel-0.5.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+password-hash-devel}"
SRC_URI[x86_64_v2_rust-argon2+password-hash-devel.sha256sum] = "16a8d10aa558d2d6df41e45115f396de07f9bcd7801e70529e1d3a5bca75f475"

URI_x86_64_v2_rust-argon2+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+rand-devel-0.5.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+rand-devel}"
SRC_URI[x86_64_v2_rust-argon2+rand-devel.sha256sum] = "36a93fa75e6eb1a4e2a713a1b0f2b125d53781123976effb9220bb6807451fb3"

URI_x86_64_v2_rust-argon2+simple-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+simple-devel-0.5.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+simple-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+simple-devel}"
SRC_URI[x86_64_v2_rust-argon2+simple-devel.sha256sum] = "2b7ded8a4af61d1ab5006cb6f280dfd269a516bbd1ee0f822b8970a55385045b"

URI_x86_64_v2_rust-argon2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+std-devel-0.5.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+std-devel}"
SRC_URI[x86_64_v2_rust-argon2+std-devel.sha256sum] = "56bc93b35d0e87abd05423eea3e519ae75b5c1baa27eca2dca4801320a844deb"

URI_x86_64_v2_rust-argon2+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+zeroize-devel-0.5.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+zeroize-devel}"
SRC_URI[x86_64_v2_rust-argon2+zeroize-devel.sha256sum] = "90853fecc1e11bc497d222b1fbff95700f8505dd1da585deac8d2ef980dc8cba"

URI_x86_64_v2_rust-argon2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2-devel-0.5.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2-devel}"
SRC_URI[x86_64_v2_rust-argon2-devel.sha256sum] = "f30896251db822f5ec9f30f8186738cf49ed51c094e40920f2b65f6de3f87f3e"

URI_aarch64_rust-argon2+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+alloc-devel-0.5.3-5.el10_2.noarch.rpm;name=aarch64_rust-argon2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+alloc-devel}"
SRC_URI[aarch64_rust-argon2+alloc-devel.sha256sum] = "c7ce343012d7f6993b14f637c52ea39602c5579a06bff2ddff2c17dfd08d107a"

URI_aarch64_rust-argon2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+default-devel-0.5.3-5.el10_2.noarch.rpm;name=aarch64_rust-argon2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+default-devel}"
SRC_URI[aarch64_rust-argon2+default-devel.sha256sum] = "d6cd1887c92a784933b46a1f9b10eef7674404537467ef28bd6b0e1220c7fd7f"

URI_aarch64_rust-argon2+password-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+password-hash-devel-0.5.3-5.el10_2.noarch.rpm;name=aarch64_rust-argon2+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+password-hash-devel}"
SRC_URI[aarch64_rust-argon2+password-hash-devel.sha256sum] = "4c0e62cba34e080011981e49262a97383da73845e20fe4bdb72beb7dda19b6e8"

URI_aarch64_rust-argon2+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+rand-devel-0.5.3-5.el10_2.noarch.rpm;name=aarch64_rust-argon2+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+rand-devel}"
SRC_URI[aarch64_rust-argon2+rand-devel.sha256sum] = "d442dd8079b37008fb7261e9ac6d8c99e8252988c22c469f10366ed9b4ce3cc1"

URI_aarch64_rust-argon2+simple-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+simple-devel-0.5.3-5.el10_2.noarch.rpm;name=aarch64_rust-argon2+simple-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+simple-devel}"
SRC_URI[aarch64_rust-argon2+simple-devel.sha256sum] = "17229e1ba5f02878e18f0e1941b693b4a43b1903a2ddbb6331dc10d0e00426c2"

URI_aarch64_rust-argon2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+std-devel-0.5.3-5.el10_2.noarch.rpm;name=aarch64_rust-argon2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+std-devel}"
SRC_URI[aarch64_rust-argon2+std-devel.sha256sum] = "2a6c30bea735c6a7791fbbcddc546e1bfc4afafd1bd200f7767a517b5fcd628d"

URI_aarch64_rust-argon2+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+zeroize-devel-0.5.3-5.el10_2.noarch.rpm;name=aarch64_rust-argon2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+zeroize-devel}"
SRC_URI[aarch64_rust-argon2+zeroize-devel.sha256sum] = "c7c302747122204f1423459552cff6fd3fbc68ebf05121275259a2318216a165"

URI_aarch64_rust-argon2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2-devel-0.5.3-5.el10_2.noarch.rpm;name=aarch64_rust-argon2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2-devel}"
SRC_URI[aarch64_rust-argon2-devel.sha256sum] = "a807dcc337e27ebe3f68f65d1caef3da5af09f874cfde3833fce86e6b021111e"

RDEPENDS:rust-argon2+alloc-devel = " \
 cargo \
 rust-argon2-devel \
 rust-password-hash+alloc-devel \
 rust-password-hash+default-devel \
 "
RDEPENDS:rust-argon2+default-devel = " \
 cargo \
 rust-argon2+alloc-devel \
 rust-argon2+password-hash-devel \
 rust-argon2+rand-devel \
 rust-argon2-devel \
 "
RDEPENDS:rust-argon2+password-hash-devel = " \
 cargo \
 rust-argon2-devel \
 rust-password-hash+default-devel \
 "
RDEPENDS:rust-argon2+rand-devel = " \
 cargo \
 rust-argon2-devel \
 rust-password-hash+default-devel \
 rust-password-hash+rand_core-devel \
 "
RDEPENDS:rust-argon2+simple-devel = " \
 cargo \
 rust-argon2+password-hash-devel \
 rust-argon2-devel \
 "
RDEPENDS:rust-argon2+std-devel = " \
 cargo \
 rust-argon2+alloc-devel \
 rust-argon2-devel \
 rust-password-hash+default-devel \
 rust-password-hash+std-devel \
 "
RDEPENDS:rust-argon2+zeroize-devel = " \
 cargo \
 rust-argon2-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-argon2-devel = " \
 cargo \
 rust \
 rust-base64ct+default-devel \
 rust-blake2-devel \
 rust-cpufeatures0.2+default-devel \
 "
