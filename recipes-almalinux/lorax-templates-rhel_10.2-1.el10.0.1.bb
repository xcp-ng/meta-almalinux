# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lorax-templates-rhel"
PV = "10.2"
PR = "1.el10.0.1"
PACKAGES = " \
 lorax-templates-almalinux \
 lorax-templates-rhel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lorax-templates-rhel-10.2-1.el10.0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "358b392d65b33bee4d313a47bf6a9835607ff5995dd0f46a7ff79819f8c66adc"

URI_x86_64_v2_lorax-templates-almalinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-almalinux-10.2-1.el10.0.1.noarch.rpm;name=x86_64_v2_lorax-templates-almalinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-templates-almalinux}"
SRC_URI[x86_64_v2_lorax-templates-almalinux.sha256sum] = "25ecf6d4c3f097eb616a5887e19e0c7d03390c4d753336b0470cfef66ce688dc"
RPROVIDES:lorax-templates-almalinux:x86_64_v2 = "virtual/lorax-templates"

URI_x86_64_v2_lorax-templates-rhel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-rhel-10.2-1.el10.0.1.noarch.rpm;name=x86_64_v2_lorax-templates-rhel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-templates-rhel}"
SRC_URI[x86_64_v2_lorax-templates-rhel.sha256sum] = "541674947760d079e8508d71d4713b04a383a6330d24c1d3acafbe2d329d565a"
RPROVIDES:lorax-templates-rhel:x86_64_v2 = "virtual/lorax-templates"

URI_aarch64_lorax-templates-almalinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-almalinux-10.2-1.el10.0.1.noarch.rpm;name=aarch64_lorax-templates-almalinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-templates-almalinux}"
SRC_URI[aarch64_lorax-templates-almalinux.sha256sum] = "25ecf6d4c3f097eb616a5887e19e0c7d03390c4d753336b0470cfef66ce688dc"
RPROVIDES:lorax-templates-almalinux:aarch64 = "virtual/lorax-templates"

URI_aarch64_lorax-templates-rhel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-rhel-10.2-1.el10.0.1.noarch.rpm;name=aarch64_lorax-templates-rhel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-templates-rhel}"
SRC_URI[aarch64_lorax-templates-rhel.sha256sum] = "541674947760d079e8508d71d4713b04a383a6330d24c1d3acafbe2d329d565a"
RPROVIDES:lorax-templates-rhel:aarch64 = "virtual/lorax-templates"

RDEPENDS:lorax-templates-almalinux = " \
 lorax \
 "
RDEPENDS:lorax-templates-rhel = " \
 lorax \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/lorax-templates"

PROVIDES:append:aarch64 = " rpm/virtual/lorax-templates"
