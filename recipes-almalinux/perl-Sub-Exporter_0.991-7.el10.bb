# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sub-Exporter"
PV = "0.991"
PR = "7.el10"
PACKAGES = " \
 perl-Sub-Exporter \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Sub-Exporter-0.991-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4227e9438479d2f45263d46d0017c54a61384725c4a94b054ba138c3306de730"

URI_x86_64_v2_perl-Sub-Exporter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Sub-Exporter-0.991-7.el10.noarch.rpm;name=x86_64_v2_perl-Sub-Exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sub-Exporter}"
SRC_URI[x86_64_v2_perl-Sub-Exporter.sha256sum] = "d72c51eca8d144757e48a55c76d1c9135ccc49e69d0f3079542f15949d2e10ba"

URI_aarch64_perl-Sub-Exporter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Sub-Exporter-0.991-7.el10.noarch.rpm;name=aarch64_perl-Sub-Exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sub-Exporter}"
SRC_URI[aarch64_perl-Sub-Exporter.sha256sum] = "d72c51eca8d144757e48a55c76d1c9135ccc49e69d0f3079542f15949d2e10ba"

RDEPENDS:perl-Sub-Exporter = " \
 perl-Carp \
 perl-Data-OptList \
 perl-Package-Generator \
 perl-Params-Util \
 perl-Sub-Exporter \
 perl-Sub-Install \
 perl-libs \
 "
