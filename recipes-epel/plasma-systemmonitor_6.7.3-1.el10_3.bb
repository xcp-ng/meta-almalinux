# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-systemmonitor"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-systemmonitor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-systemmonitor-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5d4099afa6e5438a07bb1bb166cab40f5c0c733e3cb46eebd40d98e1aa253f4"

URI_x86_64_v2_plasma-systemmonitor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-systemmonitor-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-systemmonitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-systemmonitor}"
SRC_URI[x86_64_v2_plasma-systemmonitor.sha256sum] = "51fd75dd2b84562eeb35b230bc73e5df5ebf4629b51ea952fa3b1ad9ec83d388"

URI_aarch64_plasma-systemmonitor = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-systemmonitor-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-systemmonitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-systemmonitor}"
SRC_URI[aarch64_plasma-systemmonitor.sha256sum] = "d289534edfa6443b94d672624668c6d94205c274e6be8ccb9a627d5b27cd7d66"

RDEPENDS:plasma-systemmonitor = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knewstuff \
 kf6-kquickcharts \
 kf6-kservice \
 kf6-kwindowsystem \
 ksystemstats \
 libksysguard \
 libstdc++ \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
