# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "noip"
PV = "2.1.9"
PR = "41.el10_0"
PACKAGES = " \
 noip \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/noip-2.1.9-41.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e13396b50565c310080b378c1537c7a64562cc41f16c4680ed4e20be06baf4d"

URI_x86_64_v2_noip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/noip-2.1.9-41.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_noip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_noip}"
SRC_URI[x86_64_v2_noip.sha256sum] = "affad8921ef83ba54ab710c92f3a4b4dc8989325f2c826af2122ae21e6e54b63"

URI_aarch64_noip = "${EPEL_MIRROR}/aarch64/Packages/n/noip-2.1.9-41.el10_0.aarch64.rpm;name=aarch64_noip;unpack=0"
SRC_URI:append = " ${URI_aarch64_noip}"
SRC_URI[aarch64_noip.sha256sum] = "6548713920c00ab5d468f4cc4a0db7fec5605e836a52b1d27d4cd73f56398d4a"

RDEPENDS:noip = " \
 bash \
 glibc \
 shadow-utils \
 systemd \
 "
