# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xl2tpd"
PV = "1.3.17"
PR = "6.el10_0"
PACKAGES = " \
 xl2tpd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xl2tpd-1.3.17-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24f9d4a509d0d3e9af1c2cd0b30ff3a18661de8b85452dcf1e8bde465dd233e9"

URI_x86_64_v2_xl2tpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xl2tpd-1.3.17-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xl2tpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xl2tpd}"
SRC_URI[x86_64_v2_xl2tpd.sha256sum] = "9061fe27da9e3d8e93081d0b8d0d3c6ac5552e390cdad7fe2cde4123551f418e"

URI_aarch64_xl2tpd = "${EPEL_MIRROR}/aarch64/Packages/x/xl2tpd-1.3.17-6.el10_0.aarch64.rpm;name=aarch64_xl2tpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_xl2tpd}"
SRC_URI[aarch64_xl2tpd.sha256sum] = "69f808d7ac989c2ff1115466d517f36c20f6ba3eaa50a5b96c79530735469770"

RDEPENDS:xl2tpd = " \
 bash \
 glibc \
 libpcap \
 openssl-libs \
 ppp \
 systemd \
 virtual/kmod_l2tp_ppp.ko_ \
 "
