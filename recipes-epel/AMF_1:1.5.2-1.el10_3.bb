# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "AMF"
PE = "1"
PV = "1.5.2"
PR = "1.el10_3"
PACKAGES = " \
 AMF-devel \
 AMF-docs \
 AMF-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/AMF-1.5.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "944f0c468c0f1034e71b9805d4eeba2ec2e592a5b9b3c81df5dea88d087c2cf4"

URI_x86_64_v2_AMF-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/AMF-devel-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_AMF-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_AMF-devel}"
SRC_URI[x86_64_v2_AMF-devel.sha256sum] = "6505d06a38285f48d4ab26a7022ab0f83a071946062a17a7ce5988b9b3c6d678"

URI_x86_64_v2_AMF-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/AMF-docs-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_AMF-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_AMF-docs}"
SRC_URI[x86_64_v2_AMF-docs.sha256sum] = "4a238c64f3e2958807a57284ba03d83e8ed039ee43e77657dce176004caad41d"

URI_x86_64_v2_AMF-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/AMF-samples-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_AMF-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_AMF-samples}"
SRC_URI[x86_64_v2_AMF-samples.sha256sum] = "ca5df09df622c7fe017c573cc21f37d1573dcbef4985d16636fadea12dc4d2d8"

URI_aarch64_AMF-devel = "${EPEL_MIRROR}/aarch64/Packages/a/AMF-devel-1.5.2-1.el10_3.noarch.rpm;name=aarch64_AMF-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_AMF-devel}"
SRC_URI[aarch64_AMF-devel.sha256sum] = "86865a39d6b1e9c64207bf6e149f4a361401b464a234dbcce6bd76be8bf28a11"

URI_aarch64_AMF-docs = "${EPEL_MIRROR}/aarch64/Packages/a/AMF-docs-1.5.2-1.el10_3.noarch.rpm;name=aarch64_AMF-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_AMF-docs}"
SRC_URI[aarch64_AMF-docs.sha256sum] = "7422cca37db0d5640ee5a1a61cd644e801f3e438385371d20b77ff5fffa2b4ae"

URI_aarch64_AMF-samples = "${EPEL_MIRROR}/aarch64/Packages/a/AMF-samples-1.5.2-1.el10_3.noarch.rpm;name=aarch64_AMF-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_AMF-samples}"
SRC_URI[aarch64_AMF-samples.sha256sum] = "22a4e3822fc929279948b1332c399b3cc0bdd74df3b93a520b4a83dc221f46be"

RDEPENDS:AMF-devel = " \
 "
RDEPENDS:AMF-docs = " \
 "
RDEPENDS:AMF-samples = " \
 "
