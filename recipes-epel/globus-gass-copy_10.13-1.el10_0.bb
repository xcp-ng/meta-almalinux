# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gass-copy"
PV = "10.13"
PR = "1.el10_0"
PACKAGES = " \
 globus-gass-copy \
 globus-gass-copy-devel \
 globus-gass-copy-doc \
 globus-gass-copy-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gass-copy-10.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca2310e4f46a06fe90ae1443f9a13aa7107ffd3559be79a589d710b5d06818fa"

URI_x86_64_v2_globus-gass-copy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-copy-10.13-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-copy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-copy}"
SRC_URI[x86_64_v2_globus-gass-copy.sha256sum] = "1696c9202e4b4089fa170af235e1e47d5645ab17b0f2925110f0888dd7d83a18"

URI_x86_64_v2_globus-gass-copy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-copy-devel-10.13-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-copy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-copy-devel}"
SRC_URI[x86_64_v2_globus-gass-copy-devel.sha256sum] = "89e4b3ab29f5e8bc4ff6437160f4ede78445af7e5e6d5243a462f742e7028d44"

URI_x86_64_v2_globus-gass-copy-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-copy-doc-10.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gass-copy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-copy-doc}"
SRC_URI[x86_64_v2_globus-gass-copy-doc.sha256sum] = "1fc4b73eb090f6af3a2942c4226b1c43c8e73af7b02dec189ccf1107e67a6381"

URI_x86_64_v2_globus-gass-copy-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-copy-progs-10.13-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-copy-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-copy-progs}"
SRC_URI[x86_64_v2_globus-gass-copy-progs.sha256sum] = "af7a1c3681a4d3e32d7d0b7c99acff4d28033a3934abb60a2a19d18bb7590893"

URI_aarch64_globus-gass-copy = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-copy-10.13-1.el10_0.aarch64.rpm;name=aarch64_globus-gass-copy;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-copy}"
SRC_URI[aarch64_globus-gass-copy.sha256sum] = "961c11ec7a34cbb016f162faee7c2d2090863e7ffaf7b57b2a4b7b5da06055a6"

URI_aarch64_globus-gass-copy-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-copy-devel-10.13-1.el10_0.aarch64.rpm;name=aarch64_globus-gass-copy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-copy-devel}"
SRC_URI[aarch64_globus-gass-copy-devel.sha256sum] = "3c87a6fc3003ee1d598ab2a4a062654788bc5a434630e13cfb2ce1ac46d72fac"

URI_aarch64_globus-gass-copy-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-copy-doc-10.13-1.el10_0.noarch.rpm;name=aarch64_globus-gass-copy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-copy-doc}"
SRC_URI[aarch64_globus-gass-copy-doc.sha256sum] = "f7589b1878f2485c607eb6347c76cbdf0c8348db970355518c5dc181c969c7ec"

URI_aarch64_globus-gass-copy-progs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-copy-progs-10.13-1.el10_0.aarch64.rpm;name=aarch64_globus-gass-copy-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-copy-progs}"
SRC_URI[aarch64_globus-gass-copy-progs.sha256sum] = "1b3e82b57f9bd322fac95191873b4896460d718b363de053d71681f45eff6518"

RDEPENDS:globus-gass-copy = " \
 glibc \
 globus-common \
 globus-ftp-client \
 globus-gass-transfer \
 globus-io \
 openssl-libs \
 "
RDEPENDS:globus-gass-copy-devel = " \
 globus-common-devel \
 globus-ftp-client-devel \
 globus-ftp-control-devel \
 globus-gass-copy \
 globus-gass-transfer-devel \
 globus-gsi-sysconfig-devel \
 globus-gssapi-error-devel \
 globus-gssapi-gsi-devel \
 globus-io-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gass-copy-doc = " \
 "
RDEPENDS:globus-gass-copy-progs = " \
 glibc \
 globus-common \
 globus-ftp-client \
 globus-gass-copy \
 globus-gass-transfer \
 globus-gsi-sysconfig \
 globus-gssapi-error \
 globus-gssapi-gsi \
 globus-io \
 libtool-ltdl \
 openssl-libs \
 "
