# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-width0.1"
PV = "0.1.14"
PR = "1.el10_0"
PACKAGES = " \
 rust-unicode-width0.1+cjk-devel \
 rust-unicode-width0.1+default-devel \
 rust-unicode-width0.1+no_std-devel \
 rust-unicode-width0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-width0.1-0.1.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41a568219cb0333950401e76b0a875c6016baf1d424f9ae0a1be13e6c53c7985"

URI_x86_64_v2_rust-unicode-width0.1+cjk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width0.1+cjk-devel-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width0.1+cjk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-width0.1+cjk-devel}"
SRC_URI[x86_64_v2_rust-unicode-width0.1+cjk-devel.sha256sum] = "9135a3136b882ec1602f04026139a2d61b6e07204e37b740a96ad9a6ba76bd48"

URI_x86_64_v2_rust-unicode-width0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width0.1+default-devel-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-width0.1+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-width0.1+default-devel.sha256sum] = "fc27e528f5e5bbd5bd59de9e76edcb8e099fc3de5aede260bbdd6e40c1efafb0"
RPROVIDES:rust-unicode-width0.1+default-devel:append:x86_64_v2 = " virtual/crate_unicode-width/default__ge_0.0.0_with_crate_unicode-width/default__lt_1.0.0~ virtual/crate_unicode-width/default__ge_0.1.0_with_crate_unicode-width/default__lt_0.3.0~"

URI_x86_64_v2_rust-unicode-width0.1+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width0.1+no_std-devel-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width0.1+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-width0.1+no_std-devel}"
SRC_URI[x86_64_v2_rust-unicode-width0.1+no_std-devel.sha256sum] = "eab3ab055f551349e643fe82fd73f90a5dd4622876becf204c02186c8d4e925e"

URI_x86_64_v2_rust-unicode-width0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width0.1-devel-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-width0.1-devel}"
SRC_URI[x86_64_v2_rust-unicode-width0.1-devel.sha256sum] = "1b90665aa2b587cf3ee32a679be354bd208f4da4c3d269323c7a2ae210ed255c"

URI_aarch64_rust-unicode-width0.1+cjk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width0.1+cjk-devel-0.1.14-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-width0.1+cjk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-width0.1+cjk-devel}"
SRC_URI[aarch64_rust-unicode-width0.1+cjk-devel.sha256sum] = "e0237387c4fd5e3734839dc94fced4ba9a4b0d4425f09ab172e372f0bad72c08"

URI_aarch64_rust-unicode-width0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width0.1+default-devel-0.1.14-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-width0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-width0.1+default-devel}"
SRC_URI[aarch64_rust-unicode-width0.1+default-devel.sha256sum] = "19ad7430a10798bc2e3ee9c668532e1612dc5ccc5e8c4113e8c73fe696433887"
RPROVIDES:rust-unicode-width0.1+default-devel:append:aarch64 = " virtual/crate_unicode-width/default__ge_0.0.0_with_crate_unicode-width/default__lt_1.0.0~ virtual/crate_unicode-width/default__ge_0.1.0_with_crate_unicode-width/default__lt_0.3.0~"

URI_aarch64_rust-unicode-width0.1+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width0.1+no_std-devel-0.1.14-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-width0.1+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-width0.1+no_std-devel}"
SRC_URI[aarch64_rust-unicode-width0.1+no_std-devel.sha256sum] = "70ac382506bf3233a8d01a29e797e9ba79ad92184d5eb384bec71e6b2c577c5a"

URI_aarch64_rust-unicode-width0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width0.1-devel-0.1.14-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-width0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-width0.1-devel}"
SRC_URI[aarch64_rust-unicode-width0.1-devel.sha256sum] = "81409f0b18be1d9b68a53c78739bb9c5cfb34245ee4c4b78b0e2c4a2e13d8f0b"

RDEPENDS:rust-unicode-width0.1+cjk-devel = " \
 cargo \
 rust-unicode-width0.1-devel \
 "
RDEPENDS:rust-unicode-width0.1+default-devel = " \
 cargo \
 rust-unicode-width0.1+cjk-devel \
 rust-unicode-width0.1-devel \
 "
RDEPENDS:rust-unicode-width0.1+no_std-devel = " \
 cargo \
 rust-unicode-width0.1-devel \
 "
RDEPENDS:rust-unicode-width0.1-devel = " \
 cargo \
 "
