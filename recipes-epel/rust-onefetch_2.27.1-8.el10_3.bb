# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch"
PV = "2.27.1"
PR = "8.el10_3"
PACKAGES = " \
 onefetch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-2.27.1-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38738c2494fb64203aaa6340c8b2809d719949b576d7a214034a571796765438"

URI_x86_64_v2_onefetch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/onefetch-2.27.1-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_onefetch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_onefetch}"
SRC_URI[x86_64_v2_onefetch.sha256sum] = "02d913ea5a05681dcfc6b3cd963ad1b660714c9c6ff8b3645ab23884058f362c"

URI_aarch64_onefetch = "${EPEL_MIRROR}/aarch64/Packages/o/onefetch-2.27.1-8.el10_3.aarch64.rpm;name=aarch64_onefetch;unpack=0"
SRC_URI:append = " ${URI_aarch64_onefetch}"
SRC_URI[aarch64_onefetch.sha256sum] = "c47ddde9e0643a214e5012f16848180289d5a61c6dd0ccea5d2cc070eef61ecd"

RDEPENDS:onefetch = " \
 glibc \
 libgcc \
 libzstd \
 "
