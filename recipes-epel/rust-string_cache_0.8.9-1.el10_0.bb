# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-string_cache"
PV = "0.8.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-string_cache+default-devel \
 rust-string_cache+serde-devel \
 rust-string_cache+serde_support-devel \
 rust-string_cache-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-string_cache-0.8.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a4c94be5ea1e17ebfb9ac9fdb9c8f4099fc7263387c6544ff99818631e2f1ed"

URI_x86_64_v2_rust-string_cache+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache+default-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache+default-devel}"
SRC_URI[x86_64_v2_rust-string_cache+default-devel.sha256sum] = "97cf623b87698ed17f3d336dbf66df9bd2bcde16be9947c86345a729c512befb"

URI_x86_64_v2_rust-string_cache+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache+serde-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache+serde-devel}"
SRC_URI[x86_64_v2_rust-string_cache+serde-devel.sha256sum] = "e966a92ea4684264344f7585fb64245bb3b2eed1c32cd634abf758aa9f817482"

URI_x86_64_v2_rust-string_cache+serde_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache+serde_support-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache+serde_support-devel}"
SRC_URI[x86_64_v2_rust-string_cache+serde_support-devel.sha256sum] = "a2ce08b8a12e8884bd0d88c6d69d37671ca2170144375ff4fb9e0a5418fb6b97"

URI_x86_64_v2_rust-string_cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache-devel}"
SRC_URI[x86_64_v2_rust-string_cache-devel.sha256sum] = "951018464170d309679011d501f614e8194e26417a4aa12e045d180cceecd7af"

URI_aarch64_rust-string_cache+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache+default-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-string_cache+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache+default-devel}"
SRC_URI[aarch64_rust-string_cache+default-devel.sha256sum] = "7334136356a89810f979f4a796092f3e1016cfcd5512fdd7716bd0e6b0d4970a"

URI_aarch64_rust-string_cache+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache+serde-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-string_cache+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache+serde-devel}"
SRC_URI[aarch64_rust-string_cache+serde-devel.sha256sum] = "74d4683ff4ae81b2a23a51f63b71b7af751b096e590374f94a1c224febb9024a"

URI_aarch64_rust-string_cache+serde_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache+serde_support-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-string_cache+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache+serde_support-devel}"
SRC_URI[aarch64_rust-string_cache+serde_support-devel.sha256sum] = "b051d5e35f7342b74de6a104425dcddd0886293069edcfa7bae522fa9e77a376"

URI_aarch64_rust-string_cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-string_cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache-devel}"
SRC_URI[aarch64_rust-string_cache-devel.sha256sum] = "791cdcf7e04d4825968e356fa19a46b8a19855cda6bf6fef44dac77f9e41e422"

RDEPENDS:rust-string_cache+default-devel = " \
 cargo \
 rust-string_cache+serde_support-devel \
 rust-string_cache-devel \
 "
RDEPENDS:rust-string_cache+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-string_cache-devel \
 "
RDEPENDS:rust-string_cache+serde_support-devel = " \
 cargo \
 rust-string_cache+serde-devel \
 rust-string_cache-devel \
 "
RDEPENDS:rust-string_cache-devel = " \
 cargo \
 rust \
 rust-new_debug_unreachable+default-devel \
 rust-parking_lot+default-devel \
 rust-phf_shared+default-devel \
 rust-precomputed-hash+default-devel \
 "
