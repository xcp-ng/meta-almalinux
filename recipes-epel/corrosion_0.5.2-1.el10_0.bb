# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "corrosion"
PV = "0.5.2"
PR = "1.el10_0"
PACKAGES = " \
 corrosion \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/corrosion-0.5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7d75c7ad43c2fdc55429564e94759fd57c6b259d10269dc5e2ceec2778fcf0ab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/corrosion-0.5.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_corrosion;unpack=0"
SRC_URI[x86_64_v2_corrosion.sha256sum] = "bc6ba870a4b9a723fa839eab0bb91d2c38c394f8cb8c36577af4b758e13df04c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/corrosion-0.5.2-1.el10_0.aarch64.rpm;name=aarch64_corrosion;unpack=0"
SRC_URI[aarch64_corrosion.sha256sum] = "cf0dd407a9b36809025418eb9307ba50299f461403b23c6b3784b43bdadb60aa"

RDEPENDS:corrosion = " \
 cmake \
 cmake-filesystem \
 glibc \
 libgcc \
 "
