# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sdd"
PV = "3.0.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-sdd+default-devel \
 rust-sdd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sdd-3.0.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "400ed0d10bc8bce1111756fc5a8d3818da97f47e1333f8839b18f0efc34be904"

URI_x86_64_v2_rust-sdd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sdd+default-devel-3.0.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sdd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sdd+default-devel}"
SRC_URI[x86_64_v2_rust-sdd+default-devel.sha256sum] = "16aa693288dfe7f82985c3e98330424bfc86fd233b938693891d3d51a7b089f4"

URI_x86_64_v2_rust-sdd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sdd-devel-3.0.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sdd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sdd-devel}"
SRC_URI[x86_64_v2_rust-sdd-devel.sha256sum] = "37dbc9b189ce9e8162e1a0ce167f0f79c4ac5e114662ab873b587e0af49a4e93"

URI_aarch64_rust-sdd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sdd+default-devel-3.0.10-1.el10_0.noarch.rpm;name=aarch64_rust-sdd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sdd+default-devel}"
SRC_URI[aarch64_rust-sdd+default-devel.sha256sum] = "f781e5d7389099a70fac8a5b858b58f230367a2cfbef0747b03f9fe85888b48d"

URI_aarch64_rust-sdd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sdd-devel-3.0.10-1.el10_0.noarch.rpm;name=aarch64_rust-sdd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sdd-devel}"
SRC_URI[aarch64_rust-sdd-devel.sha256sum] = "64abf319fd41ddc259c0cb8f6dcf4fbb3f85a2aea6900962e3725ba7f8f08107"

RDEPENDS:rust-sdd+default-devel = " \
 cargo \
 rust-sdd-devel \
 "
RDEPENDS:rust-sdd-devel = " \
 cargo \
 rust \
 "
