# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexopt"
PV = "0.3.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-lexopt+default-devel \
 rust-lexopt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexopt-0.3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb808b1e246b76a283e3aa6b25d19a2884afcfd8e8ef8af9274f57fd85ff6431"

URI_x86_64_v2_rust-lexopt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexopt+default-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexopt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexopt+default-devel}"
SRC_URI[x86_64_v2_rust-lexopt+default-devel.sha256sum] = "f6347c05dda9a5f17f2916ed7c3b4bf3bbc51d8b67974597a8e4f470085e1423"

URI_x86_64_v2_rust-lexopt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexopt-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexopt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexopt-devel}"
SRC_URI[x86_64_v2_rust-lexopt-devel.sha256sum] = "72e8761bb5262677c16388132aa254598f88d0fb2bb59811b104f91738d05d39"

URI_aarch64_rust-lexopt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexopt+default-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-lexopt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexopt+default-devel}"
SRC_URI[aarch64_rust-lexopt+default-devel.sha256sum] = "2cc030f4347cb5e9c55ce16df0d4da13427b2c5bfb2bd662ca5205403575061d"

URI_aarch64_rust-lexopt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexopt-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-lexopt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexopt-devel}"
SRC_URI[aarch64_rust-lexopt-devel.sha256sum] = "d454038f6f8e3877be37494acdc10b95b0c9d19e3fadc60c3b4dc92dfb958d88"

RDEPENDS:rust-lexopt+default-devel = " \
 cargo \
 rust-lexopt-devel \
 "
RDEPENDS:rust-lexopt-devel = " \
 cargo \
 "
