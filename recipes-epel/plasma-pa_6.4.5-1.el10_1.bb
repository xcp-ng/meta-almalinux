# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-pa"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 plasma-pa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-pa-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb8a63a16ae2b5db948596790802843c84083155c87243f4952a063e011fa796"

URI_x86_64_v2_plasma-pa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-pa-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-pa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-pa}"
SRC_URI[x86_64_v2_plasma-pa.sha256sum] = "605ddabed3fe6e3a1be1aa2a5ab29ca9ba082d6a13f12d88473e2f3f692afc43"

URI_aarch64_plasma-pa = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-pa-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-pa;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-pa}"
SRC_URI[aarch64_plasma-pa.sha256sum] = "5d1d44c75204b91dd27b5fcf851c6e77e9ed824574149658935dc7b084b2a0a9"

RDEPENDS:plasma-pa = " \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kstatusnotifieritem \
 libcanberra \
 libplasma \
 libstdc++ \
 pipewire-pulseaudio \
 pulseaudio-libs \
 pulseaudio-qt-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
