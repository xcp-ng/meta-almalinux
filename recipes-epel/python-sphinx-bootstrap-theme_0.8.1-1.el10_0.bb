# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-bootstrap-theme"
PV = "0.8.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-sphinx-bootstrap-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-bootstrap-theme-0.8.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47612c3c284ffc42d12cd89528efee90acfe521a5fe804bf701301faa3963994"

URI_x86_64_v2_python3-sphinx-bootstrap-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-bootstrap-theme-0.8.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-bootstrap-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-bootstrap-theme}"
SRC_URI[x86_64_v2_python3-sphinx-bootstrap-theme.sha256sum] = "ec807471acfc490776240a54e11aaffe2f34609d49679bdbcd7b659563191b13"

URI_aarch64_python3-sphinx-bootstrap-theme = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-bootstrap-theme-0.8.1-1.el10_0.noarch.rpm;name=aarch64_python3-sphinx-bootstrap-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-bootstrap-theme}"
SRC_URI[aarch64_python3-sphinx-bootstrap-theme.sha256sum] = "6d23d9db3859a363a34c743453c87ae0497741c2a1454b3a1734544b885f375b"

RDEPENDS:python3-sphinx-bootstrap-theme = " \
 python3 \
 python3-sphinx \
 web-assets-filesystem \
 "
