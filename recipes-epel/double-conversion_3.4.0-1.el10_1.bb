# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "double-conversion"
PV = "3.4.0"
PR = "1.el10_1"
PACKAGES = " \
 double-conversion \
 double-conversion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/double-conversion-3.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04aa7ca1d3265f371225548aef2b7a035753299bf2c8c0a7fd2c21b6d7fb16f0"

URI_x86_64_v2_double-conversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/double-conversion-3.4.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_double-conversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_double-conversion}"
SRC_URI[x86_64_v2_double-conversion.sha256sum] = "30d2dc2120a637c55026d7390585f1a4494558a05e7b88d082a3558fa8fdfee0"

URI_x86_64_v2_double-conversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/double-conversion-devel-3.4.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_double-conversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_double-conversion-devel}"
SRC_URI[x86_64_v2_double-conversion-devel.sha256sum] = "fccaee7b148756614ac7dff4bcd4004d0b78cfb185d374ab7ab0d7336b486dc2"

URI_aarch64_double-conversion = "${EPEL_MIRROR}/aarch64/Packages/d/double-conversion-3.4.0-1.el10_1.aarch64.rpm;name=aarch64_double-conversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_double-conversion}"
SRC_URI[aarch64_double-conversion.sha256sum] = "34e705e046787ce4c5ff3f1853d31159561a4bef811f471fccb15d49f2c886e6"

URI_aarch64_double-conversion-devel = "${EPEL_MIRROR}/aarch64/Packages/d/double-conversion-devel-3.4.0-1.el10_1.aarch64.rpm;name=aarch64_double-conversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_double-conversion-devel}"
SRC_URI[aarch64_double-conversion-devel.sha256sum] = "93e4467d2dbfdfbfad93dd7f5a9ae0e8c747e25546f5afa53fccb31643949aa6"

RDEPENDS:double-conversion = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:double-conversion-devel = " \
 cmake-filesystem \
 double-conversion \
 pkgconf-pkg-config \
 "
