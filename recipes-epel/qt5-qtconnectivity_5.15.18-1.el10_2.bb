# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtconnectivity"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtconnectivity \
 qt5-qtconnectivity-devel \
 qt5-qtconnectivity-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtconnectivity-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c96dfb9df2b4cefc106a1e98f30ba9ecfaf3b39b1efdbb55b62aacfdd5ff5cce"

URI_x86_64_v2_qt5-qtconnectivity = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtconnectivity-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtconnectivity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtconnectivity}"
SRC_URI[x86_64_v2_qt5-qtconnectivity.sha256sum] = "89425760a3f1aee959811fe45e852738fb6e905741ce588179ee3f28c2a63431"

URI_x86_64_v2_qt5-qtconnectivity-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtconnectivity-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtconnectivity-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtconnectivity-devel}"
SRC_URI[x86_64_v2_qt5-qtconnectivity-devel.sha256sum] = "ad065591813bc087a6656b20210238821fe1d60995d4737f76572f4960268c72"

URI_x86_64_v2_qt5-qtconnectivity-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtconnectivity-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtconnectivity-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtconnectivity-examples}"
SRC_URI[x86_64_v2_qt5-qtconnectivity-examples.sha256sum] = "ab8254a3655f1b47f06c574e295c0e4e7965b417d7aac79a9a827e6d2e36973d"

URI_aarch64_qt5-qtconnectivity = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtconnectivity-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtconnectivity;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtconnectivity}"
SRC_URI[aarch64_qt5-qtconnectivity.sha256sum] = "7a6498bb2f265e6249f21651ee81a878fc6fd2e83a5fdcd64e7995ecbf175fca"

URI_aarch64_qt5-qtconnectivity-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtconnectivity-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtconnectivity-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtconnectivity-devel}"
SRC_URI[aarch64_qt5-qtconnectivity-devel.sha256sum] = "7029fd62a4030b419d9a05e0ef7aad6ae9e6c9cd9ff476bd651d40c4275e5582"

URI_aarch64_qt5-qtconnectivity-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtconnectivity-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtconnectivity-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtconnectivity-examples}"
SRC_URI[aarch64_qt5-qtconnectivity-examples.sha256sum] = "6c3f1d38fa635a334aea9b6ff9ee6fccdc89023c1ac353b0eb1b5674711f38dc"

RDEPENDS:qt5-qtconnectivity = " \
 bluez-libs \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtconnectivity-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtconnectivity \
 "
RDEPENDS:qt5-qtconnectivity-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtconnectivity \
 qt5-qtdeclarative \
 "
