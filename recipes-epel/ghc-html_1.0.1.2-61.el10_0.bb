# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-html"
PV = "1.0.1.2"
PR = "61.el10_0"
PACKAGES = " \
 ghc-html \
 ghc-html-devel \
 ghc-html-doc \
 ghc-html-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-html-1.0.1.2-61.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b63f856d7af20d7f6456c07811cb235c93e2aa22af3ab9d9e72089913f4f6e6"

URI_x86_64_v2_ghc-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-html-1.0.1.2-61.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-html}"
SRC_URI[x86_64_v2_ghc-html.sha256sum] = "b45bd478924114e33ade880f2b66ef327e59056e9d43b2ce359e548f8d5fa402"

URI_x86_64_v2_ghc-html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-html-devel-1.0.1.2-61.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-html-devel}"
SRC_URI[x86_64_v2_ghc-html-devel.sha256sum] = "dc017896a3de5c0df50b37d2bc7ab1a7c4328c1b0e85013821cfb172716fcded"

URI_x86_64_v2_ghc-html-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-html-doc-1.0.1.2-61.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-html-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-html-doc}"
SRC_URI[x86_64_v2_ghc-html-doc.sha256sum] = "e9a37dd3ef2d7f8993a9234a1a5a4032639aee66fd02b8fe8e16c74c354cee1d"

URI_x86_64_v2_ghc-html-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-html-prof-1.0.1.2-61.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-html-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-html-prof}"
SRC_URI[x86_64_v2_ghc-html-prof.sha256sum] = "fd0edf96debab275775003e03499fab7abc092ad01bc635184724a8b7c82ea4e"

URI_aarch64_ghc-html = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-html-1.0.1.2-61.el10_0.aarch64.rpm;name=aarch64_ghc-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-html}"
SRC_URI[aarch64_ghc-html.sha256sum] = "81b8051c1dfd2cc12f14d820227b2f0b3a032db65bfe5f464db23f8d81582ce9"

URI_aarch64_ghc-html-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-html-devel-1.0.1.2-61.el10_0.aarch64.rpm;name=aarch64_ghc-html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-html-devel}"
SRC_URI[aarch64_ghc-html-devel.sha256sum] = "e424a901cf3472964213e45f27880c8682a6fc1e36f8a4d0758a31e5852a4e76"

URI_aarch64_ghc-html-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-html-doc-1.0.1.2-61.el10_0.noarch.rpm;name=aarch64_ghc-html-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-html-doc}"
SRC_URI[aarch64_ghc-html-doc.sha256sum] = "6cefc638d865713118c6b2883225e31407d444b65098b14eec92482cb9b4e4c9"

URI_aarch64_ghc-html-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-html-prof-1.0.1.2-61.el10_0.aarch64.rpm;name=aarch64_ghc-html-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-html-prof}"
SRC_URI[aarch64_ghc-html-prof.sha256sum] = "67c4df319dada463b858050fde146d33a6fca5746ace66a419bc575dc3a0eedd"

RDEPENDS:ghc-html = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-html-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-html \
 "
RDEPENDS:ghc-html-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-html-prof = " \
 ghc-base-prof \
 ghc-html-devel \
 "
