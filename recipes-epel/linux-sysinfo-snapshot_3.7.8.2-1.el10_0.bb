# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linux-sysinfo-snapshot"
PV = "3.7.8.2"
PR = "1.el10_0"
PACKAGES = " \
 linux-sysinfo-snapshot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/linux-sysinfo-snapshot-3.7.8.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2534038106bed50a6f3a71a44cd4b596ab4618c3c42e08362155fc3fe170ec4"

URI_x86_64_v2_linux-sysinfo-snapshot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/linux-sysinfo-snapshot-3.7.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_linux-sysinfo-snapshot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linux-sysinfo-snapshot}"
SRC_URI[x86_64_v2_linux-sysinfo-snapshot.sha256sum] = "78452e87f2f2cf8f33ab1db5ef95df8a008a3957b4d29bef4e471667607705f4"

URI_aarch64_linux-sysinfo-snapshot = "${EPEL_MIRROR}/aarch64/Packages/l/linux-sysinfo-snapshot-3.7.8.2-1.el10_0.noarch.rpm;name=aarch64_linux-sysinfo-snapshot;unpack=0"
SRC_URI:append = " ${URI_aarch64_linux-sysinfo-snapshot}"
SRC_URI[aarch64_linux-sysinfo-snapshot.sha256sum] = "64caf042ce05ad872b2578593167d5bef411911e5cacdb5986045514235e949b"

RDEPENDS:linux-sysinfo-snapshot = " \
 python3 \
 python3-setuptools \
 "
