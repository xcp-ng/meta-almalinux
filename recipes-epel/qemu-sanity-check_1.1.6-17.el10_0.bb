# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qemu-sanity-check"
PV = "1.1.6"
PR = "17.el10_0"
PACKAGES = " \
 qemu-sanity-check \
 qemu-sanity-check-nodeps \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qemu-sanity-check-1.1.6-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b225f7d56acc5208dbc90f2a0340eeb1872db8f813690d66e189b48c68dd3368"

URI_x86_64_v2_qemu-sanity-check = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qemu-sanity-check-1.1.6-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qemu-sanity-check;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-sanity-check}"
SRC_URI[x86_64_v2_qemu-sanity-check.sha256sum] = "e652167ba802864966d0edbb131bb86713875739b2e7ef700f51b0f09298a391"

URI_x86_64_v2_qemu-sanity-check-nodeps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qemu-sanity-check-nodeps-1.1.6-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qemu-sanity-check-nodeps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-sanity-check-nodeps}"
SRC_URI[x86_64_v2_qemu-sanity-check-nodeps.sha256sum] = "ac12ae62d8cd4df4f7652337516bd6618b7ca4d23ec6f34813526f88c6cd35e0"

URI_aarch64_qemu-sanity-check = "${EPEL_MIRROR}/aarch64/Packages/q/qemu-sanity-check-1.1.6-17.el10_0.aarch64.rpm;name=aarch64_qemu-sanity-check;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-sanity-check}"
SRC_URI[aarch64_qemu-sanity-check.sha256sum] = "470179ee54aa5e3babdbef52b488c407c099ec6735d5a3a1b1c62984a3ec28dc"

URI_aarch64_qemu-sanity-check-nodeps = "${EPEL_MIRROR}/aarch64/Packages/q/qemu-sanity-check-nodeps-1.1.6-17.el10_0.aarch64.rpm;name=aarch64_qemu-sanity-check-nodeps;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-sanity-check-nodeps}"
SRC_URI[aarch64_qemu-sanity-check-nodeps.sha256sum] = "b8e21fd2c98de5843d2a81002b47fa0f2b7d830b0c969db57d97f2833c347ca9"

RDEPENDS:qemu-sanity-check = " \
 qemu-kvm \
 qemu-sanity-check-nodeps \
 virtual/kernel \
 "
RDEPENDS:qemu-sanity-check-nodeps = " \
 bash \
 "
