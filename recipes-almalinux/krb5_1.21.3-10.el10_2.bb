# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krb5"
PV = "1.21.3"
PR = "10.el10_2"
PACKAGES = " \
 krb5-devel \
 krb5-libs \
 krb5-pkinit \
 krb5-server \
 krb5-server-ldap \
 krb5-workstation \
 krb5-xrealmauthz \
 libkadm5 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/krb5-1.21.3-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbc4e32dd992727dd174d45f4a6ca2a7a4bb4948d03328aaada33101c9705696"

URI_x86_64_v2_krb5-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/krb5-devel-1.21.3-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_krb5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-devel}"
SRC_URI[x86_64_v2_krb5-devel.sha256sum] = "8f3c574a5d5fdfce6a2b6942cd48c9268a8882f0ac2d18f7976b3aa6b42fbe11"

URI_x86_64_v2_krb5-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-libs-1.21.3-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_krb5-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-libs}"
SRC_URI[x86_64_v2_krb5-libs.sha256sum] = "775049ae7f1bfdb95c805f419fb79689d69c9ca44722ec5043706b0674b2a855"

URI_x86_64_v2_krb5-pkinit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-pkinit-1.21.3-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_krb5-pkinit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-pkinit}"
SRC_URI[x86_64_v2_krb5-pkinit.sha256sum] = "91a54a2dae768a3200424b85ea639098bd826c90f7dc0e04e4140c9b194fb155"

URI_x86_64_v2_krb5-server = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-server-1.21.3-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_krb5-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-server}"
SRC_URI[x86_64_v2_krb5-server.sha256sum] = "24dd3e7f310c74519dcd8645b57577acdcff41c4acc08021b23eba2e31fed0ce"

URI_x86_64_v2_krb5-server-ldap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-server-ldap-1.21.3-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_krb5-server-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-server-ldap}"
SRC_URI[x86_64_v2_krb5-server-ldap.sha256sum] = "0a7039b8e7222d545a2dbcecc4c7160f1bc3e815001d67df4fc25cdc3505e4a5"

URI_x86_64_v2_krb5-workstation = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-workstation-1.21.3-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_krb5-workstation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-workstation}"
SRC_URI[x86_64_v2_krb5-workstation.sha256sum] = "f0f050e9e8288ae18dc2ee1cd0ba77fbc9bead946c4e5d8be8f6454687affdaa"

URI_x86_64_v2_krb5-xrealmauthz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-xrealmauthz-1.21.3-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_krb5-xrealmauthz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-xrealmauthz}"
SRC_URI[x86_64_v2_krb5-xrealmauthz.sha256sum] = "953f862986b8ca04ff05f552db5d05c401c326456f56ec9820c3fe708adaf047"

URI_x86_64_v2_libkadm5 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libkadm5-1.21.3-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_libkadm5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkadm5}"
SRC_URI[x86_64_v2_libkadm5.sha256sum] = "6d361ebc941439bca70140cb603402c043fb03fa1a674f57080cb513f1448a2d"

URI_aarch64_krb5-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/krb5-devel-1.21.3-10.el10_2.aarch64.rpm;name=aarch64_krb5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-devel}"
SRC_URI[aarch64_krb5-devel.sha256sum] = "f5c5d16fdc0f9921f40fa48c89a561db089ac4c39bb78917d27768d4e00c9dd2"

URI_aarch64_krb5-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-libs-1.21.3-10.el10_2.aarch64.rpm;name=aarch64_krb5-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-libs}"
SRC_URI[aarch64_krb5-libs.sha256sum] = "a6bd66ee0fbb1744667175e3312bd7e30b344ad35b9fe9be53f5382e399546fa"

URI_aarch64_krb5-pkinit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-pkinit-1.21.3-10.el10_2.aarch64.rpm;name=aarch64_krb5-pkinit;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-pkinit}"
SRC_URI[aarch64_krb5-pkinit.sha256sum] = "b3f1dff86c7548ed49a00376e4ed6d0d9956b19b4514df0d17eacc9e09765732"

URI_aarch64_krb5-server = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-server-1.21.3-10.el10_2.aarch64.rpm;name=aarch64_krb5-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-server}"
SRC_URI[aarch64_krb5-server.sha256sum] = "2f6f1ae38b93c4b3456de791e596437a694fe46c77c736ef5caa108148bcba28"

URI_aarch64_krb5-server-ldap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-server-ldap-1.21.3-10.el10_2.aarch64.rpm;name=aarch64_krb5-server-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-server-ldap}"
SRC_URI[aarch64_krb5-server-ldap.sha256sum] = "5c6f0a523afe6deae7248a6aa0977cb4d03f7433fb8971763acf9e6849e45910"

URI_aarch64_krb5-workstation = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-workstation-1.21.3-10.el10_2.aarch64.rpm;name=aarch64_krb5-workstation;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-workstation}"
SRC_URI[aarch64_krb5-workstation.sha256sum] = "96eff6cfa700f8f0438b06953874fa29c21d9c3c277f37992ae781d167cf1a86"

URI_aarch64_krb5-xrealmauthz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-xrealmauthz-1.21.3-10.el10_2.aarch64.rpm;name=aarch64_krb5-xrealmauthz;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-xrealmauthz}"
SRC_URI[aarch64_krb5-xrealmauthz.sha256sum] = "539e9600b3a7e3c76271c1caf3b9a59a2565e7619fb9c2da6520747990b82531"

URI_aarch64_libkadm5 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libkadm5-1.21.3-10.el10_2.aarch64.rpm;name=aarch64_libkadm5;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkadm5}"
SRC_URI[aarch64_libkadm5.sha256sum] = "2f904be738fd72c1ec3230da321390a42adb7b64f9765ae5c74fbf4699825199"

RDEPENDS:krb5-devel = " \
 bash \
 keyutils-libs-devel \
 krb5-devel \
 krb5-libs \
 libcom_err-devel \
 libkadm5 \
 libselinux-devel \
 libverto-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:krb5-libs = " \
 crypto-policies \
 gawk \
 glibc \
 keyutils-libs \
 libcom_err \
 libselinux \
 libverto \
 openssl-libs \
 sed \
 virtual/coreutils \
 "
RDEPENDS:krb5-pkinit = " \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 openssl-libs \
 "
RDEPENDS:krb5-server = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 krb5-pkinit \
 libcom_err \
 libkadm5 \
 libselinux \
 libss \
 libverto \
 libverto-libev \
 lmdb-libs \
 logrotate \
 openssl-libs \
 systemd \
 words \
 "
RDEPENDS:krb5-server-ldap = " \
 glibc \
 keyutils-libs \
 krb5-libs \
 krb5-server \
 libcom_err \
 libkadm5 \
 openldap \
 openssl-libs \
 "
RDEPENDS:krb5-workstation = " \
 bash \
 glibc \
 krb5-libs \
 krb5-pkinit \
 libcom_err \
 libkadm5 \
 libss \
 pam-libs \
 "
RDEPENDS:krb5-xrealmauthz = " \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 libselinux \
 openssl-libs \
 "
RDEPENDS:libkadm5 = " \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 openssl-libs \
 "
