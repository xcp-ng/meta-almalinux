# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-lite"
PV = "0.1.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-regex-lite+default-devel \
 rust-regex-lite+std-devel \
 rust-regex-lite+string-devel \
 rust-regex-lite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-lite-0.1.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e095c59e29f11cef71228bf7422ef23bab09d51c2ec7bd8e6d27629efa6cf838"

URI_x86_64_v2_rust-regex-lite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-lite+default-devel-0.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-lite+default-devel}"
SRC_URI[x86_64_v2_rust-regex-lite+default-devel.sha256sum] = "3e4e488c4dfc1e5718fd1f38360de16abab339b8cf33636871927d87eef10234"

URI_x86_64_v2_rust-regex-lite+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-lite+std-devel-0.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-lite+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-lite+std-devel}"
SRC_URI[x86_64_v2_rust-regex-lite+std-devel.sha256sum] = "618a131e2598caf07f4ebdd16ee5e72b96910f563f6e275d9f5af14546b4e779"

URI_x86_64_v2_rust-regex-lite+string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-lite+string-devel-0.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-lite+string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-lite+string-devel}"
SRC_URI[x86_64_v2_rust-regex-lite+string-devel.sha256sum] = "0cb43082d0f1a24ca5c7a891872cb8aea0f191388caefe599ee9b76cffda0c2e"

URI_x86_64_v2_rust-regex-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-lite-devel-0.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-lite-devel}"
SRC_URI[x86_64_v2_rust-regex-lite-devel.sha256sum] = "d4a50a87e91b2b7fa88e22681cd8afc2e40ab8405eebf5fde3fcee1c1239b493"

URI_aarch64_rust-regex-lite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-lite+default-devel-0.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-regex-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-lite+default-devel}"
SRC_URI[aarch64_rust-regex-lite+default-devel.sha256sum] = "525febcfb6a4ea49809045ceb308d4c25791376bdd57d6b8e94b526f77d9ecf3"

URI_aarch64_rust-regex-lite+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-lite+std-devel-0.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-regex-lite+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-lite+std-devel}"
SRC_URI[aarch64_rust-regex-lite+std-devel.sha256sum] = "c54a7a198e6f17c6f5bc09fa322e68f3a40bd6db1334c551fb9402d1cb976250"

URI_aarch64_rust-regex-lite+string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-lite+string-devel-0.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-regex-lite+string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-lite+string-devel}"
SRC_URI[aarch64_rust-regex-lite+string-devel.sha256sum] = "ec327f8242cd5a5fbdfe567bdcea0547bb42359e3aca7ad3f581bf32b6a1ff87"

URI_aarch64_rust-regex-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-lite-devel-0.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-regex-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-lite-devel}"
SRC_URI[aarch64_rust-regex-lite-devel.sha256sum] = "2a5ea999909082f5e9fb135516ba5e78e8aca7a659013d8c26dfe2ab10c7e5b4"

RDEPENDS:rust-regex-lite+default-devel = " \
 cargo \
 rust-regex-lite+std-devel \
 rust-regex-lite+string-devel \
 rust-regex-lite-devel \
 "
RDEPENDS:rust-regex-lite+std-devel = " \
 cargo \
 rust-regex-lite-devel \
 "
RDEPENDS:rust-regex-lite+string-devel = " \
 cargo \
 rust-regex-lite-devel \
 "
RDEPENDS:rust-regex-lite-devel = " \
 cargo \
 rust \
 "
