# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "docbook-style-xsl"
PV = "1.79.2"
PR = "28.el10_0"
PACKAGES = " \
 docbook-style-xsl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/docbook-style-xsl-1.79.2-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59865e5744bd444fe2656b9dc684038419a2e713abb81687226d943ceaeb95dd"

URI_x86_64_v2_docbook-style-xsl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/docbook-style-xsl-1.79.2-28.el10_0.noarch.rpm;name=x86_64_v2_docbook-style-xsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_docbook-style-xsl}"
SRC_URI[x86_64_v2_docbook-style-xsl.sha256sum] = "0b3abfed4089a673894ec586c20b2ef5de05c038f56190f7a124aaa9751c6513"

URI_aarch64_docbook-style-xsl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/docbook-style-xsl-1.79.2-28.el10_0.noarch.rpm;name=aarch64_docbook-style-xsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_docbook-style-xsl}"
SRC_URI[aarch64_docbook-style-xsl.sha256sum] = "0b3abfed4089a673894ec586c20b2ef5de05c038f56190f7a124aaa9751c6513"

RDEPENDS:docbook-style-xsl = " \
 bash \
 docbook-dtds \
 libxml2 \
 xml-common \
 "
