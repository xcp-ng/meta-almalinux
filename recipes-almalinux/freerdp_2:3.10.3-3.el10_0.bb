# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freerdp"
PE = "2"
PV = "3.10.3"
PR = "3.el10_0"
PACKAGES = " \
 freerdp \
 freerdp-devel \
 freerdp-libs \
 freerdp-server \
 libwinpr \
 libwinpr-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freerdp-3.10.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd282b2d3af2630de35e4859db972c14fd3fc0354a11457aad8dec26eb9e1bc6"

URI_x86_64_v2_freerdp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freerdp-3.10.3-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_freerdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp}"
SRC_URI[x86_64_v2_freerdp.sha256sum] = "3aa1857c2329cd6b4f5cbdf12b330bda22fa20d92194c4601ab666a100e0fc3a"

URI_x86_64_v2_freerdp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freerdp-devel-3.10.3-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_freerdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp-devel}"
SRC_URI[x86_64_v2_freerdp-devel.sha256sum] = "a216440a8057f80c8b512c58af571c398e6410b129eaa505e04c41dd705b53ad"

URI_x86_64_v2_freerdp-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freerdp-libs-3.10.3-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_freerdp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp-libs}"
SRC_URI[x86_64_v2_freerdp-libs.sha256sum] = "93045ccd30de1262c9f7d8c7a3e816e434ec88cc5522b1f46ab4d988b8965e65"

URI_x86_64_v2_freerdp-server = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freerdp-server-3.10.3-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_freerdp-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp-server}"
SRC_URI[x86_64_v2_freerdp-server.sha256sum] = "5ae7a1fea44090c0fb13ba28776cbd828eadac8a476bfb87d0b7d3661c916da6"

URI_x86_64_v2_libwinpr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwinpr-3.10.3-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_libwinpr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwinpr}"
SRC_URI[x86_64_v2_libwinpr.sha256sum] = "4633824bd3706d4c456c7aebe5174c59e59ad4acf5e93f729d603251329e33c2"

URI_x86_64_v2_libwinpr-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwinpr-devel-3.10.3-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_libwinpr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwinpr-devel}"
SRC_URI[x86_64_v2_libwinpr-devel.sha256sum] = "07ca073e7e6254db4ebe413269c4b087d9a791903d29d20bdd3fc8da9d2be549"

URI_aarch64_freerdp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freerdp-3.10.3-3.el10_0.aarch64.rpm;name=aarch64_freerdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp}"
SRC_URI[aarch64_freerdp.sha256sum] = "b645b7621dc09e82c96d3a5d3a719ce6321d5fb420589a0299a0342cd8a1cb92"

URI_aarch64_freerdp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freerdp-devel-3.10.3-3.el10_0.aarch64.rpm;name=aarch64_freerdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp-devel}"
SRC_URI[aarch64_freerdp-devel.sha256sum] = "24fa523c074de03866b7e31a21a287abdd70021c70b8943bc4c8b396a93b8e9d"

URI_aarch64_freerdp-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freerdp-libs-3.10.3-3.el10_0.aarch64.rpm;name=aarch64_freerdp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp-libs}"
SRC_URI[aarch64_freerdp-libs.sha256sum] = "d922184ff7fdccd629b918f13452e9a263ad43eabb33a1f9e7754bd80b53b547"

URI_aarch64_freerdp-server = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freerdp-server-3.10.3-3.el10_0.aarch64.rpm;name=aarch64_freerdp-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp-server}"
SRC_URI[aarch64_freerdp-server.sha256sum] = "e7e58c3ae7757ccae01997a67cfc3ac3b02d51807c3ac7fbf6fc3519c2359bf2"

URI_aarch64_libwinpr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwinpr-3.10.3-3.el10_0.aarch64.rpm;name=aarch64_libwinpr;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwinpr}"
SRC_URI[aarch64_libwinpr.sha256sum] = "3e98ec44899ca8e819290a51f83617d58bf7ad6f785559c369360e7b9bc52bf7"

URI_aarch64_libwinpr-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwinpr-devel-3.10.3-3.el10_0.aarch64.rpm;name=aarch64_libwinpr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwinpr-devel}"
SRC_URI[aarch64_libwinpr-devel.sha256sum] = "a7e263b395b6da49b53c87b9d65a622b10b77078b78f9a172840d9495458c57a"

RDEPENDS:freerdp = " \
 freerdp-libs \
 glibc \
 libX11 \
 libXcursor \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libXrender \
 libwayland-client \
 libwayland-cursor \
 libwinpr \
 libxkbcommon \
 "
RDEPENDS:freerdp-devel = " \
 cmake \
 cmake-filesystem \
 freerdp-devel \
 freerdp-libs \
 libwinpr-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:freerdp-libs = " \
 alsa-lib \
 cairo \
 cups-libs \
 fdk-aac-free \
 fuse3-libs \
 glibc \
 gsm \
 lame-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXinerama \
 libXtst \
 libgcc \
 libstdc++ \
 libusb1 \
 libwinpr \
 libxkbfile \
 openssl-libs \
 opus \
 pam-libs \
 pulseaudio-libs \
 zlib-ng-compat \
 "
RDEPENDS:freerdp-server = " \
 freerdp-libs \
 glibc \
 libwinpr \
 "
RDEPENDS:libwinpr = " \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libicu \
 libjpeg-turbo \
 libpng \
 libwebp \
 openssl-libs \
 "
RDEPENDS:libwinpr-devel = " \
 cmake \
 cmake-filesystem \
 libwinpr \
 libwinpr-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
