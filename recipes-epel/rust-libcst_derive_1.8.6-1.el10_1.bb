# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libcst_derive"
PV = "1.8.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-libcst_derive+default-devel \
 rust-libcst_derive-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libcst_derive-1.8.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "87129818e58e196202d268999d19819275be538df8b69f4f793ee1ae5db0590a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst_derive+default-devel-1.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst_derive+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libcst_derive+default-devel.sha256sum] = "95403271a5928597c499078506fb13c457215f362a596f3624b7d5fd3261eea4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst_derive-devel-1.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst_derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libcst_derive-devel.sha256sum] = "9d24d5d4b8dcace81707dec1f1771566a2a107d40df6db91149bcb26156bccf8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst_derive+default-devel-1.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-libcst_derive+default-devel;unpack=0"
SRC_URI[aarch64_rust-libcst_derive+default-devel.sha256sum] = "1f8fa5cc6414b2dbc0c0dd46eb7f236c8876de4b3294c85a8761612fee5eec43"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst_derive-devel-1.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-libcst_derive-devel;unpack=0"
SRC_URI[aarch64_rust-libcst_derive-devel.sha256sum] = "63498c9785a3c1efacc58a6c6dec3745b6206079c913e58474884512fe5b269e"

RDEPENDS:rust-libcst_derive+default-devel = " \
 cargo \
 rust-libcst_derive-devel \
 "
RDEPENDS:rust-libcst_derive-devel = " \
 cargo \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
