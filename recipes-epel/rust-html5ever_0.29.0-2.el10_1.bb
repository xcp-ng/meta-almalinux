# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-html5ever"
PV = "0.29.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-html5ever+default-devel \
 rust-html5ever+trace_tokenizer-devel \
 rust-html5ever-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-html5ever-0.29.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a00c507fddd264429a946f4d46921572568fa6325975837b233d9835c6604c1"

URI_x86_64_v2_rust-html5ever+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever+default-devel-0.29.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever+default-devel}"
SRC_URI[x86_64_v2_rust-html5ever+default-devel.sha256sum] = "f9a146acdb7ef51d44fcc43caeffbe7357ebabfa2d5edf395649917bebfd5421"

URI_x86_64_v2_rust-html5ever+trace_tokenizer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever+trace_tokenizer-devel-0.29.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever+trace_tokenizer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever+trace_tokenizer-devel}"
SRC_URI[x86_64_v2_rust-html5ever+trace_tokenizer-devel.sha256sum] = "18cb05135e5d63f79b5afe27ede1d24cc406a1d0b069a9d655be280fdd8c6ef0"

URI_x86_64_v2_rust-html5ever-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever-devel-0.29.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever-devel}"
SRC_URI[x86_64_v2_rust-html5ever-devel.sha256sum] = "d995177bf28986055c9163e49629f86903412fc7227f12efbc8756942732b77b"

URI_aarch64_rust-html5ever+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever+default-devel-0.29.0-2.el10_1.noarch.rpm;name=aarch64_rust-html5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever+default-devel}"
SRC_URI[aarch64_rust-html5ever+default-devel.sha256sum] = "1cbfff92469ada2e3d209ca71a3751660465d6d3c8839d8d103e8ba2c313a7f5"

URI_aarch64_rust-html5ever+trace_tokenizer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever+trace_tokenizer-devel-0.29.0-2.el10_1.noarch.rpm;name=aarch64_rust-html5ever+trace_tokenizer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever+trace_tokenizer-devel}"
SRC_URI[aarch64_rust-html5ever+trace_tokenizer-devel.sha256sum] = "6adc74c2d6e2fe085f4b0b1936842660187bfe2933ff96ed9da974650fb55e70"

URI_aarch64_rust-html5ever-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever-devel-0.29.0-2.el10_1.noarch.rpm;name=aarch64_rust-html5ever-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever-devel}"
SRC_URI[aarch64_rust-html5ever-devel.sha256sum] = "300c7462f45e72316105ee88bbd351a8bedce290cb599c3ca8c1fc1d7219a3fa"

RDEPENDS:rust-html5ever+default-devel = " \
 cargo \
 rust-html5ever-devel \
 "
RDEPENDS:rust-html5ever+trace_tokenizer-devel = " \
 cargo \
 rust-html5ever-devel \
 "
RDEPENDS:rust-html5ever-devel = " \
 cargo \
 rust-log+default-devel \
 rust-mac+default-devel \
 rust-markup5ever+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 "
