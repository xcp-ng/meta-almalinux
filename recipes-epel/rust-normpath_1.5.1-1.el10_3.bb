# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-normpath"
PV = "1.5.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-normpath+default-devel \
 rust-normpath+localization-devel \
 rust-normpath+serde-devel \
 rust-normpath-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-normpath-1.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afe9830f99e198e54769d1a9bf35d09cb0b9d41277dc7fa7de19127347c23b76"

URI_x86_64_v2_rust-normpath+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath+default-devel-1.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normpath+default-devel}"
SRC_URI[x86_64_v2_rust-normpath+default-devel.sha256sum] = "1ae5b9f59e84b72bbac499a7d6fbfb6a1cf53f2be311d775af2f7dc45c94c0f2"

URI_x86_64_v2_rust-normpath+localization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath+localization-devel-1.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath+localization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normpath+localization-devel}"
SRC_URI[x86_64_v2_rust-normpath+localization-devel.sha256sum] = "e36ad1cbcad59b507e529f29f5e2b5a84a185b7d3e1509ee0c255485f753155f"

URI_x86_64_v2_rust-normpath+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath+serde-devel-1.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normpath+serde-devel}"
SRC_URI[x86_64_v2_rust-normpath+serde-devel.sha256sum] = "e79b8998f2123d47749379bb51d0333833645a651a96f4f1605ffa0e130408e7"

URI_x86_64_v2_rust-normpath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath-devel-1.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normpath-devel}"
SRC_URI[x86_64_v2_rust-normpath-devel.sha256sum] = "ff0738e43e45158e3ed18b32be6c0aff7353075b17a4125f8a6868db10a3d38b"

URI_aarch64_rust-normpath+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath+default-devel-1.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-normpath+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normpath+default-devel}"
SRC_URI[aarch64_rust-normpath+default-devel.sha256sum] = "d46986d098fe7643e2e26fb0d853534f2fceb518d02a5c303307cad352b6e3fc"

URI_aarch64_rust-normpath+localization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath+localization-devel-1.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-normpath+localization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normpath+localization-devel}"
SRC_URI[aarch64_rust-normpath+localization-devel.sha256sum] = "25e0ebf203179c9dfa9b4c439df1ac060f95989f7bddf62069d56b97c80e5962"

URI_aarch64_rust-normpath+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath+serde-devel-1.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-normpath+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normpath+serde-devel}"
SRC_URI[aarch64_rust-normpath+serde-devel.sha256sum] = "6fb7bf38deb031b52a764d3a398dde0c52b003b9df225ed9761302a56e2d326d"

URI_aarch64_rust-normpath-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath-devel-1.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-normpath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normpath-devel}"
SRC_URI[aarch64_rust-normpath-devel.sha256sum] = "7ca1eddf64ac2be333563c5c6f4efe0a3a66e94e1374939ce879a3bc3f8939c5"

RDEPENDS:rust-normpath+default-devel = " \
 cargo \
 rust-normpath-devel \
 "
RDEPENDS:rust-normpath+localization-devel = " \
 cargo \
 rust-normpath-devel \
 "
RDEPENDS:rust-normpath+serde-devel = " \
 cargo \
 rust-normpath-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-normpath-devel = " \
 cargo \
 rust \
 "
