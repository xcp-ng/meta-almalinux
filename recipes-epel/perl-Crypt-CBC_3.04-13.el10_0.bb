# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-CBC"
PV = "3.04"
PR = "13.el10_0"
PACKAGES = " \
 perl-Crypt-CBC \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-CBC-3.04-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b97f20ce7b457072360bfd237e83093ccd22d7fd02cafa4d5e41a35975e1e632"

URI_x86_64_v2_perl-Crypt-CBC = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-CBC-3.04-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-CBC;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-CBC}"
SRC_URI[x86_64_v2_perl-Crypt-CBC.sha256sum] = "e08461a0be4fa7c5350bcfd6252d30e57b0f4eec36abe1f1a9c1148ff40c849d"

URI_aarch64_perl-Crypt-CBC = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-CBC-3.04-13.el10_0.noarch.rpm;name=aarch64_perl-Crypt-CBC;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-CBC}"
SRC_URI[aarch64_perl-Crypt-CBC.sha256sum] = "31d5b07d2c41481ad045f658f10dfd77d3afb663d05cddf06dba167e588dcfea"

RDEPENDS:perl-Crypt-CBC = " \
 perl-Carp \
 perl-Crypt-PBKDF2 \
 perl-CryptX \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-File-Basename \
 perl-Scalar-List-Utils \
 perl-base \
 perl-constant \
 perl-libs \
 perl-vars \
 "
