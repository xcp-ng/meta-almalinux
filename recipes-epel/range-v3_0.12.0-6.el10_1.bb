# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "range-v3"
PV = "0.12.0"
PR = "6.el10_1"
PACKAGES = " \
 range-v3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/range-v3-0.12.0-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9366566f84eacea3f386f63904fd23f8e46ae8da252dfe2a9c63aab15a6d0a9a"

URI_x86_64_v2_range-v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/range-v3-devel-0.12.0-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_range-v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_range-v3-devel}"
SRC_URI[x86_64_v2_range-v3-devel.sha256sum] = "b8b15dd119af672283ee3c0da3a159b566555166fcd16cb061d463440cb51dab"

URI_aarch64_range-v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/range-v3-devel-0.12.0-6.el10_1.aarch64.rpm;name=aarch64_range-v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_range-v3-devel}"
SRC_URI[aarch64_range-v3-devel.sha256sum] = "2031bbb79eb38c4193917c8c6f12ea82a7d939bba30efa7218cf6e8761a6b84f"

RDEPENDS:range-v3-devel = " \
 cmake-filesystem \
 "
