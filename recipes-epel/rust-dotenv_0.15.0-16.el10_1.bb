# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dotenv"
PV = "0.15.0"
PR = "16.el10_1"
PACKAGES = " \
 rust-dotenv+default-devel \
 rust-dotenv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dotenv-0.15.0-16.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b2e2d5d916784d96e05808334185b04ba2141d79e4664d75b200a6fb83ccb85"

URI_x86_64_v2_rust-dotenv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dotenv+default-devel-0.15.0-16.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dotenv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dotenv+default-devel}"
SRC_URI[x86_64_v2_rust-dotenv+default-devel.sha256sum] = "0a8464f9455202b93e57843811e80b36c94ea6447253a9359c2154e02fb6f8d6"

URI_x86_64_v2_rust-dotenv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dotenv-devel-0.15.0-16.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dotenv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dotenv-devel}"
SRC_URI[x86_64_v2_rust-dotenv-devel.sha256sum] = "f64d9972a6b56417451445c829c89f7595ee3f1e74316959360e2f330dd89c6f"

URI_aarch64_rust-dotenv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dotenv+default-devel-0.15.0-16.el10_1.noarch.rpm;name=aarch64_rust-dotenv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dotenv+default-devel}"
SRC_URI[aarch64_rust-dotenv+default-devel.sha256sum] = "e11f9d1b1338a8fd0feddaa6f4fe3ff93092a52f6485956fb79303cb04600f82"

URI_aarch64_rust-dotenv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dotenv-devel-0.15.0-16.el10_1.noarch.rpm;name=aarch64_rust-dotenv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dotenv-devel}"
SRC_URI[aarch64_rust-dotenv-devel.sha256sum] = "7ae7b300e1dcb8c326d3ad03a64843092cc73a4a3126ada786d11be9b2862b6a"

RDEPENDS:rust-dotenv+default-devel = " \
 cargo \
 rust-dotenv-devel \
 "
RDEPENDS:rust-dotenv-devel = " \
 cargo \
 "
