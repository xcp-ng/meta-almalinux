# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma5support"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma5support \
 plasma5support-devel \
 plasma5support-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma5support-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d08dc8dab8b385f38bfcebdde648621e70b4b592d964bd4dab2e75f81d19c38"

URI_x86_64_v2_plasma5support = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma5support;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma5support}"
SRC_URI[x86_64_v2_plasma5support.sha256sum] = "6e5ec03c8e042e9875a6fcc69dd8911842881e05124167135b523b70c4566a66"

URI_x86_64_v2_plasma5support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma5support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma5support-devel}"
SRC_URI[x86_64_v2_plasma5support-devel.sha256sum] = "a260f6f28e6d87afb8fa42a149640883f64db99c034d89677b0da2106e52fc92"

URI_x86_64_v2_plasma5support-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-doc-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma5support-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma5support-doc}"
SRC_URI[x86_64_v2_plasma5support-doc.sha256sum] = "68a12709f0ca85a2f73e44c7c0000c9e1dcb1a97ea2094857f5a97406e6be8c1"

URI_aarch64_plasma5support = "${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma5support;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma5support}"
SRC_URI[aarch64_plasma5support.sha256sum] = "119ae36419ac59ff1400865d2dd8929736cb4e5c5b4ee292e34bd53d5fd06346"

URI_aarch64_plasma5support-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma5support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma5support-devel}"
SRC_URI[aarch64_plasma5support-devel.sha256sum] = "dfb27478d510f0354103eaf001a4e3e9786e658a9ac62637841564433772f685"

URI_aarch64_plasma5support-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-doc-6.7.3-1.el10_3.noarch.rpm;name=aarch64_plasma5support-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma5support-doc}"
SRC_URI[aarch64_plasma5support-doc.sha256sum] = "4b7e59322977f7c10355a622d9e027a63d79680ab38d41296d297370e449cef4"

RDEPENDS:plasma5support = " \
 glibc \
 gpsd-libs \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kunitconversion \
 kf6-networkmanager-qt \
 kf6-solid \
 libX11 \
 libXfixes \
 libksysguard \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma5support-devel = " \
 cmake-filesystem \
 plasma5support \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma5support-doc = " \
 "
