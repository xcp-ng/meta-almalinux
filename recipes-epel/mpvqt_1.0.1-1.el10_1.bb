# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mpvqt"
PV = "1.0.1"
PR = "1.el10_1"
PACKAGES = " \
 mpvqt \
 mpvqt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mpvqt-1.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3015590910b490ed7357d26cf455e126edcf85c1846d16f581e1b781d59f8e3f"

URI_x86_64_v2_mpvqt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mpvqt-1.0.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mpvqt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpvqt}"
SRC_URI[x86_64_v2_mpvqt.sha256sum] = "916dca76da74a9bace3f061ba9667445904afed8bf3b1d42b1193342973ed106"

URI_x86_64_v2_mpvqt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mpvqt-devel-1.0.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mpvqt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpvqt-devel}"
SRC_URI[x86_64_v2_mpvqt-devel.sha256sum] = "fd66995c458b3811641f672d91e8cc6126bcc37ec7c4a7b251ec8b81400846d9"

URI_aarch64_mpvqt = "${EPEL_MIRROR}/aarch64/Packages/m/mpvqt-1.0.1-1.el10_1.aarch64.rpm;name=aarch64_mpvqt;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpvqt}"
SRC_URI[aarch64_mpvqt.sha256sum] = "8f796e02b4ca3d6fa5e8a717ce40e387db6d1e4f35bbcdaedc9504568560e61c"

URI_aarch64_mpvqt-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mpvqt-devel-1.0.1-1.el10_1.aarch64.rpm;name=aarch64_mpvqt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpvqt-devel}"
SRC_URI[aarch64_mpvqt-devel.sha256sum] = "0105f4abc90b2265720d2f7b99502f4ef408d863b7d318131bea02fe47a6c9bd"

RDEPENDS:mpvqt = " \
 glibc \
 libstdc++ \
 mpv-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:mpvqt-devel = " \
 cmake-filesystem \
 mpv-devel \
 mpvqt \
 qt6-qtdeclarative-devel \
 "
