# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-constant_time_eq"
PV = "0.4.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-constant_time_eq+default-devel \
 rust-constant_time_eq+std-devel \
 rust-constant_time_eq-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-constant_time_eq-0.4.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a91b004f7c40a110c427cee9fd22e81e62b0ea3abb445aded377c3a3fbe506d6"

URI_x86_64_v2_rust-constant_time_eq+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-constant_time_eq+default-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-constant_time_eq+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-constant_time_eq+default-devel}"
SRC_URI[x86_64_v2_rust-constant_time_eq+default-devel.sha256sum] = "41a07ceb1b059b2720891d35163bb2d7c370f4db0430ba74a7b06091431884a8"

URI_x86_64_v2_rust-constant_time_eq+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-constant_time_eq+std-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-constant_time_eq+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-constant_time_eq+std-devel}"
SRC_URI[x86_64_v2_rust-constant_time_eq+std-devel.sha256sum] = "52c3b71abbd3b01e0c43f16fdc4df6a7e85f71e23170b1c599bbcfe98c0c8974"

URI_x86_64_v2_rust-constant_time_eq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-constant_time_eq-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-constant_time_eq-devel}"
SRC_URI[x86_64_v2_rust-constant_time_eq-devel.sha256sum] = "891dfc24fb9744428c4bd9e08bec4720d08edbdff1b0f82963985a5a9ff7ce24"

URI_aarch64_rust-constant_time_eq+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-constant_time_eq+default-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-constant_time_eq+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-constant_time_eq+default-devel}"
SRC_URI[aarch64_rust-constant_time_eq+default-devel.sha256sum] = "91febebbd63302e575ddc47988523ade50630f800827b73444469a15e90a1269"

URI_aarch64_rust-constant_time_eq+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-constant_time_eq+std-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-constant_time_eq+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-constant_time_eq+std-devel}"
SRC_URI[aarch64_rust-constant_time_eq+std-devel.sha256sum] = "7ba7695609f025e713b43e4aa5c2ea22d76ccc59f8a660e3957ba699d21510ac"

URI_aarch64_rust-constant_time_eq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-constant_time_eq-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-constant_time_eq-devel}"
SRC_URI[aarch64_rust-constant_time_eq-devel.sha256sum] = "2b546756f699a1210349706ef0111b017a7dd646a9a3101454985d9de1a3199f"

RDEPENDS:rust-constant_time_eq+default-devel = " \
 cargo \
 rust-constant_time_eq+std-devel \
 rust-constant_time_eq-devel \
 "
RDEPENDS:rust-constant_time_eq+std-devel = " \
 cargo \
 rust-constant_time_eq-devel \
 "
RDEPENDS:rust-constant_time_eq-devel = " \
 cargo \
 rust \
 "
