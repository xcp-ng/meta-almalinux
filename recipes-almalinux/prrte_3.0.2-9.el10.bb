# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prrte"
PV = "3.0.2"
PR = "9.el10"
PACKAGES = " \
 prrte \
 prrte-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/prrte-3.0.2-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5f8eaba3ce7b33534feaf61001c02fa208309768da03ba6f6fd28367b20282d"

URI_x86_64_v2_prrte = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/prrte-3.0.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_prrte;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_prrte}"
SRC_URI[x86_64_v2_prrte.sha256sum] = "d0a78d47b17de5cbde363b11db1028f2e6cd4432028c5b0111d3dc027414f3a5"

URI_x86_64_v2_prrte-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/prrte-libs-3.0.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_prrte-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_prrte-libs}"
SRC_URI[x86_64_v2_prrte-libs.sha256sum] = "2fdf6eb1f7ff139bc4d1786e86c687192a8bde540868b798fa724e85a032cb24"

URI_aarch64_prrte = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/prrte-3.0.2-9.el10.aarch64.rpm;name=aarch64_prrte;unpack=0"
SRC_URI:append = " ${URI_aarch64_prrte}"
SRC_URI[aarch64_prrte.sha256sum] = "b5735cb378bbeffbe72bb36e8410fbc1cc4556b115d5c87bde917e1564f82c72"

URI_aarch64_prrte-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/prrte-libs-3.0.2-9.el10.aarch64.rpm;name=aarch64_prrte-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_prrte-libs}"
SRC_URI[aarch64_prrte-libs.sha256sum] = "bfb844188eac8bd0e3e45af045f4f9aea9263eb39ef5732132ebe06f30fe85a5"

RDEPENDS:prrte = " \
 glibc \
 hwloc-libs \
 libevent \
 pmix \
 prrte-libs \
 "
RDEPENDS:prrte-libs = " \
 glibc \
 hwloc-libs \
 libevent \
 pmix \
 torque-libs \
 "
