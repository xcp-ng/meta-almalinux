# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libbs2b"
PV = "3.1.0"
PR = "34.el10_0"
PACKAGES = " \
 libbs2b \
 libbs2b-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libbs2b-3.1.0-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2da3b8a547cfa88428981f0745a5aa0c32eb2884524c4ef9cfcbfd677d466ac0"

URI_x86_64_v2_libbs2b = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbs2b-3.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbs2b;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbs2b}"
SRC_URI[x86_64_v2_libbs2b.sha256sum] = "3fcbe5eac9412367be34d9029a8e43be6579c9dd64473e14cd1eb9506122bc8b"

URI_x86_64_v2_libbs2b-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbs2b-devel-3.1.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbs2b-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbs2b-devel}"
SRC_URI[x86_64_v2_libbs2b-devel.sha256sum] = "7f4cbe45e505b5a658b7e1df8bb49a5dea470b9322bd5f508762c3cb0f8b74e7"

URI_aarch64_libbs2b = "${EPEL_MIRROR}/aarch64/Packages/l/libbs2b-3.1.0-34.el10_0.aarch64.rpm;name=aarch64_libbs2b;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbs2b}"
SRC_URI[aarch64_libbs2b.sha256sum] = "cb582e83e287f8833ff57b896f41f39ecddca4a2915dd896457823f0df7910e2"

URI_aarch64_libbs2b-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libbs2b-devel-3.1.0-34.el10_0.aarch64.rpm;name=aarch64_libbs2b-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbs2b-devel}"
SRC_URI[aarch64_libbs2b-devel.sha256sum] = "22f2ac9e4864121c7df593db289165d22afbb67b4c3ac9e83bd2f7a723c1c87e"

RDEPENDS:libbs2b = " \
 glibc \
 libgcc \
 libsndfile \
 libstdc++ \
 "
RDEPENDS:libbs2b-devel = " \
 libbs2b \
 pkgconf-pkg-config \
 "
