# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-itoa"
PV = "1.0.18"
PR = "1.el10_2"
PACKAGES = " \
 rust-itoa+default-devel \
 rust-itoa+no-panic-devel \
 rust-itoa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-itoa-1.0.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e36f2b32f2548533cbdb003b12a38eb2b3168de37aead695833934087907d4f"

URI_x86_64_v2_rust-itoa+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoa+default-devel-1.0.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoa+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoa+default-devel}"
SRC_URI[x86_64_v2_rust-itoa+default-devel.sha256sum] = "d3045259a49a7fee90895caf452dcc380011c348295175e5ff63856274faa412"

URI_x86_64_v2_rust-itoa+no-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoa+no-panic-devel-1.0.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoa+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoa+no-panic-devel}"
SRC_URI[x86_64_v2_rust-itoa+no-panic-devel.sha256sum] = "3c4f82864311f77ad78ad16dfb38a44664cffada17b48aaa4fd6502adfaa8878"

URI_x86_64_v2_rust-itoa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoa-devel-1.0.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoa-devel}"
SRC_URI[x86_64_v2_rust-itoa-devel.sha256sum] = "3b94475721f4f0de883e38f079bf4a9fa8a02e6110d2bb80a105c7c652e963fd"

URI_aarch64_rust-itoa+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoa+default-devel-1.0.18-1.el10_2.noarch.rpm;name=aarch64_rust-itoa+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoa+default-devel}"
SRC_URI[aarch64_rust-itoa+default-devel.sha256sum] = "6e9f7f4e1e1c685e9f5a94e8aa227179e3e31822c5e8fcaf7f366638a2e0103c"

URI_aarch64_rust-itoa+no-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoa+no-panic-devel-1.0.18-1.el10_2.noarch.rpm;name=aarch64_rust-itoa+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoa+no-panic-devel}"
SRC_URI[aarch64_rust-itoa+no-panic-devel.sha256sum] = "0ccf53ad2a1536e845a559bb240ed3a94a28cd679036dfe471c3a8c3ac64c5ad"

URI_aarch64_rust-itoa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoa-devel-1.0.18-1.el10_2.noarch.rpm;name=aarch64_rust-itoa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoa-devel}"
SRC_URI[aarch64_rust-itoa-devel.sha256sum] = "77af194346b6cedbd35a6b5d693daee94b1526fb788eef3361235b181e050052"

RDEPENDS:rust-itoa+default-devel = " \
 cargo \
 rust-itoa-devel \
 "
RDEPENDS:rust-itoa+no-panic-devel = " \
 cargo \
 rust-itoa-devel \
 rust-no-panic+default-devel \
 "
RDEPENDS:rust-itoa-devel = " \
 cargo \
 rust \
 "
