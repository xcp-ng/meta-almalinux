# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wasmedge"
PV = "0.17.1"
PR = "1.el10_2"
PACKAGES = " \
 wasmedge \
 wasmedge-devel \
 wasmedge-rt \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/wasmedge-0.17.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b0be46b37d8bc5ff7e7b5141425e415ea4ee93f5081422d9c0af40a79a779a32"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wasmedge-0.17.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wasmedge;unpack=0"
SRC_URI[x86_64_v2_wasmedge.sha256sum] = "48dc8cffea0a44a4ebef88b91a0b0b2884a1132f6ca53c4363f50f14e3118fba"
RPROVIDES:wasmedge:append:x86_64_v2 = " virtual/libwasmedge.so.0___64bit_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wasmedge-devel-0.17.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wasmedge-devel;unpack=0"
SRC_URI[x86_64_v2_wasmedge-devel.sha256sum] = "d06b456d42d0161a2f21e45ac8f3126301af190c0f1ae01263fe379dab06e0a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wasmedge-rt-0.17.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wasmedge-rt;unpack=0"
SRC_URI[x86_64_v2_wasmedge-rt.sha256sum] = "4cb6117554bc1e886860bdc4d6419b5eee4670f382e88ab0ba495ca5ba252bd6"
RPROVIDES:wasmedge-rt:append:x86_64_v2 = " virtual/libwasmedge.so.0___64bit_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wasmedge-0.17.1-1.el10_2.aarch64.rpm;name=aarch64_wasmedge;unpack=0"
SRC_URI[aarch64_wasmedge.sha256sum] = "4bab92e47bc7f9e11cf3af499946815965bf07adfa9954754cceceb4942149ef"
RPROVIDES:wasmedge:append:aarch64 = " virtual/libwasmedge.so.0___64bit_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wasmedge-devel-0.17.1-1.el10_2.aarch64.rpm;name=aarch64_wasmedge-devel;unpack=0"
SRC_URI[aarch64_wasmedge-devel.sha256sum] = "8be990f8dc67d10c6a857d1ed60af9b6c51865c9f2da678ae919efb7adf6e575"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wasmedge-rt-0.17.1-1.el10_2.aarch64.rpm;name=aarch64_wasmedge-rt;unpack=0"
SRC_URI[aarch64_wasmedge-rt.sha256sum] = "20952871a9390d0738ae143ed07f7f2f36aead8c621ceae78ffcd34bd184fb36"
RPROVIDES:wasmedge-rt:append:aarch64 = " virtual/libwasmedge.so.0___64bit_"

RDEPENDS:wasmedge = " \
 fmt \
 glibc \
 libgcc \
 libstdc++ \
 lld19 \
 lld19-libs \
 llvm19 \
 llvm19-libs \
 spdlog \
 "
RDEPENDS:wasmedge-devel = " \
 virtual/libwasmedge.so.0___64bit_ \
 wasmedge \
 "
RDEPENDS:wasmedge-rt = " \
 fmt \
 glibc \
 libgcc \
 libstdc++ \
 lld19-libs \
 llvm19-libs \
 spdlog \
 "
