# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hexops-gotextdiff"
PV = "1.0.3"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-hexops-gotextdiff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hexops-gotextdiff-1.0.3-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2160788fa077b730aada54baff5a33830aa4e2b02535f2c29bc9ef36630158c1"

URI_x86_64_v2_golang-github-hexops-gotextdiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hexops-gotextdiff-devel-1.0.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hexops-gotextdiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hexops-gotextdiff-devel}"
SRC_URI[x86_64_v2_golang-github-hexops-gotextdiff-devel.sha256sum] = "0e7bee2c3b61a7598bffa7c6e6f7745053b4b2ffbe17d2893f500bd7bfe35f08"

URI_aarch64_golang-github-hexops-gotextdiff-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hexops-gotextdiff-devel-1.0.3-6.el10_0.noarch.rpm;name=aarch64_golang-github-hexops-gotextdiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hexops-gotextdiff-devel}"
SRC_URI[aarch64_golang-github-hexops-gotextdiff-devel.sha256sum] = "71fd7ecd984891be8459fd07818e094c89450e3e84a9bf10ebdd866b43215d46"

RDEPENDS:golang-github-hexops-gotextdiff-devel = " \
 go-filesystem \
 "
