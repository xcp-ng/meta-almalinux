# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtserialport"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtserialport \
 qt5-qtserialport-devel \
 qt5-qtserialport-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtserialport-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1e4b25bdc93cfd9152410a89d5161242e7a0320ba33f75bea28a536bab75959"

URI_x86_64_v2_qt5-qtserialport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialport-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialport}"
SRC_URI[x86_64_v2_qt5-qtserialport.sha256sum] = "0919b5e12c526d4d64b8a4a2a25fafe1caafa4d88cdc306273b3a6b49bb588b4"

URI_x86_64_v2_qt5-qtserialport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialport-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialport-devel}"
SRC_URI[x86_64_v2_qt5-qtserialport-devel.sha256sum] = "20cc42cb21d35b88251e7fcb4b6ca113fc93d5561bdd8ff6f40a7f0c2b53bac1"

URI_x86_64_v2_qt5-qtserialport-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialport-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialport-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialport-examples}"
SRC_URI[x86_64_v2_qt5-qtserialport-examples.sha256sum] = "9f469e56c7329f60c15059f94188b2dc208520f0f69455b7f5f77c874fe56eed"

URI_aarch64_qt5-qtserialport = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialport-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtserialport;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialport}"
SRC_URI[aarch64_qt5-qtserialport.sha256sum] = "71deeec85ebd573cb16417781b70b96759646480ad2c40c28a92c129f8b81587"

URI_aarch64_qt5-qtserialport-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialport-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtserialport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialport-devel}"
SRC_URI[aarch64_qt5-qtserialport-devel.sha256sum] = "12bc056ec04a5ac4c73fba71b3b04091e194b306b28a4dea92f49b837529ded0"

URI_aarch64_qt5-qtserialport-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialport-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtserialport-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialport-examples}"
SRC_URI[aarch64_qt5-qtserialport-examples.sha256sum] = "540bf9150f281511685755f2bde87474f64f679745198cb884fb04c12b9a8f8b"

RDEPENDS:qt5-qtserialport = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 systemd-libs \
 "
RDEPENDS:qt5-qtserialport-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtserialport \
 "
RDEPENDS:qt5-qtserialport-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtserialport \
 "
