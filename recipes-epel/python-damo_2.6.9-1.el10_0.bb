# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-damo"
PV = "2.6.9"
PR = "1.el10_0"
PACKAGES = " \
 damo \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-damo-2.6.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3049fcec59c2ec77e8db779ed7f0f1f77a0a7494516104d0b6ec8079b073b298"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/damo-2.6.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_damo;unpack=0"
SRC_URI[x86_64_v2_damo.sha256sum] = "f1561bd0013b95dded526507d86bb7da8f076843a947c50b37eb291c6458cf5c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/damo-2.6.9-1.el10_0.noarch.rpm;name=aarch64_damo;unpack=0"
SRC_URI[aarch64_damo.sha256sum] = "e0838f268f8098c501f768cac1e53be05731d75c2ab0153377fbeb750ee2c547"

RDEPENDS:damo = " \
 python3 \
 "
