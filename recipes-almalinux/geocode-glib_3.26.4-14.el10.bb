# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "geocode-glib"
PV = "3.26.4"
PR = "14.el10"
PACKAGES = " \
 geocode-glib \
 geocode-glib-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/geocode-glib-3.26.4-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fba3dfd31504e40395be1271e465efe0a741588eda99b6ef653e3a8ee680d776"

URI_x86_64_v2_geocode-glib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/geocode-glib-3.26.4-14.el10.x86_64_v2.rpm;name=x86_64_v2_geocode-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_geocode-glib}"
SRC_URI[x86_64_v2_geocode-glib.sha256sum] = "def6537ebd3d6cb10b51f6932835274034e9de3f152a0dae3bf92b5d04a37504"

URI_x86_64_v2_geocode-glib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/geocode-glib-devel-3.26.4-14.el10.x86_64_v2.rpm;name=x86_64_v2_geocode-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_geocode-glib-devel}"
SRC_URI[x86_64_v2_geocode-glib-devel.sha256sum] = "1fbff9d2186d51ffe8e07c5874843ca154e1629ceb430fe6a8acaed0432a4792"

URI_aarch64_geocode-glib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/geocode-glib-3.26.4-14.el10.aarch64.rpm;name=aarch64_geocode-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_geocode-glib}"
SRC_URI[aarch64_geocode-glib.sha256sum] = "49d083b0d6c6f3f8e3c4f48834efac0fd88e8ef883b52fbaca66668169672df0"

URI_aarch64_geocode-glib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/geocode-glib-devel-3.26.4-14.el10.aarch64.rpm;name=aarch64_geocode-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_geocode-glib-devel}"
SRC_URI[aarch64_geocode-glib-devel.sha256sum] = "db2eced5e2f71b0930e3fffc22aa591f979546aa0b5b7530f93443e9a25dc327"

RDEPENDS:geocode-glib = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 libsoup3 \
 "
RDEPENDS:geocode-glib-devel = " \
 geocode-glib \
 glib2-devel \
 pkgconf-pkg-config \
 "
