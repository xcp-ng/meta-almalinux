# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-maxminddb"
PV = "1.14.0"
PR = "1.el10_3"
PACKAGES = " \
 php-maxmind-db-reader \
 php-maxminddb \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-maxminddb-1.14.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1e65ced91f5164ca4dd49d6045046c85247e650603f52c320c3e2af5c7a289c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-maxmind-db-reader-1.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_php-maxmind-db-reader;unpack=0"
SRC_URI[x86_64_v2_php-maxmind-db-reader.sha256sum] = "f7a12ef5284e5a43aa226952e34b3484d85ee982d030bd9f97087b56084b7a01"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-maxminddb-1.14.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-maxminddb;unpack=0"
SRC_URI[x86_64_v2_php-maxminddb.sha256sum] = "45f2c40f1eba708393cca8f4365ac8b04d2d9499c4bb82cb879ce42716500b59"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-maxmind-db-reader-1.14.0-1.el10_3.noarch.rpm;name=aarch64_php-maxmind-db-reader;unpack=0"
SRC_URI[aarch64_php-maxmind-db-reader.sha256sum] = "46b2f097119cf59297177ec79b52acd726aec3c4ad4fb2091fa05180b19df375"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-maxminddb-1.14.0-1.el10_3.aarch64.rpm;name=aarch64_php-maxminddb;unpack=0"
SRC_URI[aarch64_php-maxminddb.sha256sum] = "939a7147e3e76e815f293b867be1d696517831a1a0bcfb6d3657b9ce4cc530cf"

RDEPENDS:php-maxmind-db-reader = " \
 php-fedora-autoloader \
 virtual/php-filter \
 virtual/php-spl \
 virtual/php_language__ge_7.2 \
 "
RDEPENDS:php-maxminddb = " \
 glibc \
 libmaxminddb \
 php-common \
 "
