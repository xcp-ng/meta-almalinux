# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-uri-encode"
PV = "1.5.0.7"
PR = "16.el10_0"
PACKAGES = " \
 ghc-uri-encode \
 ghc-uri-encode-devel \
 ghc-uri-encode-doc \
 ghc-uri-encode-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-uri-encode-1.5.0.7-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f95149022d608d36601f3898dbf6af443b5806f2859a40259bb1b5a605b647a"

URI_x86_64_v2_ghc-uri-encode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uri-encode-1.5.0.7-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uri-encode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uri-encode}"
SRC_URI[x86_64_v2_ghc-uri-encode.sha256sum] = "a7532fc53df52baaaf074e6ea9d5e7a281f25781ac780252b9f15306721f597d"

URI_x86_64_v2_ghc-uri-encode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uri-encode-devel-1.5.0.7-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uri-encode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uri-encode-devel}"
SRC_URI[x86_64_v2_ghc-uri-encode-devel.sha256sum] = "0f2867f74ea20bee060cd00b9ca7808f012d08bf8e4f2c8b3a18bb1cf20c2f87"

URI_x86_64_v2_ghc-uri-encode-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uri-encode-doc-1.5.0.7-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-uri-encode-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uri-encode-doc}"
SRC_URI[x86_64_v2_ghc-uri-encode-doc.sha256sum] = "0f6d36d42e761f6d3e08ce0367a8d4adfd9b5c1d2dc165a38795992db6a7ad2e"

URI_x86_64_v2_ghc-uri-encode-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uri-encode-prof-1.5.0.7-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uri-encode-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uri-encode-prof}"
SRC_URI[x86_64_v2_ghc-uri-encode-prof.sha256sum] = "5dce09737608c5245f70d7d1491b269441b0e84a8f62d4b82fbf88fe72e8cd28"

URI_aarch64_ghc-uri-encode = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uri-encode-1.5.0.7-16.el10_0.aarch64.rpm;name=aarch64_ghc-uri-encode;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uri-encode}"
SRC_URI[aarch64_ghc-uri-encode.sha256sum] = "3b7f614e127f4f6a3fece4f89946e3395d7e5e9c8aeaf50449d411fe4c7709fd"

URI_aarch64_ghc-uri-encode-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uri-encode-devel-1.5.0.7-16.el10_0.aarch64.rpm;name=aarch64_ghc-uri-encode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uri-encode-devel}"
SRC_URI[aarch64_ghc-uri-encode-devel.sha256sum] = "6e8c19f2dbe9b436fd7797304c7206cbac0d9b9baab42e3f42c8faae547fda91"

URI_aarch64_ghc-uri-encode-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uri-encode-doc-1.5.0.7-16.el10_0.noarch.rpm;name=aarch64_ghc-uri-encode-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uri-encode-doc}"
SRC_URI[aarch64_ghc-uri-encode-doc.sha256sum] = "ba647e5472c2b4d54768d4bd9601e237d6287f6e8e9a03b7e5e5e25adf66aed3"

URI_aarch64_ghc-uri-encode-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uri-encode-prof-1.5.0.7-16.el10_0.aarch64.rpm;name=aarch64_ghc-uri-encode-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uri-encode-prof}"
SRC_URI[aarch64_ghc-uri-encode-prof.sha256sum] = "03d9f1f8d7c2f4a049966eacfc8aeda279cdabae692aa1bcf8ff128277a03c3b"

RDEPENDS:ghc-uri-encode = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-network-uri \
 ghc-parsec \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-th-compat \
 ghc-transformers \
 ghc-utf8-string \
 glibc \
 gmp \
 "
RDEPENDS:ghc-uri-encode-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-network-uri-devel \
 ghc-text-devel \
 ghc-uri-encode \
 ghc-utf8-string-devel \
 "
RDEPENDS:ghc-uri-encode-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-uri-encode-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-network-uri-prof \
 ghc-text-prof \
 ghc-uri-encode-devel \
 ghc-utf8-string-prof \
 "
