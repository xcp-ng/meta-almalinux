# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalm"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kalm \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kalm-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ed0a4049a08500a5a60f3c92203506ee0b3e71958aad3be1c7f1fcb57ad765ee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalm-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalm;unpack=0"
SRC_URI[x86_64_v2_kalm.sha256sum] = "114944d5d744622a82d54727c6e5e06d2fd52d156a6b507b00f230d547385387"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kalm-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kalm;unpack=0"
SRC_URI[aarch64_kalm.sha256sum] = "16be6d48cf5c2afafca6b19768e49cb05aa240cf9e4c10f9e40b77fea947acdf"

RDEPENDS:kalm = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami-addons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
