# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "staticcheck"
PV = "2026.1"
PR = "1.el10_2"
PACKAGES = " \
 staticcheck \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/staticcheck-2026.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be41cbec75aca31832123cf8331236cb8d006cbaac24d5802f73cd00a6c9fce9"

URI_x86_64_v2_staticcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/staticcheck-2026.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_staticcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_staticcheck}"
SRC_URI[x86_64_v2_staticcheck.sha256sum] = "099aedba038e05bc6a607758bfca5d0c33cd8656358d0812244879edf9a76996"

URI_aarch64_staticcheck = "${EPEL_MIRROR}/aarch64/Packages/s/staticcheck-2026.1-1.el10_2.aarch64.rpm;name=aarch64_staticcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_staticcheck}"
SRC_URI[aarch64_staticcheck.sha256sum] = "e85310c4081b23e68f1ff879be7e9e8983bd4edcfe3c481a2f8bcd2d3f0c95d4"

RDEPENDS:staticcheck = " \
 glibc \
 "
