# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-tour"
PV = "46.0"
PR = "4.el10.alma.1"
PACKAGES = " \
 gnome-tour \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-tour-46.0-4.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7e173848fd4ba52411a7c8dc9d2aec25b6b412370cf76f998b6cae5ffc8836d"

URI_x86_64_v2_gnome-tour = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-tour-46.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gnome-tour;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-tour}"
SRC_URI[x86_64_v2_gnome-tour.sha256sum] = "e883bf58ac64e04e2faa7e23cb6691f0a21fd7c9f83b1d70eb2a7d5968af56af"

URI_aarch64_gnome-tour = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-tour-46.0-4.el10.alma.1.aarch64.rpm;name=aarch64_gnome-tour;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-tour}"
SRC_URI[aarch64_gnome-tour.sha256sum] = "c6148aa105e941b477be01ddbcba6dce2a93b8c370b135466be74d21f8e275fe"

RDEPENDS:gnome-tour = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
 libgcc \
 pango \
 "
