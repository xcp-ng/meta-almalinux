# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jsonwebtoken"
PV = "9.3.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-jsonwebtoken+default-devel \
 rust-jsonwebtoken+pem-devel \
 rust-jsonwebtoken+simple_asn1-devel \
 rust-jsonwebtoken+use_pem-devel \
 rust-jsonwebtoken-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jsonwebtoken-9.3.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5799fae5fac4f37d5c9e2a71721fd735140c118749c5d99ff11990b981c7f186"

URI_x86_64_v2_rust-jsonwebtoken+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jsonwebtoken+default-devel-9.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jsonwebtoken+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jsonwebtoken+default-devel}"
SRC_URI[x86_64_v2_rust-jsonwebtoken+default-devel.sha256sum] = "c984fed0dbd00fa385b75ed3ea6d52f1a94113c575366ead39f8e5d420eb3ff0"

URI_x86_64_v2_rust-jsonwebtoken+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jsonwebtoken+pem-devel-9.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jsonwebtoken+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jsonwebtoken+pem-devel}"
SRC_URI[x86_64_v2_rust-jsonwebtoken+pem-devel.sha256sum] = "be73b412011b76337b26a61ecd2fc8637b41fce56e2d87f9083e581e48e4d10d"

URI_x86_64_v2_rust-jsonwebtoken+simple_asn1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jsonwebtoken+simple_asn1-devel-9.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jsonwebtoken+simple_asn1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jsonwebtoken+simple_asn1-devel}"
SRC_URI[x86_64_v2_rust-jsonwebtoken+simple_asn1-devel.sha256sum] = "34374b5da680dda19a6f3258693ba17e0292952eb424849b4e43d3b977c5c6d8"

URI_x86_64_v2_rust-jsonwebtoken+use_pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jsonwebtoken+use_pem-devel-9.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jsonwebtoken+use_pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jsonwebtoken+use_pem-devel}"
SRC_URI[x86_64_v2_rust-jsonwebtoken+use_pem-devel.sha256sum] = "4224b7bbddbb1382d818c06a95074ea7c446dede376c466a18ecd2667bf004d2"

URI_x86_64_v2_rust-jsonwebtoken-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jsonwebtoken-devel-9.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jsonwebtoken-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jsonwebtoken-devel}"
SRC_URI[x86_64_v2_rust-jsonwebtoken-devel.sha256sum] = "2d2163854a1ab97faafef09ba15185105ea58e33c7fc56c7a6b8fa73b36e7453"

URI_aarch64_rust-jsonwebtoken+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jsonwebtoken+default-devel-9.3.1-2.el10_1.noarch.rpm;name=aarch64_rust-jsonwebtoken+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jsonwebtoken+default-devel}"
SRC_URI[aarch64_rust-jsonwebtoken+default-devel.sha256sum] = "5ad848ef3d12eb92dd6c018344823b281000e2f854b723fcf3956a0e3be85566"

URI_aarch64_rust-jsonwebtoken+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jsonwebtoken+pem-devel-9.3.1-2.el10_1.noarch.rpm;name=aarch64_rust-jsonwebtoken+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jsonwebtoken+pem-devel}"
SRC_URI[aarch64_rust-jsonwebtoken+pem-devel.sha256sum] = "0d8fba1a9127d25de4399d78aa2c02a5a43938fd445883ee8ec2550fdcd10b7f"

URI_aarch64_rust-jsonwebtoken+simple_asn1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jsonwebtoken+simple_asn1-devel-9.3.1-2.el10_1.noarch.rpm;name=aarch64_rust-jsonwebtoken+simple_asn1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jsonwebtoken+simple_asn1-devel}"
SRC_URI[aarch64_rust-jsonwebtoken+simple_asn1-devel.sha256sum] = "7d91a1a14004c52f593562d2ba5fbf532e90c03ff9c4679d70b10abd3677db51"

URI_aarch64_rust-jsonwebtoken+use_pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jsonwebtoken+use_pem-devel-9.3.1-2.el10_1.noarch.rpm;name=aarch64_rust-jsonwebtoken+use_pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jsonwebtoken+use_pem-devel}"
SRC_URI[aarch64_rust-jsonwebtoken+use_pem-devel.sha256sum] = "ac2c83273064aac1c7099d1d03d0d2ff399ad1a91561914c5561fae0057aea0a"

URI_aarch64_rust-jsonwebtoken-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jsonwebtoken-devel-9.3.1-2.el10_1.noarch.rpm;name=aarch64_rust-jsonwebtoken-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jsonwebtoken-devel}"
SRC_URI[aarch64_rust-jsonwebtoken-devel.sha256sum] = "ef9b0746ff8f2fc560d557879e4a95ef7fda3c62532a6a43e4faba6e13055e8f"

RDEPENDS:rust-jsonwebtoken+default-devel = " \
 cargo \
 rust-jsonwebtoken+use_pem-devel \
 rust-jsonwebtoken-devel \
 "
RDEPENDS:rust-jsonwebtoken+pem-devel = " \
 cargo \
 rust-jsonwebtoken-devel \
 rust-pem+default-devel \
 "
RDEPENDS:rust-jsonwebtoken+simple_asn1-devel = " \
 cargo \
 rust-jsonwebtoken-devel \
 rust-simple_asn1+default-devel \
 "
RDEPENDS:rust-jsonwebtoken+use_pem-devel = " \
 cargo \
 rust-jsonwebtoken+pem-devel \
 rust-jsonwebtoken+simple_asn1-devel \
 rust-jsonwebtoken-devel \
 "
RDEPENDS:rust-jsonwebtoken-devel = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-ring+default-devel \
 rust-ring+std-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
