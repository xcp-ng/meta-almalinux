# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm"
PV = "7.2.0"
PR = "4.el10_3"
PACKAGES:x86_64_v2 = " \
 rocm \
 rocm-devel \
 rocm-test \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-7.2.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0516f6076968a174d022ae8477f689a1bf12046a40db2b5bb869086f970c4442"

URI_x86_64_v2_rocm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-7.2.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm}"
SRC_URI[x86_64_v2_rocm.sha256sum] = "b18e34c7edda21afb6bd1cf691b5c3ff29c7172205028eb10bec93d55176c2b9"

URI_x86_64_v2_rocm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-devel-7.2.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-devel}"
SRC_URI[x86_64_v2_rocm-devel.sha256sum] = "e6e53415d1854bf19ca8df66eafcc3ebe777a45a875079beca077df3ec05e0e8"

URI_x86_64_v2_rocm-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-test-7.2.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-test}"
SRC_URI[x86_64_v2_rocm-test.sha256sum] = "6d5cb9beac312d5fdfd778d983f79732bbf947531b12aa50f338b48761e844e3"

RDEPENDS:rocm = " \
 amdsmi \
 hipblas \
 hipcc \
 hipfft \
 hiprand \
 hipsolver \
 hipsparse \
 rocblas \
 rocfft \
 rocm-clang \
 rocm-hip \
 rocm-runtime \
 rocm-smi \
 rocminfo \
 rocrand \
 rocsolver \
 rocsparse \
 "
RDEPENDS:rocm-devel = " \
 amdsmi-devel \
 half-devel \
 hipblas-common-devel \
 hipblas-devel \
 hipcub-devel \
 hipfft-devel \
 hiprand-devel \
 hipsolver-devel \
 hipsparse-devel \
 rocblas-devel \
 rocfft-devel \
 rocm-clang-devel \
 rocm-cmake \
 rocm-compilersupport-macros \
 rocm-hip-devel \
 rocm-rpm-macros \
 rocm-rpm-macros-modules \
 rocm-runtime-devel \
 rocm-smi-devel \
 rocprim-devel \
 rocrand-devel \
 rocsolver-devel \
 rocsparse-devel \
 "
RDEPENDS:rocm-test = " \
 kfdtest \
 "
