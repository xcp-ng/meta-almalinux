# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-take_mut"
PV = "0.2.2"
PR = "21.el10_1"
PACKAGES = " \
 rust-take_mut+default-devel \
 rust-take_mut-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-take_mut-0.2.2-21.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22fb630803068c2dd9e1ef1272385ff60b166261361ea6436af58a1442c01116"

URI_x86_64_v2_rust-take_mut+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-take_mut+default-devel-0.2.2-21.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-take_mut+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-take_mut+default-devel}"
SRC_URI[x86_64_v2_rust-take_mut+default-devel.sha256sum] = "6bb4d0f2ed836ffd366a8b60e43fb87d8869ede61595f5c45dbbd2ec8d25f436"

URI_x86_64_v2_rust-take_mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-take_mut-devel-0.2.2-21.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-take_mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-take_mut-devel}"
SRC_URI[x86_64_v2_rust-take_mut-devel.sha256sum] = "c8bc1f69fe06bb92b5e04682695b941ed17749ae8da5f78a0692cfd3bc2e149e"

URI_aarch64_rust-take_mut+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-take_mut+default-devel-0.2.2-21.el10_1.noarch.rpm;name=aarch64_rust-take_mut+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-take_mut+default-devel}"
SRC_URI[aarch64_rust-take_mut+default-devel.sha256sum] = "59206cc4ec3ad2d587561104e8772da8df8f3f4641379c5c9d455079c5bedfb3"

URI_aarch64_rust-take_mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-take_mut-devel-0.2.2-21.el10_1.noarch.rpm;name=aarch64_rust-take_mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-take_mut-devel}"
SRC_URI[aarch64_rust-take_mut-devel.sha256sum] = "ad10ab7f994d0b2e2f9564070e65132062aecefb584f44930c358a066d5507ed"

RDEPENDS:rust-take_mut+default-devel = " \
 cargo \
 rust-take_mut-devel \
 "
RDEPENDS:rust-take_mut-devel = " \
 cargo \
 "
