# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cgnslib"
PV = "4.5.0"
PR = "5.el10_1"
PACKAGES = " \
 cgnslib \
 cgnslib-common \
 cgnslib-devel \
 cgnslib-libs \
 cgnslib-mpich \
 cgnslib-mpich-devel \
 cgnslib-mpich-libs \
 cgnslib-openmpi \
 cgnslib-openmpi-devel \
 cgnslib-openmpi-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cgnslib-4.5.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8e3a56d3652f6d0426e01b8e4dd2c03f008800fe1b2a5b9238c28b60c382e71"

URI_x86_64_v2_cgnslib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-4.5.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib}"
SRC_URI[x86_64_v2_cgnslib.sha256sum] = "23bc4a661ce97d159f85016fa70cb8b669c5c84143bcc275db836ba9b3f543c2"

URI_x86_64_v2_cgnslib-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-common-4.5.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_cgnslib-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-common}"
SRC_URI[x86_64_v2_cgnslib-common.sha256sum] = "3ea25e695e22be4e816f8e7c821ce9f883068111a9590f970553da1ae5da08a5"

URI_x86_64_v2_cgnslib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-devel-4.5.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-devel}"
SRC_URI[x86_64_v2_cgnslib-devel.sha256sum] = "69cf0355d4f44d390297c21fdd973409c44f54d8e4d577451f488c379d979b1c"

URI_x86_64_v2_cgnslib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-libs-4.5.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-libs}"
SRC_URI[x86_64_v2_cgnslib-libs.sha256sum] = "b2e835a4b45f8c8fb9fd46137d7b17c224520f7e9b1ea6a44ccabe1696adb976"

URI_x86_64_v2_cgnslib-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-mpich-4.5.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-mpich}"
SRC_URI[x86_64_v2_cgnslib-mpich.sha256sum] = "6048763625a1cb1ebb8a9b8ac42e3cef9608c6e76e73b58623e5fee5d813c750"

URI_x86_64_v2_cgnslib-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-mpich-devel-4.5.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-mpich-devel}"
SRC_URI[x86_64_v2_cgnslib-mpich-devel.sha256sum] = "b6b2148e03a0d9aae2c306a320f2807345735d869a8f5a15d99dd1d3a4be01de"

URI_x86_64_v2_cgnslib-mpich-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-mpich-libs-4.5.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-mpich-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-mpich-libs}"
SRC_URI[x86_64_v2_cgnslib-mpich-libs.sha256sum] = "acb691019d91a967cf9961e4c4e45deb0f1fbdb032b364d415f7a3a7107677e4"

URI_x86_64_v2_cgnslib-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-openmpi-4.5.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-openmpi}"
SRC_URI[x86_64_v2_cgnslib-openmpi.sha256sum] = "2ca9a31d9249fc6dc8dc87402e8c63a60f6616ec52452133159fda0ba57d19cb"

URI_x86_64_v2_cgnslib-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-openmpi-devel-4.5.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-openmpi-devel}"
SRC_URI[x86_64_v2_cgnslib-openmpi-devel.sha256sum] = "0499a5c40ccf989a08fa64fc1396760b4f9ee6a9bf01c4d645d63e070615275f"

URI_x86_64_v2_cgnslib-openmpi-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-openmpi-libs-4.5.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-openmpi-libs}"
SRC_URI[x86_64_v2_cgnslib-openmpi-libs.sha256sum] = "b96d1a55b252009875ef0d999654f3d99399711570d9497bc2fad485c56b0e5c"

URI_aarch64_cgnslib = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-4.5.0-5.el10_1.aarch64.rpm;name=aarch64_cgnslib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib}"
SRC_URI[aarch64_cgnslib.sha256sum] = "8e071cb6b57f5f1772c042e330211430c2b2e7ce0823f888d4eb397aaaaa1ae4"

URI_aarch64_cgnslib-common = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-common-4.5.0-5.el10_1.noarch.rpm;name=aarch64_cgnslib-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-common}"
SRC_URI[aarch64_cgnslib-common.sha256sum] = "a2859bf1bc2c6e2f61360abb3891e7fc216a9ded13575d08a5384e723202f00f"

URI_aarch64_cgnslib-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-devel-4.5.0-5.el10_1.aarch64.rpm;name=aarch64_cgnslib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-devel}"
SRC_URI[aarch64_cgnslib-devel.sha256sum] = "7757789a93d1e2f12385dca3ff23a91271f4b4cfde1888c8f5d90ae352674e91"

URI_aarch64_cgnslib-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-libs-4.5.0-5.el10_1.aarch64.rpm;name=aarch64_cgnslib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-libs}"
SRC_URI[aarch64_cgnslib-libs.sha256sum] = "c498cc8521de7ab4fc913297c7f8b5e1e190c784fcdaa8e6e123cab2a35da613"

URI_aarch64_cgnslib-mpich = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-mpich-4.5.0-5.el10_1.aarch64.rpm;name=aarch64_cgnslib-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-mpich}"
SRC_URI[aarch64_cgnslib-mpich.sha256sum] = "5af0dd718cc1c86679d49cfdefc2544a25699394a6d8462e6764f7775c7dc45c"

URI_aarch64_cgnslib-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-mpich-devel-4.5.0-5.el10_1.aarch64.rpm;name=aarch64_cgnslib-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-mpich-devel}"
SRC_URI[aarch64_cgnslib-mpich-devel.sha256sum] = "405ae59602028a2cbd41fca5731c63d3b8dda9203f96528ec591338559d1a118"

URI_aarch64_cgnslib-mpich-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-mpich-libs-4.5.0-5.el10_1.aarch64.rpm;name=aarch64_cgnslib-mpich-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-mpich-libs}"
SRC_URI[aarch64_cgnslib-mpich-libs.sha256sum] = "682cec988894fcdea6af4561457823e9e796b25e328f11acc144e2c1e837f666"

URI_aarch64_cgnslib-openmpi = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-openmpi-4.5.0-5.el10_1.aarch64.rpm;name=aarch64_cgnslib-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-openmpi}"
SRC_URI[aarch64_cgnslib-openmpi.sha256sum] = "2b0ec43c9ed32114b324fc9f95839faa07e85b64a68f1bbe15f1a40b2bd95c8d"

URI_aarch64_cgnslib-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-openmpi-devel-4.5.0-5.el10_1.aarch64.rpm;name=aarch64_cgnslib-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-openmpi-devel}"
SRC_URI[aarch64_cgnslib-openmpi-devel.sha256sum] = "33546b9ddef81bf4d9942772516411b0f72f5f6df5beeb34e9b2186245c65bfc"

URI_aarch64_cgnslib-openmpi-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-openmpi-libs-4.5.0-5.el10_1.aarch64.rpm;name=aarch64_cgnslib-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-openmpi-libs}"
SRC_URI[aarch64_cgnslib-openmpi-libs.sha256sum] = "674aab1ae3574abdaea33698b10d7d1b8c47b84292b91b1605c059878ac55753"

RDEPENDS:cgnslib = " \
 bash \
 cgnslib-common \
 cgnslib-libs \
 glibc \
 hdf5 \
 libX11 \
 libXmu \
 libglvnd-glx \
 libglvnd-opengl \
 mesa-libGLU \
 tcl \
 tk \
 "
RDEPENDS:cgnslib-common = " \
 "
RDEPENDS:cgnslib-devel = " \
 cgnslib \
 cmake-filesystem \
 gcc-gfortran \
 hdf5-devel \
 "
RDEPENDS:cgnslib-libs:x86_64_v2 = " \
 glibc \
 hdf5 \
 libgcc \
 libgfortran \
"
RDEPENDS:cgnslib-libs:aarch64 = " \
 glibc \
 hdf5 \
 libgfortran \
"
RDEPENDS:cgnslib-mpich = " \
 bash \
 cgnslib-common \
 cgnslib-mpich-libs \
 glibc \
 libX11 \
 libXmu \
 libglvnd-glx \
 libglvnd-opengl \
 mesa-libGLU \
 tcl \
 tk \
 "
RDEPENDS:cgnslib-mpich-devel = " \
 cgnslib-mpich \
 mpich-devel \
 "
RDEPENDS:cgnslib-mpich-libs:x86_64_v2 = " \
 glibc \
 hdf5-mpich \
 libgcc \
 libgfortran \
 mpich \
"
RDEPENDS:cgnslib-mpich-libs:aarch64 = " \
 glibc \
 hdf5-mpich \
 libgfortran \
 mpich \
"
RDEPENDS:cgnslib-openmpi = " \
 bash \
 cgnslib-common \
 cgnslib-openmpi-libs \
 glibc \
 libX11 \
 libXmu \
 libglvnd-glx \
 libglvnd-opengl \
 mesa-libGLU \
 tcl \
 tk \
 "
RDEPENDS:cgnslib-openmpi-devel = " \
 cgnslib-openmpi \
 openmpi-devel \
 "
RDEPENDS:cgnslib-openmpi-libs:x86_64_v2 = " \
 glibc \
 hdf5-openmpi \
 libgcc \
 libgfortran \
 openmpi \
"
RDEPENDS:cgnslib-openmpi-libs:aarch64 = " \
 glibc \
 hdf5-openmpi \
 libgfortran \
 openmpi \
"
