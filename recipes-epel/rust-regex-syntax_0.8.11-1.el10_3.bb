# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-syntax"
PV = "0.8.11"
PR = "1.el10_3"
PACKAGES = " \
 rust-regex-syntax+arbitrary-devel \
 rust-regex-syntax+default-devel \
 rust-regex-syntax+std-devel \
 rust-regex-syntax+unicode-age-devel \
 rust-regex-syntax+unicode-bool-devel \
 rust-regex-syntax+unicode-case-devel \
 rust-regex-syntax+unicode-devel \
 rust-regex-syntax+unicode-gencat-devel \
 rust-regex-syntax+unicode-perl-devel \
 rust-regex-syntax+unicode-script-devel \
 rust-regex-syntax+unicode-segment-devel \
 rust-regex-syntax-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-syntax-0.8.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78f9a4efef18496a275490e566d3f12d7273968a450d7b9b054c7d0ffd7f12cc"

URI_x86_64_v2_rust-regex-syntax+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+arbitrary-devel-0.8.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+arbitrary-devel.sha256sum] = "75771a7a38ca4246dad81556a45dd3cd1309202e93769f46a0fb391de3a8e217"

URI_x86_64_v2_rust-regex-syntax+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+default-devel-0.8.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+default-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+default-devel.sha256sum] = "cf3a9df8f9872dab020ac293bdf4e235a0b67bec6a97eb1a98fdfb15477b248a"

URI_x86_64_v2_rust-regex-syntax+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+std-devel-0.8.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+std-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+std-devel.sha256sum] = "b2da6e8f9268780284aaa27e17d3636621b00fb3a27b0960bc80b123636faa62"

URI_x86_64_v2_rust-regex-syntax+unicode-age-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-age-devel-0.8.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-age-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-age-devel.sha256sum] = "e3b57ae1f2de15530186106f97ac6584693f879594bba75ac48342b92be7d365"

URI_x86_64_v2_rust-regex-syntax+unicode-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-bool-devel-0.8.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-bool-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-bool-devel.sha256sum] = "364bbcec8e7dae95b17fe79b0e954c877215de04d7aaee7fbfba5232180558c3"

URI_x86_64_v2_rust-regex-syntax+unicode-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-case-devel-0.8.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-case-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-case-devel.sha256sum] = "5bd99ce764b3ea16ccaf44109faeb0fa5ba16bd85348b8bfa078c313c81a7338"

URI_x86_64_v2_rust-regex-syntax+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-devel-0.8.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-devel.sha256sum] = "10ccd3d185b3c61d21ef8620804cbfe3a9d1b61ac2fb878d845971bf27233c47"

URI_x86_64_v2_rust-regex-syntax+unicode-gencat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-gencat-devel-0.8.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-gencat-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-gencat-devel.sha256sum] = "fb38e8a7e8abe6795b9805f4cd7084b20d6dc0ae6483b4d63e14501e1aa6c9a4"

URI_x86_64_v2_rust-regex-syntax+unicode-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-perl-devel-0.8.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-perl-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-perl-devel.sha256sum] = "fd813b3e9c3273c1d7e6098969a58526200960296afc665b8e1209ec72c42bc9"

URI_x86_64_v2_rust-regex-syntax+unicode-script-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-script-devel-0.8.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-script-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-script-devel.sha256sum] = "c8893da670cf6ef588bc64bba046b904b87763c872c635fc6e918b43801f6aa0"

URI_x86_64_v2_rust-regex-syntax+unicode-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-segment-devel-0.8.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-segment-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-segment-devel.sha256sum] = "bcc2a076d3a2e3915a5a227e389d17d3a3290e147fa4df73c96a7f8eacf00e8c"

URI_x86_64_v2_rust-regex-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax-devel-0.8.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax-devel.sha256sum] = "68e253fe8689f6b9d868d1be348fb01f1503b55a7f57461f3afb150238cd1195"

URI_aarch64_rust-regex-syntax+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+arbitrary-devel-0.8.11-1.el10_3.noarch.rpm;name=aarch64_rust-regex-syntax+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+arbitrary-devel}"
SRC_URI[aarch64_rust-regex-syntax+arbitrary-devel.sha256sum] = "df3e5cb6853d22be23e520474879523eb46001e640d1c050112315f4b5c65e54"

URI_aarch64_rust-regex-syntax+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+default-devel-0.8.11-1.el10_3.noarch.rpm;name=aarch64_rust-regex-syntax+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+default-devel}"
SRC_URI[aarch64_rust-regex-syntax+default-devel.sha256sum] = "7617fed2d2ea84e6c9787969f56f1594161bf93266aad3564ba9acac8bd9d1bf"

URI_aarch64_rust-regex-syntax+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+std-devel-0.8.11-1.el10_3.noarch.rpm;name=aarch64_rust-regex-syntax+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+std-devel}"
SRC_URI[aarch64_rust-regex-syntax+std-devel.sha256sum] = "88308e0877769d34c69d34890635adbb151435a3ad5f376b54dab0fc3867be02"

URI_aarch64_rust-regex-syntax+unicode-age-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-age-devel-0.8.11-1.el10_3.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-age-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-age-devel.sha256sum] = "4192da4380f76c83a1357824b60ae20882a4be17479be1a90338d46ddd9196ab"

URI_aarch64_rust-regex-syntax+unicode-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-bool-devel-0.8.11-1.el10_3.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-bool-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-bool-devel.sha256sum] = "f891e3957d7e70cff4dcd717cac08d5fa75c0789273e94cf54f5a1f15a6d1a61"

URI_aarch64_rust-regex-syntax+unicode-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-case-devel-0.8.11-1.el10_3.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-case-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-case-devel.sha256sum] = "8a89c8f6e83ec0c4ec527ae93898f1719ed3aafbea646c2592549a0d78645590"

URI_aarch64_rust-regex-syntax+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-devel-0.8.11-1.el10_3.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-devel.sha256sum] = "75663f87d5c8b61c978d5932f964da9a987a03929f961e5871fbf85eaca3ed40"

URI_aarch64_rust-regex-syntax+unicode-gencat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-gencat-devel-0.8.11-1.el10_3.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-gencat-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-gencat-devel.sha256sum] = "fa7447dcefb547dc6ef19d572f41444ad2c6a89174ab0db319f97b2ad8daab1c"

URI_aarch64_rust-regex-syntax+unicode-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-perl-devel-0.8.11-1.el10_3.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-perl-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-perl-devel.sha256sum] = "2f80e70ddec6a4fafaf65b40e5684d04a18ec64dabfa26e1607a182d233ed91a"

URI_aarch64_rust-regex-syntax+unicode-script-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-script-devel-0.8.11-1.el10_3.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-script-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-script-devel.sha256sum] = "b64004c77ed1b3bdd542e397800269b004dc4fbd5e8afb332a1322882c2b0f49"

URI_aarch64_rust-regex-syntax+unicode-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-segment-devel-0.8.11-1.el10_3.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-segment-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-segment-devel.sha256sum] = "2ad472d3c530cb7d9eb8432bc9f2eb8e24001233955c2a6e22be78cbb0c9f3d5"

URI_aarch64_rust-regex-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax-devel-0.8.11-1.el10_3.noarch.rpm;name=aarch64_rust-regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax-devel}"
SRC_URI[aarch64_rust-regex-syntax-devel.sha256sum] = "c865c1c275de43205ffe001bbf9add6b3ef5d904f916d32f9606619d28779615"

RDEPENDS:rust-regex-syntax+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+default-devel = " \
 cargo \
 rust-regex-syntax+std-devel \
 rust-regex-syntax+unicode-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+std-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-age-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-bool-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-case-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-devel = " \
 cargo \
 rust-regex-syntax+unicode-age-devel \
 rust-regex-syntax+unicode-bool-devel \
 rust-regex-syntax+unicode-case-devel \
 rust-regex-syntax+unicode-gencat-devel \
 rust-regex-syntax+unicode-perl-devel \
 rust-regex-syntax+unicode-script-devel \
 rust-regex-syntax+unicode-segment-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-gencat-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-perl-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-script-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-segment-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax-devel = " \
 cargo \
 rust \
 "
