# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdegraphics-thumbnailers"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kdegraphics-thumbnailers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdegraphics-thumbnailers-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "666bf995e636983d2f9805be2fc5176cd569ffc041c37809b21dfc702cee1ee2"

URI_x86_64_v2_kdegraphics-thumbnailers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-thumbnailers-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdegraphics-thumbnailers}"
SRC_URI[x86_64_v2_kdegraphics-thumbnailers.sha256sum] = "61cc6f3a44835279b23aa6ffa9294a916a0e076a8130ba35c14df480d4fdbce8"

URI_aarch64_kdegraphics-thumbnailers = "${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-thumbnailers-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kdegraphics-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdegraphics-thumbnailers}"
SRC_URI[aarch64_kdegraphics-thumbnailers.sha256sum] = "39c1eb7b607c84cdc8760f31a3a9f74da45916cfb3d5c47de6d93516822f5b54"

RDEPENDS:kdegraphics-thumbnailers = " \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libkdcraw \
 libkexiv2-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
