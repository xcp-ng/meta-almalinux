# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-pg"
PV = "1.5.4"
PR = "5.el10"
PACKAGES = " \
 rubygem-pg \
 rubygem-pg-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rubygem-pg-1.5.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba09ee4fc72ab9c58ab04409f0500ea6fda87440f84994247a29a5e4f7fb49b9"

URI_x86_64_v2_rubygem-pg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-pg-1.5.4-5.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-pg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-pg}"
SRC_URI[x86_64_v2_rubygem-pg.sha256sum] = "c0511dfc7f24a2a580e6881ecbc3fe54aad245edf824973b4545b251492290ac"

URI_x86_64_v2_rubygem-pg-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rubygem-pg-doc-1.5.4-5.el10.noarch.rpm;name=x86_64_v2_rubygem-pg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-pg-doc}"
SRC_URI[x86_64_v2_rubygem-pg-doc.sha256sum] = "31f6c5a7b548a0558bfa5e9016147f118efaba8acea1ec1f67692de065bd98ac"

URI_aarch64_rubygem-pg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-pg-1.5.4-5.el10.aarch64.rpm;name=aarch64_rubygem-pg;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-pg}"
SRC_URI[aarch64_rubygem-pg.sha256sum] = "3e57430b56f860935a71e720e45ca520f1520f128ace6281cea560ccf9608d45"

URI_aarch64_rubygem-pg-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rubygem-pg-doc-1.5.4-5.el10.noarch.rpm;name=aarch64_rubygem-pg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-pg-doc}"
SRC_URI[aarch64_rubygem-pg-doc.sha256sum] = "31f6c5a7b548a0558bfa5e9016147f118efaba8acea1ec1f67692de065bd98ac"

RDEPENDS:rubygem-pg = " \
 glibc \
 libpq \
 ruby-libs \
 rubygem-bigdecimal \
 rubygem-json \
 rubygems \
 "
RDEPENDS:rubygem-pg-doc = " \
 rubygem-pg \
 "
