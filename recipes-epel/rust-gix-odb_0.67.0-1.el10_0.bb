# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-odb"
PV = "0.67.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-odb+default-devel \
 rust-gix-odb+document-features-devel \
 rust-gix-odb+serde-devel \
 rust-gix-odb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-odb-0.67.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "509217e66039b46f1e7b9fcce2d279c21f02e4f526308fb050ec6534e6db9124"

URI_x86_64_v2_rust-gix-odb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+default-devel-0.67.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+default-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+default-devel.sha256sum] = "c8d3ef59524a4a981dc128daac52bcf6fd631256711fd40f28c11cbe47ba90bf"

URI_x86_64_v2_rust-gix-odb+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+document-features-devel-0.67.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+document-features-devel.sha256sum] = "96cf048f80805e44c6aa00d24ecd742929641ba4cd6c1d9bc2634c7f4049f42a"

URI_x86_64_v2_rust-gix-odb+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+serde-devel-0.67.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+serde-devel.sha256sum] = "ff888612b1eac046417f3c64db6bcc3a319fdb46ff5c7d86e812b61d38d3914b"

URI_x86_64_v2_rust-gix-odb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb-devel-0.67.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb-devel}"
SRC_URI[x86_64_v2_rust-gix-odb-devel.sha256sum] = "e90f8852356aab4ce0b09526e8100921a19eaac3a6aa11b597e2b1560646e4ce"

URI_aarch64_rust-gix-odb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+default-devel-0.67.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-odb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+default-devel}"
SRC_URI[aarch64_rust-gix-odb+default-devel.sha256sum] = "306f3635359743a9ec989b15ac1f081238eae7475c40b6058494ba41a1350f45"

URI_aarch64_rust-gix-odb+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+document-features-devel-0.67.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-odb+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+document-features-devel}"
SRC_URI[aarch64_rust-gix-odb+document-features-devel.sha256sum] = "82d758d29e550773d6782da96e8394d4f3db3f1e5304087a36f6c39400e1855d"

URI_aarch64_rust-gix-odb+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+serde-devel-0.67.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-odb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+serde-devel}"
SRC_URI[aarch64_rust-gix-odb+serde-devel.sha256sum] = "8c6e179cbdb95650fb6c609b625eda4092792f8b975d5ba547d22e3c545bc1f6"

URI_aarch64_rust-gix-odb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb-devel-0.67.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-odb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb-devel}"
SRC_URI[aarch64_rust-gix-odb-devel.sha256sum] = "64c72203182e842991f17056ba5ab1f76d99744ce8db9d720c52db3e96a1369b"

RDEPENDS:rust-gix-odb+default-devel = " \
 cargo \
 rust-gix-odb-devel \
 "
RDEPENDS:rust-gix-odb+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-odb-devel \
 "
RDEPENDS:rust-gix-odb+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-odb-devel \
 rust-gix-pack+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-odb-devel = " \
 cargo \
 rust \
 rust-arc-swap+default-devel \
 rust-gix-date+default-devel \
 rust-gix-features+crc32-devel \
 rust-gix-features+default-devel \
 rust-gix-features+rustsha1-devel \
 rust-gix-features+walkdir-devel \
 rust-gix-features+zlib-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-object+default-devel \
 rust-gix-pack-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-parking_lot+default-devel \
 rust-tempfile+default-devel \
 rust-thiserror+default-devel \
 "
