# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-termcolor"
PV = "2.5.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-termcolor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-termcolor-2.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8926c804be0ca87fc9dd4c9ff5bf303fa1ba8b2807cb45f896beff000218cef6"

URI_x86_64_v2_python3-termcolor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-termcolor-2.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-termcolor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-termcolor}"
SRC_URI[x86_64_v2_python3-termcolor.sha256sum] = "1670b41fafc331a01971f15d2f4072affc3dd073646787eee06372dd3a4d01c1"

URI_aarch64_python3-termcolor = "${EPEL_MIRROR}/aarch64/Packages/p/python3-termcolor-2.5.0-1.el10_0.noarch.rpm;name=aarch64_python3-termcolor;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-termcolor}"
SRC_URI[aarch64_python3-termcolor.sha256sum] = "24ea6ecb20ec1cacc202cf3884dd4228ad8c314af8eca60da45b97c5668de565"

RDEPENDS:python3-termcolor = " \
 python3 \
 "
