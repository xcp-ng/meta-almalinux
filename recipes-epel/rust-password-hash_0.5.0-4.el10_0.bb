# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-password-hash"
PV = "0.5.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-password-hash+alloc-devel \
 rust-password-hash+default-devel \
 rust-password-hash+getrandom-devel \
 rust-password-hash+rand_core-devel \
 rust-password-hash+std-devel \
 rust-password-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-password-hash-0.5.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2a116c918b0b17a3d15e32f31b12456e11d38a288cb3ed7b90cd5d922280916"

URI_x86_64_v2_rust-password-hash+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash+alloc-devel-0.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash+alloc-devel}"
SRC_URI[x86_64_v2_rust-password-hash+alloc-devel.sha256sum] = "7572024d5ad3a0da9b6ec8377e491101ade34b445a1ae122047f70ef1afe962c"

URI_x86_64_v2_rust-password-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash+default-devel-0.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash+default-devel}"
SRC_URI[x86_64_v2_rust-password-hash+default-devel.sha256sum] = "e9000254b75147a07dfe81de6a4ea9c316099dffa3e4b3067a56454ecf792bd7"

URI_x86_64_v2_rust-password-hash+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash+getrandom-devel-0.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash+getrandom-devel}"
SRC_URI[x86_64_v2_rust-password-hash+getrandom-devel.sha256sum] = "1c1244ecdcff965dc1367588223927d2d79852568844844d0e906acf7f8f91dd"

URI_x86_64_v2_rust-password-hash+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash+rand_core-devel-0.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash+rand_core-devel}"
SRC_URI[x86_64_v2_rust-password-hash+rand_core-devel.sha256sum] = "efac9c79bbf480e4d536c8ede32077d29cf92012e8f94b74799c987d0fb3e740"

URI_x86_64_v2_rust-password-hash+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash+std-devel-0.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash+std-devel}"
SRC_URI[x86_64_v2_rust-password-hash+std-devel.sha256sum] = "1ab671128fb2b19ef80894caa4a30b23e37aad2a8b03e029304af9e602da32e7"

URI_x86_64_v2_rust-password-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-password-hash-devel-0.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-password-hash-devel}"
SRC_URI[x86_64_v2_rust-password-hash-devel.sha256sum] = "e694927912ff4d40e4b7807b2c315d7a4e29c1dbcfd0bac0030b54b7bab6c525"

URI_aarch64_rust-password-hash+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash+alloc-devel-0.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-password-hash+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash+alloc-devel}"
SRC_URI[aarch64_rust-password-hash+alloc-devel.sha256sum] = "f0970377450036d600e017c5d9b3881fcbb113f01c11c0d6ca520955c95fef26"

URI_aarch64_rust-password-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash+default-devel-0.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-password-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash+default-devel}"
SRC_URI[aarch64_rust-password-hash+default-devel.sha256sum] = "32c35b94d032be29825cbbd9cae26f755671c2ee7e8000ffcc64be32aba889cb"

URI_aarch64_rust-password-hash+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash+getrandom-devel-0.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-password-hash+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash+getrandom-devel}"
SRC_URI[aarch64_rust-password-hash+getrandom-devel.sha256sum] = "4e47c8ca855e49660b057615c9e77b8b14fdb12e6986b2dc684b50a470fb0d00"

URI_aarch64_rust-password-hash+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash+rand_core-devel-0.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-password-hash+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash+rand_core-devel}"
SRC_URI[aarch64_rust-password-hash+rand_core-devel.sha256sum] = "cc6aa45c2f9e9b67d2307864f4d35abe8e815387a63c36dd085cfc5c208161d4"

URI_aarch64_rust-password-hash+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash+std-devel-0.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-password-hash+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash+std-devel}"
SRC_URI[aarch64_rust-password-hash+std-devel.sha256sum] = "b162b1bebb64cb0924a3bbca0e3d819a8db4e242258bb24e4488e535fae9478c"

URI_aarch64_rust-password-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-password-hash-devel-0.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-password-hash-devel}"
SRC_URI[aarch64_rust-password-hash-devel.sha256sum] = "6fb7e218f03f8a40b4f93e20b60d521df9904d2b2bfa6abed322bf474d9c186a"

RDEPENDS:rust-password-hash+alloc-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-password-hash-devel \
 "
RDEPENDS:rust-password-hash+default-devel = " \
 cargo \
 rust-password-hash+rand_core-devel \
 rust-password-hash-devel \
 "
RDEPENDS:rust-password-hash+getrandom-devel = " \
 cargo \
 rust-password-hash-devel \
 rust-rand_core0.6+getrandom-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-password-hash+rand_core-devel = " \
 cargo \
 rust-password-hash-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-password-hash+std-devel = " \
 cargo \
 rust-base64ct+std-devel \
 rust-password-hash+alloc-devel \
 rust-password-hash-devel \
 rust-rand_core0.6+std-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-password-hash-devel = " \
 cargo \
 rust \
 rust-base64ct+default-devel \
 rust-subtle-devel \
 "
