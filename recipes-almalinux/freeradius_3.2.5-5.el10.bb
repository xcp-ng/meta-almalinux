# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freeradius"
PV = "3.2.5"
PR = "5.el10"
PACKAGES = " \
 freeradius \
 freeradius-devel \
 freeradius-doc \
 freeradius-krb5 \
 freeradius-ldap \
 freeradius-mysql \
 freeradius-perl \
 freeradius-postgresql \
 freeradius-rest \
 freeradius-sqlite \
 freeradius-unixODBC \
 freeradius-utils \
 python3-freeradius \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freeradius-3.2.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78e4b798139bc8756fe29b32c3dbe7085078fc08d047200fb9a8cb05281e4738"

URI_x86_64_v2_freeradius = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeradius-3.2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius}"
SRC_URI[x86_64_v2_freeradius.sha256sum] = "51fb57e6a282fe99a764d21f6b78080ef80f78dc24840e283ef43d606ac1dc6a"

URI_x86_64_v2_freeradius-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeradius-devel-3.2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-devel}"
SRC_URI[x86_64_v2_freeradius-devel.sha256sum] = "e6d0f4f564a501003ee394934dc9983b6f6edaf5c772264b2c441ac9ad7d35bf"

URI_x86_64_v2_freeradius-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeradius-doc-3.2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-doc}"
SRC_URI[x86_64_v2_freeradius-doc.sha256sum] = "4734a44baf1a593442bdafc5b7c6692914ee9791e016d9d3c42f9f8fb1a8cd0d"

URI_x86_64_v2_freeradius-krb5 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeradius-krb5-3.2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-krb5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-krb5}"
SRC_URI[x86_64_v2_freeradius-krb5.sha256sum] = "12e490ac1e53ff2f54e4a09a4c28b199da0ec63acafc9e48b7bb4c45ae629799"

URI_x86_64_v2_freeradius-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeradius-ldap-3.2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-ldap}"
SRC_URI[x86_64_v2_freeradius-ldap.sha256sum] = "4a25c3abf38a8ba50c6b80470d9f4f3f944950fe3fa51db315bffcb78252d7d1"

URI_x86_64_v2_freeradius-mysql = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeradius-mysql-3.2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-mysql}"
SRC_URI[x86_64_v2_freeradius-mysql.sha256sum] = "9ca565018e99cdd80bd266a2cfdfb53c1c210de74afc01a8675491ed70caa41d"

URI_x86_64_v2_freeradius-perl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeradius-perl-3.2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-perl}"
SRC_URI[x86_64_v2_freeradius-perl.sha256sum] = "7d60ae7c1d7569a3230a62ec535c0954cd53c717b4012259b1feca64ad55b1f7"

URI_x86_64_v2_freeradius-postgresql = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeradius-postgresql-3.2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-postgresql}"
SRC_URI[x86_64_v2_freeradius-postgresql.sha256sum] = "ce1a2b20d2a54ce55f34570dc491db51c6ed9cd43be14f9b64d1182c244b0304"

URI_x86_64_v2_freeradius-rest = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeradius-rest-3.2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-rest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-rest}"
SRC_URI[x86_64_v2_freeradius-rest.sha256sum] = "1bb1755426156b6f3d116c0a579322dd40b41326cbd60b4a2a8cc3beaa9dcedc"

URI_x86_64_v2_freeradius-sqlite = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeradius-sqlite-3.2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-sqlite}"
SRC_URI[x86_64_v2_freeradius-sqlite.sha256sum] = "2c025aec1dbbba4206a8c095ca354fbfcef3f641dbcd34c6eb35792341a08215"

URI_x86_64_v2_freeradius-unixODBC = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeradius-unixODBC-3.2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-unixODBC;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-unixODBC}"
SRC_URI[x86_64_v2_freeradius-unixODBC.sha256sum] = "0cc0ccbf2ace22aef58ff2c6aa4e7e2c8306883f6947eecb57f862c79d8b7f15"

URI_x86_64_v2_freeradius-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeradius-utils-3.2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-utils}"
SRC_URI[x86_64_v2_freeradius-utils.sha256sum] = "c172c79365d550e7a09ba0d7f314beeeb3ad15ed983fd6915422f3166216a432"

URI_x86_64_v2_python3-freeradius = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-freeradius-3.2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-freeradius;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-freeradius}"
SRC_URI[x86_64_v2_python3-freeradius.sha256sum] = "092a70415c4ff585ff0ff21209c78e31e4eb11f966e5567603384d5f595e60ce"

URI_aarch64_freeradius = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeradius-3.2.5-5.el10.aarch64.rpm;name=aarch64_freeradius;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius}"
SRC_URI[aarch64_freeradius.sha256sum] = "9db904948ab4ebca05804dabf9115253a4e5f8cc68eb73c2b9c9046e245310f0"

URI_aarch64_freeradius-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeradius-devel-3.2.5-5.el10.aarch64.rpm;name=aarch64_freeradius-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-devel}"
SRC_URI[aarch64_freeradius-devel.sha256sum] = "762fb5fd8346d6059bca693ab634d5f381d5fe68d30ed63509ac4b80db79639f"

URI_aarch64_freeradius-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeradius-doc-3.2.5-5.el10.aarch64.rpm;name=aarch64_freeradius-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-doc}"
SRC_URI[aarch64_freeradius-doc.sha256sum] = "c779bc5d61f14fa8907d4168d5a4f4cc8ad171763391344bd0989fedc3890900"

URI_aarch64_freeradius-krb5 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeradius-krb5-3.2.5-5.el10.aarch64.rpm;name=aarch64_freeradius-krb5;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-krb5}"
SRC_URI[aarch64_freeradius-krb5.sha256sum] = "1b9b1a2924d7b2f26316d9c4b5bbc54df5d07b4c13063f5ca0193fcc7ea0d065"

URI_aarch64_freeradius-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeradius-ldap-3.2.5-5.el10.aarch64.rpm;name=aarch64_freeradius-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-ldap}"
SRC_URI[aarch64_freeradius-ldap.sha256sum] = "b6de89460fd674758d5206641a01104b51aed98e6c6d671e027462d497b26ba6"

URI_aarch64_freeradius-mysql = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeradius-mysql-3.2.5-5.el10.aarch64.rpm;name=aarch64_freeradius-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-mysql}"
SRC_URI[aarch64_freeradius-mysql.sha256sum] = "196717924cacd5594a37dd09e13463fcfd1ae4303cf24c6f41cad374ce8f1d69"

URI_aarch64_freeradius-perl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeradius-perl-3.2.5-5.el10.aarch64.rpm;name=aarch64_freeradius-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-perl}"
SRC_URI[aarch64_freeradius-perl.sha256sum] = "da0b3ca708bd502c69e5bddffe4ecc1b4c565e9796bf0b969ca2ce5033157b9b"

URI_aarch64_freeradius-postgresql = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeradius-postgresql-3.2.5-5.el10.aarch64.rpm;name=aarch64_freeradius-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-postgresql}"
SRC_URI[aarch64_freeradius-postgresql.sha256sum] = "ff7e5f17d82e69a025511c5da4d10f063c64850c3257b521670e2555c8e2b4c7"

URI_aarch64_freeradius-rest = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeradius-rest-3.2.5-5.el10.aarch64.rpm;name=aarch64_freeradius-rest;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-rest}"
SRC_URI[aarch64_freeradius-rest.sha256sum] = "81ba974dea2314c7812111f096cad743f7b490f20245bb5a1472b937a0c8fc19"

URI_aarch64_freeradius-sqlite = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeradius-sqlite-3.2.5-5.el10.aarch64.rpm;name=aarch64_freeradius-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-sqlite}"
SRC_URI[aarch64_freeradius-sqlite.sha256sum] = "6029f96ef1909fef20bd1f616ef5b2e5f24418e6d976ecd50ab3ee604c62103a"

URI_aarch64_freeradius-unixODBC = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeradius-unixODBC-3.2.5-5.el10.aarch64.rpm;name=aarch64_freeradius-unixODBC;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-unixODBC}"
SRC_URI[aarch64_freeradius-unixODBC.sha256sum] = "e869c7cd2064f1847b74c3b6d2780279e46f6431a37d1cd8255b805c9f091ee8"

URI_aarch64_freeradius-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeradius-utils-3.2.5-5.el10.aarch64.rpm;name=aarch64_freeradius-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-utils}"
SRC_URI[aarch64_freeradius-utils.sha256sum] = "b91bbec516d62c6413a4eaea876bcb7cb678f83e947d97b08865241f4ecefa19"

URI_aarch64_python3-freeradius = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-freeradius-3.2.5-5.el10.aarch64.rpm;name=aarch64_python3-freeradius;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-freeradius}"
SRC_URI[aarch64_python3-freeradius.sha256sum] = "a0aa2097731fbd6f8a714352315064e55c20a18001662bc795787b36765046bd"

RDEPENDS:freeradius = " \
 bash \
 gdbm-libs \
 glibc \
 glibc-common \
 json-c \
 libpcap \
 libtalloc \
 libxcrypt \
 make \
 openssl \
 openssl-libs \
 pam-libs \
 perl-interpreter \
 readline \
 shadow-utils \
 systemd \
 "
RDEPENDS:freeradius-devel = " \
 freeradius \
 "
RDEPENDS:freeradius-doc = " \
 "
RDEPENDS:freeradius-krb5 = " \
 freeradius \
 glibc \
 krb5-libs \
 libcom_err \
 "
RDEPENDS:freeradius-ldap = " \
 freeradius \
 glibc \
 openldap \
 "
RDEPENDS:freeradius-mysql = " \
 freeradius \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:freeradius-perl = " \
 freeradius \
 glibc \
 perl-libs \
 "
RDEPENDS:freeradius-postgresql = " \
 freeradius \
 glibc \
 libpq \
 "
RDEPENDS:freeradius-rest = " \
 freeradius \
 glibc \
 json-c \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:freeradius-sqlite = " \
 freeradius \
 glibc \
 sqlite-libs \
 "
RDEPENDS:freeradius-unixODBC = " \
 freeradius \
 glibc \
 unixODBC \
 "
RDEPENDS:freeradius-utils = " \
 bash \
 freeradius \
 gdbm-libs \
 glibc \
 libpcap \
 libtalloc \
 openssl-libs \
 perl-DBI \
 perl-Fcntl \
 perl-File-Basename \
 perl-GDBM_File \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-POSIX \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:python3-freeradius = " \
 freeradius \
 glibc \
 python3 \
 python3-libs \
 "
