# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-log"
PV = "8.1.1"
PR = "1.el10_3"
PACKAGES = " \
 python-oslo-log-doc \
 python-oslo-log-lang \
 python3-oslo-log \
 python3-oslo-log-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-oslo-log-8.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "977a5c474a63e74199a9b3097689980dc086e211e8a2cf558c80058b3455b850"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-log-doc-8.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-log-doc;unpack=0"
SRC_URI[x86_64_v2_python-oslo-log-doc.sha256sum] = "81fbc7aa45ac7df4c94f65aea95191db395c3b5db2eb622dda71ee1d1357c30a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-log-lang-8.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-log-lang;unpack=0"
SRC_URI[x86_64_v2_python-oslo-log-lang.sha256sum] = "b67c85e7446bfabb3249e1454de0e2f59319bd7b92cf1b05ae5ae8b09dc5fc62"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-log-8.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-log;unpack=0"
SRC_URI[x86_64_v2_python3-oslo-log.sha256sum] = "14de22c36095d5dbcda9bd5c18500d9b91910f6a95f3d22c9de3544f9a472b4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-log-tests-8.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-log-tests;unpack=0"
SRC_URI[x86_64_v2_python3-oslo-log-tests.sha256sum] = "971b79037ec3f753a1924f1ca403d74f3fbc798a24db6cc3230a00cae22f689b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-log-doc-8.1.1-1.el10_3.noarch.rpm;name=aarch64_python-oslo-log-doc;unpack=0"
SRC_URI[aarch64_python-oslo-log-doc.sha256sum] = "59d06bc56552b091a3504e60709962d37cc2a922e46327905353d21f8b205bd5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-log-lang-8.1.1-1.el10_3.noarch.rpm;name=aarch64_python-oslo-log-lang;unpack=0"
SRC_URI[aarch64_python-oslo-log-lang.sha256sum] = "e8ff363115a9731a9edf1f370844cbafdba99d32db49cdbfe04bc57092aef9ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-log-8.1.1-1.el10_3.noarch.rpm;name=aarch64_python3-oslo-log;unpack=0"
SRC_URI[aarch64_python3-oslo-log.sha256sum] = "db2c121851b2132f0164a69f242b52d5b625ad5a612636f590b8ea3e9bfadc79"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-log-tests-8.1.1-1.el10_3.noarch.rpm;name=aarch64_python3-oslo-log-tests;unpack=0"
SRC_URI[aarch64_python3-oslo-log-tests.sha256sum] = "50e1eff6168f3eb64211ea3e26722fd011dca918f5c6ef8868ae7cc7f48a2f3f"

RDEPENDS:python-oslo-log-doc = " \
 "
RDEPENDS:python-oslo-log-lang = " \
 "
RDEPENDS:python3-oslo-log = " \
 python-oslo-log-lang \
 python3 \
 python3-dateutil \
 python3-debtcollector \
 python3-oslo-config \
 python3-oslo-context \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 "
RDEPENDS:python3-oslo-log-tests = " \
 python3 \
 python3-oslo-log \
 "
