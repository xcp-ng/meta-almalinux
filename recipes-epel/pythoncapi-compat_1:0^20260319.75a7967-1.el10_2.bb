# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pythoncapi-compat"
PE = "1"
PV = "0^20260319.75a7967"
PR = "1.el10_2"
PACKAGES = " \
 pythoncapi-compat-devel \
 pythoncapi-compat-doc \
 pythoncapi-compat-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pythoncapi-compat-0^20260319.75a7967-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9be9951eb09bef973c24295762730036281c221071dd7e735b76c8d8b863963"

URI_x86_64_v2_pythoncapi-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-devel-0^20260319.75a7967-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythoncapi-compat-devel}"
SRC_URI[x86_64_v2_pythoncapi-compat-devel.sha256sum] = "03e909a1b583f3c610981e03480dd391ec85c8200c05c3f382ebac4b7f32cd1d"

URI_x86_64_v2_pythoncapi-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-doc-0^20260319.75a7967-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythoncapi-compat-doc}"
SRC_URI[x86_64_v2_pythoncapi-compat-doc.sha256sum] = "bfb6f8ac361b1b74d3a425083121810cc3a9689427742fcd9d5308bb5e3a15c4"

URI_x86_64_v2_pythoncapi-compat-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-tools-0^20260319.75a7967-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythoncapi-compat-tools}"
SRC_URI[x86_64_v2_pythoncapi-compat-tools.sha256sum] = "5d095eb5e1a8700d0a990c6b09d6adafebb0c3b6fbceac64e4648155664a83de"

URI_aarch64_pythoncapi-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-devel-0^20260319.75a7967-1.el10_2.noarch.rpm;name=aarch64_pythoncapi-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythoncapi-compat-devel}"
SRC_URI[aarch64_pythoncapi-compat-devel.sha256sum] = "45345e1a3f6edaf9dc6309b6c26ee0196cf30706ff9349550be8b20f89b6a4db"

URI_aarch64_pythoncapi-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-doc-0^20260319.75a7967-1.el10_2.noarch.rpm;name=aarch64_pythoncapi-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythoncapi-compat-doc}"
SRC_URI[aarch64_pythoncapi-compat-doc.sha256sum] = "fe4a00a5f84472c7878c3027c2faaa09ad67f39e7b10d72b899d31836eb67f47"

URI_aarch64_pythoncapi-compat-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-tools-0^20260319.75a7967-1.el10_2.noarch.rpm;name=aarch64_pythoncapi-compat-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythoncapi-compat-tools}"
SRC_URI[aarch64_pythoncapi-compat-tools.sha256sum] = "bd091f69aa28a583104cac06da77f4f85495a846ff1824f96f6a8baedee24a13"

RDEPENDS:pythoncapi-compat-devel = " \
 "
RDEPENDS:pythoncapi-compat-doc = " \
 "
RDEPENDS:pythoncapi-compat-tools = " \
 python3 \
 "
