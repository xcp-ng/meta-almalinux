# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krdp"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 krdp \
 krdp-devel \
 krdp-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krdp-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "734687e171dc99e642efa4d8cd78f5e8a1cca6d7451adb3cfa746d4357fb62ad"

URI_x86_64_v2_krdp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdp}"
SRC_URI[x86_64_v2_krdp.sha256sum] = "e2e0cf59537a7afd22302a09db0c1e2ad585ec536d2c6af82665d05b5ba979a8"

URI_x86_64_v2_krdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdp-devel}"
SRC_URI[x86_64_v2_krdp-devel.sha256sum] = "ad48e58c7290650b7dd0f181819579ae1d71c094d3a3dff4dfe99e5401c1a9d1"

URI_x86_64_v2_krdp-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-libs-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdp-libs}"
SRC_URI[x86_64_v2_krdp-libs.sha256sum] = "979c92b8a7432c33bbb92c1bfb706c4625bdd89f2a02e5c976979044101fa0a2"

URI_aarch64_krdp = "${EPEL_MIRROR}/aarch64/Packages/k/krdp-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_krdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdp}"
SRC_URI[aarch64_krdp.sha256sum] = "7e150c6ec7f333d991489dc93c22f2b5eb13eb6f349ae92f9fbc7346421017e8"

URI_aarch64_krdp-devel = "${EPEL_MIRROR}/aarch64/Packages/k/krdp-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_krdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdp-devel}"
SRC_URI[aarch64_krdp-devel.sha256sum] = "ab8b6f0e8d30b250722544082be21bcf9c78fbfa49bfdfb94de2457672b8eb4a"

URI_aarch64_krdp-libs = "${EPEL_MIRROR}/aarch64/Packages/k/krdp-libs-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_krdp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdp-libs}"
SRC_URI[aarch64_krdp-libs.sha256sum] = "870ee100561c155f6c868efabd9b9be74bd04f19ffa41a3e6b4bb3b836d0316e"

RDEPENDS:krdp = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kstatusnotifieritem \
 kpipewire \
 krdp-libs \
 libstdc++ \
 openssl \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:krdp-devel = " \
 cmake-filesystem \
 krdp-libs \
 "
RDEPENDS:krdp-libs = " \
 freerdp \
 freerdp2-libs \
 glibc \
 kf6-kconfig \
 kpipewire \
 libstdc++ \
 libwayland-client \
 libwinpr2 \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwayland \
 "
