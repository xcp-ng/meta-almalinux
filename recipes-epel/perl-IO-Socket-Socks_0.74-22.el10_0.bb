# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Socket-Socks"
PV = "0.74"
PR = "22.el10_0"
PACKAGES = " \
 perl-IO-Socket-Socks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IO-Socket-Socks-0.74-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d182b1ada6aef6fe45f8e79084ca9beac6d55a8b8d6f78267940e4a74062bf6f"

URI_x86_64_v2_perl-IO-Socket-Socks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IO-Socket-Socks-0.74-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IO-Socket-Socks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Socket-Socks}"
SRC_URI[x86_64_v2_perl-IO-Socket-Socks.sha256sum] = "f131edf4cade1c8b5a54c6e6679a30ef6f8cbb351d0e9bb3613aad934f73f46e"

URI_aarch64_perl-IO-Socket-Socks = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IO-Socket-Socks-0.74-22.el10_0.noarch.rpm;name=aarch64_perl-IO-Socket-Socks;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Socket-Socks}"
SRC_URI[aarch64_perl-IO-Socket-Socks.sha256sum] = "b6f8ba52e840de1186deeba4b9e3ffec3fe247cc796b6a79b4521b0f2287d6fc"

RDEPENDS:perl-IO-Socket-Socks = " \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-IO \
 perl-IO-Socket-IP \
 perl-Socket \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-vars \
 "
