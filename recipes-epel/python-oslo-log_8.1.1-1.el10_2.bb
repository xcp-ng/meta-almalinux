# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-log"
PV = "8.1.1"
PR = "1.el10_2"
PACKAGES = " \
 python-oslo-log-doc \
 python-oslo-log-lang \
 python3-oslo-log \
 python3-oslo-log-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-oslo-log-8.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9c5644162384cc104af71df37aeab53cc9a1f0923638733751fa06318bed3458"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-log-doc-8.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-log-doc;unpack=0"
SRC_URI[x86_64_v2_python-oslo-log-doc.sha256sum] = "6647a88158523255f5ef8773bf0b7bad04306e23f3958a33f1378f1181be580f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-log-lang-8.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-log-lang;unpack=0"
SRC_URI[x86_64_v2_python-oslo-log-lang.sha256sum] = "330da1d3a1bd64f6f39cb748cf1cfb7adb4b8a12f0e2e40b371ad7471ebdb87b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-log-8.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-log;unpack=0"
SRC_URI[x86_64_v2_python3-oslo-log.sha256sum] = "3e2788e38b493ad63231ee429b7fb9dd949babcd918ca3396b2b91616830bf37"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-log-tests-8.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-log-tests;unpack=0"
SRC_URI[x86_64_v2_python3-oslo-log-tests.sha256sum] = "20280aa8c3308185847dd5e66ce418006262a51773382a4b94c1461ac27065a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-log-doc-8.1.1-1.el10_2.noarch.rpm;name=aarch64_python-oslo-log-doc;unpack=0"
SRC_URI[aarch64_python-oslo-log-doc.sha256sum] = "c9a17e8036b93725570623d29f3edc18a88ec2dbaa7bcedaa75b8f17927afde0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-log-lang-8.1.1-1.el10_2.noarch.rpm;name=aarch64_python-oslo-log-lang;unpack=0"
SRC_URI[aarch64_python-oslo-log-lang.sha256sum] = "4b2a6b9370f0b0302068445b73de6455711576b24406aca8fd46d9871a44626c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-log-8.1.1-1.el10_2.noarch.rpm;name=aarch64_python3-oslo-log;unpack=0"
SRC_URI[aarch64_python3-oslo-log.sha256sum] = "ec6eb2c978e7d1672d8403e53690fcaa9750a25cf3896fac89f7d5ae84d01482"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-log-tests-8.1.1-1.el10_2.noarch.rpm;name=aarch64_python3-oslo-log-tests;unpack=0"
SRC_URI[aarch64_python3-oslo-log-tests.sha256sum] = "2a8bc30f7e5650f9a4449572a1a567569cc2ee757bd31c1f7aebf0de18e145e5"

RDEPENDS:python-oslo-log-doc = " \
 "
RDEPENDS:python-oslo-log-lang = " \
 "
RDEPENDS:python3-oslo-log = " \
 python-oslo-log-lang \
 python3 \
 python3-dateutil \
 python3-debtcollector \
 python3-oslo-config \
 python3-oslo-context \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 "
RDEPENDS:python3-oslo-log-tests = " \
 python3 \
 python3-oslo-log \
 "
