# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scalasca"
PV = "2.6.2"
PR = "1.el10_1"
PACKAGES = " \
 scalasca \
 scalasca-doc \
 scalasca-mpich \
 scalasca-openmpi \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/scalasca-2.6.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e2b554fdb333315b900da1d07734087bb6fb75e5ec5da681cefcaa9e05f374af"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalasca-2.6.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalasca;unpack=0"
SRC_URI[x86_64_v2_scalasca.sha256sum] = "f53d4fe7a8558050528d431a6a5f646500ef9b4db550464bf344f4b6311198ac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalasca-doc-2.6.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_scalasca-doc;unpack=0"
SRC_URI[x86_64_v2_scalasca-doc.sha256sum] = "55ee28476edb40a7c8fcfbe997a9f6f2a92660c232c34c045f829f22df0a1d23"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalasca-mpich-2.6.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalasca-mpich;unpack=0"
SRC_URI[x86_64_v2_scalasca-mpich.sha256sum] = "205702f5962ec76b431326a789deb93bc91b3ca4c735e6ca26c5e1aa90fdb284"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalasca-openmpi-2.6.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalasca-openmpi;unpack=0"
SRC_URI[x86_64_v2_scalasca-openmpi.sha256sum] = "5b81c50e26141ce298641c5269b02703f1decc7a25148c47cc584457b198cccb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/scalasca-2.6.2-1.el10_1.aarch64.rpm;name=aarch64_scalasca;unpack=0"
SRC_URI[aarch64_scalasca.sha256sum] = "1385f4ba06eb3ba0d7c9ffec6cdf1019a58f0eca7a216928241cf4150c1cfb75"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/scalasca-doc-2.6.2-1.el10_1.noarch.rpm;name=aarch64_scalasca-doc;unpack=0"
SRC_URI[aarch64_scalasca-doc.sha256sum] = "826f92f14c85036cfb02800284e42ba8f49007be01c9bc03256ecbeef87e6c56"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/scalasca-mpich-2.6.2-1.el10_1.aarch64.rpm;name=aarch64_scalasca-mpich;unpack=0"
SRC_URI[aarch64_scalasca-mpich.sha256sum] = "e1b55c0d54761785e1d4130571846aedcad5711a1bc7744a2affb8a4222b9ada"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/scalasca-openmpi-2.6.2-1.el10_1.aarch64.rpm;name=aarch64_scalasca-openmpi;unpack=0"
SRC_URI[aarch64_scalasca-openmpi.sha256sum] = "73e87aece41b964799831bcb0645a8b316b3f68fe77d78f2ef7928c7f7f82fd2"

RDEPENDS:scalasca = " \
 bash \
 cube-libs \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 otf2 \
 scorep-config \
 zlib-ng-compat \
 "
RDEPENDS:scalasca-doc = " \
 "
RDEPENDS:scalasca-mpich = " \
 bash \
 cube-libs \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 mpich \
 otf2 \
 scorep-mpich-config \
 zlib-ng-compat \
 "
RDEPENDS:scalasca-openmpi = " \
 bash \
 cube-libs \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 openmpi \
 otf2 \
 scorep-openmpi-config \
 zlib-ng-compat \
 "
