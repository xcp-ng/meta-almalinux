# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jaraco-envs"
PV = "2.6.0"
PR = "6.el10_1"
PACKAGES = " \
 python3-jaraco-envs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jaraco-envs-2.6.0-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "441f242bd9a1d8363b95655276d8e8d7a4ba45e405cedcb262c9673bd39513a8"

URI_x86_64_v2_python3-jaraco-envs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jaraco-envs-2.6.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jaraco-envs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jaraco-envs}"
SRC_URI[x86_64_v2_python3-jaraco-envs.sha256sum] = "48daeca1f5a3096798686274daff14807ac86d791e839e627103f31529486cab"

URI_aarch64_python3-jaraco-envs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jaraco-envs-2.6.0-6.el10_1.noarch.rpm;name=aarch64_python3-jaraco-envs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jaraco-envs}"
SRC_URI[aarch64_python3-jaraco-envs.sha256sum] = "56fa5cbcd4115abf94802ad99fcea0f284606409f87b61552f37e2a934fe6183"

RDEPENDS:python3-jaraco-envs = " \
 python3 \
 python3-path \
 python3-virtualenv \
 tox \
 "
