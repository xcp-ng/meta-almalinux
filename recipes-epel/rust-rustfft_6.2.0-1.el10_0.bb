# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustfft"
PV = "6.2.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-rustfft+avx-devel \
 rust-rustfft+default-devel \
 rust-rustfft+neon-devel \
 rust-rustfft+sse-devel \
 rust-rustfft-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustfft-6.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a49ec49164592698411a2650e81714074675be6323d5d28757f18193043b626"

URI_x86_64_v2_rust-rustfft+avx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfft+avx-devel-6.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfft+avx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustfft+avx-devel}"
SRC_URI[x86_64_v2_rust-rustfft+avx-devel.sha256sum] = "91f0e3eb145cf45337633df2afb727cb038307e3e32be8c863f4a88ac3c3f584"

URI_x86_64_v2_rust-rustfft+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfft+default-devel-6.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfft+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustfft+default-devel}"
SRC_URI[x86_64_v2_rust-rustfft+default-devel.sha256sum] = "657036ce7d7fb63973256152561d7ee5f2870c988d18698ebb1e77cf254a5f44"

URI_x86_64_v2_rust-rustfft+neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfft+neon-devel-6.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfft+neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustfft+neon-devel}"
SRC_URI[x86_64_v2_rust-rustfft+neon-devel.sha256sum] = "905960143eddcbe81a9a6aaff873c0348ae0dc03e2f1bebf5d3ad230d875a2fc"

URI_x86_64_v2_rust-rustfft+sse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfft+sse-devel-6.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfft+sse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustfft+sse-devel}"
SRC_URI[x86_64_v2_rust-rustfft+sse-devel.sha256sum] = "c278c8399ed6d15c781b6860e7b02037840015ff5e4e14a7ac9de930be10eebf"

URI_x86_64_v2_rust-rustfft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfft-devel-6.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustfft-devel}"
SRC_URI[x86_64_v2_rust-rustfft-devel.sha256sum] = "74f760a9f2c0cdd19beaeaa38b3abdde6ec89bdfaceda179588f3a84827923d1"

URI_aarch64_rust-rustfft+avx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfft+avx-devel-6.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-rustfft+avx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustfft+avx-devel}"
SRC_URI[aarch64_rust-rustfft+avx-devel.sha256sum] = "7b7363ae14791603cc206717cb73e466348dfbec24e9d1f2ec26dc30a06fda1f"

URI_aarch64_rust-rustfft+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfft+default-devel-6.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-rustfft+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustfft+default-devel}"
SRC_URI[aarch64_rust-rustfft+default-devel.sha256sum] = "513e26afc48b4368136f225cfe68e5988b635dea65668f845c40b21c8afc59c2"

URI_aarch64_rust-rustfft+neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfft+neon-devel-6.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-rustfft+neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustfft+neon-devel}"
SRC_URI[aarch64_rust-rustfft+neon-devel.sha256sum] = "c5266bce01b0d609eae732a12a382a91e1c2cf35fa92e70f61e427049980f261"

URI_aarch64_rust-rustfft+sse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfft+sse-devel-6.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-rustfft+sse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustfft+sse-devel}"
SRC_URI[aarch64_rust-rustfft+sse-devel.sha256sum] = "75fad01406029d9f86ccc971be0633640af61d87d901403014d89de3950e17ac"

URI_aarch64_rust-rustfft-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfft-devel-6.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-rustfft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustfft-devel}"
SRC_URI[aarch64_rust-rustfft-devel.sha256sum] = "84deedc5aaf03370ad111184d6e2aaa0f4fead4f6c0a977ae56369198168b82b"

RDEPENDS:rust-rustfft+avx-devel = " \
 cargo \
 rust-rustfft-devel \
 "
RDEPENDS:rust-rustfft+default-devel = " \
 cargo \
 rust-rustfft+avx-devel \
 rust-rustfft+neon-devel \
 rust-rustfft+sse-devel \
 rust-rustfft-devel \
 "
RDEPENDS:rust-rustfft+neon-devel = " \
 cargo \
 rust-rustfft-devel \
 "
RDEPENDS:rust-rustfft+sse-devel = " \
 cargo \
 rust-rustfft-devel \
 "
RDEPENDS:rust-rustfft-devel = " \
 cargo \
 rust-num-complex+default-devel \
 rust-num-integer+default-devel \
 rust-num-traits+default-devel \
 rust-primal-check+default-devel \
 rust-strength_reduce+default-devel \
 rust-transpose+default-devel \
 rust-version_check+default-devel \
 "
