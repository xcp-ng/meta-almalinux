# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "efifs"
PV = "1.11"
PR = "3.el10_1"
PACKAGES = " \
 efifs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/efifs-1.11-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d99c8dfa8ab741d7acd1e32b54670c4373a4a768cebf1c21131c5399497c5a27"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/efifs-1.11-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_efifs;unpack=0"
SRC_URI[x86_64_v2_efifs.sha256sum] = "8bd88378ff1fb15faf0ef76b84fc71a1aeb4aaa4aa2cbc75fef6b35d2d4e69d0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/efifs-1.11-3.el10_1.aarch64.rpm;name=aarch64_efifs;unpack=0"
SRC_URI[aarch64_efifs.sha256sum] = "eb8f02600560089b1ee746c6ebd4708227563fcd82b2deaf27fea940e1fe2dd2"

RDEPENDS:efifs = " \
 efi-filesystem \
 "
