# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iniparser"
PV = "4.1"
PR = "21.el10"
PACKAGES = " \
 iniparser \
 iniparser-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iniparser-4.1-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95ed86129a55cfe49369127e9443813e2687105faabaab3c1c9c31e41913fab2"

URI_x86_64_v2_iniparser = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iniparser-4.1-21.el10.x86_64_v2.rpm;name=x86_64_v2_iniparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iniparser}"
SRC_URI[x86_64_v2_iniparser.sha256sum] = "289531ac20e9e3dfc424dec618740d76aa59ae9cb9b2e004e5b63cd0e3899955"

URI_x86_64_v2_iniparser-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/iniparser-devel-4.1-21.el10.x86_64_v2.rpm;name=x86_64_v2_iniparser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iniparser-devel}"
SRC_URI[x86_64_v2_iniparser-devel.sha256sum] = "da4b54c65a29a7b1229b25133360a211eff9ca360134211540071bcf08bd52a6"

URI_aarch64_iniparser = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iniparser-4.1-21.el10.aarch64.rpm;name=aarch64_iniparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_iniparser}"
SRC_URI[aarch64_iniparser.sha256sum] = "f4cee7b68fef85232827eff249fc2d3fb28a6fa67cd1b53dbea774e0204e4006"

URI_aarch64_iniparser-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/iniparser-devel-4.1-21.el10.aarch64.rpm;name=aarch64_iniparser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_iniparser-devel}"
SRC_URI[aarch64_iniparser-devel.sha256sum] = "46a31fa5a507c45f13ccfe6482ce6a95508641314d660856ae8ebbc7eeac8079"

RDEPENDS:iniparser = " \
 glibc \
 "
RDEPENDS:iniparser-devel = " \
 iniparser \
 "
