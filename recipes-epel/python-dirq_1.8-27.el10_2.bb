# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dirq"
PV = "1.8"
PR = "27.el10_2"
PACKAGES = " \
 python3-dirq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-dirq-1.8-27.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c9181e60d8a74dc9ec1a6a38b6b20db7192b9ddf798d3d4719c300ce4c7d767"

URI_x86_64_v2_python3-dirq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dirq-1.8-27.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dirq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dirq}"
SRC_URI[x86_64_v2_python3-dirq.sha256sum] = "1d357d13ae3415f5f65de87a0752e0e935222167abe58359b6f69ebdc4a907cf"

URI_aarch64_python3-dirq = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dirq-1.8-27.el10_2.noarch.rpm;name=aarch64_python3-dirq;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dirq}"
SRC_URI[aarch64_python3-dirq.sha256sum] = "4c5714d7e90da3701826f0852b6ecc4d2b36e59ba2475cafc85633d39694991b"

RDEPENDS:python3-dirq = " \
 python3 \
 "
