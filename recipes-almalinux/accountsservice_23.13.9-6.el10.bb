# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "accountsservice"
PV = "23.13.9"
PR = "6.el10"
PACKAGES = " \
 accountsservice \
 accountsservice-devel \
 accountsservice-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/accountsservice-23.13.9-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3737c95a02468356f77ab46e22210278c7ac75bd6c46956e600f81d8bf6db798"

URI_x86_64_v2_accountsservice = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/accountsservice-23.13.9-6.el10.x86_64_v2.rpm;name=x86_64_v2_accountsservice;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accountsservice}"
SRC_URI[x86_64_v2_accountsservice.sha256sum] = "ec55f691e588d0aa06714e58d92000354507d79516f00860825cda7f9b9ea5a3"

URI_x86_64_v2_accountsservice-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/accountsservice-devel-23.13.9-6.el10.x86_64_v2.rpm;name=x86_64_v2_accountsservice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accountsservice-devel}"
SRC_URI[x86_64_v2_accountsservice-devel.sha256sum] = "8ffadba9643a80c8111446a2bc83a9d8093aff9a3e14f5700cb8fbb0dda46015"

URI_x86_64_v2_accountsservice-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/accountsservice-libs-23.13.9-6.el10.x86_64_v2.rpm;name=x86_64_v2_accountsservice-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accountsservice-libs}"
SRC_URI[x86_64_v2_accountsservice-libs.sha256sum] = "2b97c654d8d9e89d0951b0a81f4b61491e688a4a23ef57ef73def73c31c5b59a"

URI_aarch64_accountsservice = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/accountsservice-23.13.9-6.el10.aarch64.rpm;name=aarch64_accountsservice;unpack=0"
SRC_URI:append = " ${URI_aarch64_accountsservice}"
SRC_URI[aarch64_accountsservice.sha256sum] = "f68cd1ea063e70b5fb274d2e365d8c6654da5eece9655e674e22098ce84b0c10"

URI_aarch64_accountsservice-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/accountsservice-devel-23.13.9-6.el10.aarch64.rpm;name=aarch64_accountsservice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_accountsservice-devel}"
SRC_URI[aarch64_accountsservice-devel.sha256sum] = "63c8e91499403b65dcbf6ac4232af17f90e27bd3a81ebf922eb7bb9552360df7"

URI_aarch64_accountsservice-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/accountsservice-libs-23.13.9-6.el10.aarch64.rpm;name=aarch64_accountsservice-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_accountsservice-libs}"
SRC_URI[aarch64_accountsservice-libs.sha256sum] = "98ac4ebd0cce881b1657510cfcbadf243a078a4b8bf8e631b1b9337c6d5f475a"

RDEPENDS:accountsservice = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 polkit \
 polkit-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:accountsservice-devel = " \
 accountsservice-libs \
 glib2-devel \
 pkgconf-pkg-config \
 polkit-devel \
 "
RDEPENDS:accountsservice-libs = " \
 accountsservice \
 glib2 \
 glibc \
 libgcc \
 libxcrypt \
 systemd-libs \
 "
