# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-json5"
PV = "0.4.1"
PR = "8.el10_0"
PACKAGES = " \
 rust-json5+default-devel \
 rust-json5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-json5-0.4.1-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63b014c46de6b4306959b9d215541f8af2289211869812abb8b3cf14541e6aa1"

URI_x86_64_v2_rust-json5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-json5+default-devel-0.4.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-json5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-json5+default-devel}"
SRC_URI[x86_64_v2_rust-json5+default-devel.sha256sum] = "d5935a9f5b60c9bc15105b9de3907ca1ef0e2710041180516f499d23fc6523b4"

URI_x86_64_v2_rust-json5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-json5-devel-0.4.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-json5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-json5-devel}"
SRC_URI[x86_64_v2_rust-json5-devel.sha256sum] = "acba0ec5bf4227c6f72be8d435134702a2da8accd2bc5f4de3922a3eb5f0d3f2"

URI_aarch64_rust-json5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-json5+default-devel-0.4.1-8.el10_0.noarch.rpm;name=aarch64_rust-json5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-json5+default-devel}"
SRC_URI[aarch64_rust-json5+default-devel.sha256sum] = "d53d4340897330d4bc55215275c41cee27b3fee4c2aefc2861d9eeec50cf6813"

URI_aarch64_rust-json5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-json5-devel-0.4.1-8.el10_0.noarch.rpm;name=aarch64_rust-json5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-json5-devel}"
SRC_URI[aarch64_rust-json5-devel.sha256sum] = "a6eb99366f8a4ec292e9cb97058ef29f29872ea79564fa4413aa86fb44204031"

RDEPENDS:rust-json5+default-devel = " \
 cargo \
 rust-json5-devel \
 "
RDEPENDS:rust-json5-devel = " \
 cargo \
 rust-pest+default-devel \
 rust-pest_derive+default-devel \
 rust-serde+default-devel \
 "
