# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-stacker"
PV = "0.1.25"
PR = "1.el10_2"
PACKAGES = " \
 rust-stacker+default-devel \
 rust-stacker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-stacker-0.1.25-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05f34c029c01b07f58ab82464ed58b5fb92e4ad63f8eb372c57235e819a8cc2e"

URI_x86_64_v2_rust-stacker+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stacker+default-devel-0.1.25-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stacker+default-devel}"
SRC_URI[x86_64_v2_rust-stacker+default-devel.sha256sum] = "8a68e43947c057e4cce26616f323c9ac0ac7756ef080101014a355bec2776888"

URI_x86_64_v2_rust-stacker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stacker-devel-0.1.25-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stacker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stacker-devel}"
SRC_URI[x86_64_v2_rust-stacker-devel.sha256sum] = "6ed321ce0e9b24aa82eac1a81c124297998e274fa9b2fb2fb7e2da3670db8ffa"

URI_aarch64_rust-stacker+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stacker+default-devel-0.1.25-1.el10_2.noarch.rpm;name=aarch64_rust-stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stacker+default-devel}"
SRC_URI[aarch64_rust-stacker+default-devel.sha256sum] = "c3dff9324785c919d9904df048f185cb3e9c729574fe4d88a640e2325f00749c"

URI_aarch64_rust-stacker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stacker-devel-0.1.25-1.el10_2.noarch.rpm;name=aarch64_rust-stacker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stacker-devel}"
SRC_URI[aarch64_rust-stacker-devel.sha256sum] = "16613e41a059a77ca8e8cfcc9120a686e33cf0c37cc97bd0d1704090535bf4ca"

RDEPENDS:rust-stacker+default-devel = " \
 cargo \
 rust-stacker-devel \
 "
RDEPENDS:rust-stacker-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-psm+default-devel \
 "
