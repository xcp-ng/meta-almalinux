# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arbitrary"
PV = "1.4.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-arbitrary+derive_arbitrary-devel \
 rust-arbitrary-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arbitrary-1.4.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4afa064b7f80edeed0618409402fcc40b591cef97afb250d93434012332883f"

URI_x86_64_v2_rust-arbitrary+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arbitrary+default-devel-1.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arbitrary+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arbitrary+default-devel}"
SRC_URI[x86_64_v2_rust-arbitrary+default-devel.sha256sum] = "c600d90e38b58cc399c1d3f3768ed1a9743a2a2c03b7908dcb94c5479c2c461d"

URI_x86_64_v2_rust-arbitrary+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arbitrary+derive-devel-1.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arbitrary+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arbitrary+derive-devel}"
SRC_URI[x86_64_v2_rust-arbitrary+derive-devel.sha256sum] = "fd7eceb7350f82dac255522dbc8cf2ba219e7dc3df7331dfdfd30391192a0bb9"

URI_x86_64_v2_rust-arbitrary+derive_arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arbitrary+derive_arbitrary-devel-1.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arbitrary+derive_arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arbitrary+derive_arbitrary-devel}"
SRC_URI[x86_64_v2_rust-arbitrary+derive_arbitrary-devel.sha256sum] = "b556634a53083ad94543b95bba69a297094d6fc7f627f65a60e8f7ceb6d20fe0"

URI_x86_64_v2_rust-arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arbitrary-devel-1.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arbitrary-devel}"
SRC_URI[x86_64_v2_rust-arbitrary-devel.sha256sum] = "532bfb128df8499374bf1caca8e4007883cb4e7baefe7d2dd962cd6af4bbf536"

URI_aarch64_rust-arbitrary+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arbitrary+default-devel-1.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-arbitrary+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arbitrary+default-devel}"
SRC_URI[aarch64_rust-arbitrary+default-devel.sha256sum] = "20c929be28225a7789c494bdd3bbad3d586dce33a4b43f59aa9b435d4156e24d"

URI_aarch64_rust-arbitrary+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arbitrary+derive-devel-1.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-arbitrary+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arbitrary+derive-devel}"
SRC_URI[aarch64_rust-arbitrary+derive-devel.sha256sum] = "e502bd94fda691d48eb351679d990a0b41b199cc78ab2f617b372b8c3499d38a"

URI_aarch64_rust-arbitrary+derive_arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arbitrary+derive_arbitrary-devel-1.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-arbitrary+derive_arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arbitrary+derive_arbitrary-devel}"
SRC_URI[aarch64_rust-arbitrary+derive_arbitrary-devel.sha256sum] = "f027124879f0591df024c3b8e789155cae9961e2bbc1ffd725d2948ceae46bf9"

URI_aarch64_rust-arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arbitrary-devel-1.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arbitrary-devel}"
SRC_URI[aarch64_rust-arbitrary-devel.sha256sum] = "03a368c622434151c7cb166a31119dc839db10231b01989f39bb4e5019f955e2"

RDEPENDS:rust-arbitrary+default-devel = " \
 cargo \
 rust-arbitrary-devel \
 "
RDEPENDS:rust-arbitrary+derive-devel = " \
 cargo \
 rust-arbitrary+derive_arbitrary-devel \
 rust-arbitrary-devel \
 "
RDEPENDS:rust-arbitrary+derive_arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-derive_arbitrary+default-devel \
 "
RDEPENDS:rust-arbitrary-devel = " \
 bash \
 cargo \
 rust \
 "
