# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "breeze-gtk"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 breeze-gtk \
 breeze-gtk-common \
 breeze-gtk-gtk2 \
 breeze-gtk-gtk3 \
 breeze-gtk-gtk4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/breeze-gtk-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2afe3dc0bf35f7cf4b901936a91ad4f52aab0f4ab2c72a207a533c4bc6eea2f0"

URI_x86_64_v2_breeze-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk}"
SRC_URI[x86_64_v2_breeze-gtk.sha256sum] = "3bf8ae28b79bf791279fa4168da9cd4b41e8bae3d432042246bd348ace181d0d"

URI_x86_64_v2_breeze-gtk-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-common-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-common}"
SRC_URI[x86_64_v2_breeze-gtk-common.sha256sum] = "3a9a47826316179aa18cd659af6f128b9b94e065f546299571a6a30f2a02fa3a"

URI_x86_64_v2_breeze-gtk-gtk2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk2-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-gtk2}"
SRC_URI[x86_64_v2_breeze-gtk-gtk2.sha256sum] = "3b748234899b17edcbb2e40cc9f18ccfec88d706da3dc9cbee3ba89944397443"

URI_x86_64_v2_breeze-gtk-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk3-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-gtk3}"
SRC_URI[x86_64_v2_breeze-gtk-gtk3.sha256sum] = "c1bce97d7a19bff74158d5d50e651e097382923f374d7d1fdd551a460edc9bfa"

URI_x86_64_v2_breeze-gtk-gtk4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk4-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-gtk4}"
SRC_URI[x86_64_v2_breeze-gtk-gtk4.sha256sum] = "e1bf5c994e096621e52a6601a50a0f8ea39bc110e9b670a8a6982f0dee315318"

URI_aarch64_breeze-gtk = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-6.6.4-1.el10_2.noarch.rpm;name=aarch64_breeze-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk}"
SRC_URI[aarch64_breeze-gtk.sha256sum] = "1329890de661ee390d3baf0a7079fff4598b3c7135221f8d71af28e18ee2c2c9"

URI_aarch64_breeze-gtk-common = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-common-6.6.4-1.el10_2.noarch.rpm;name=aarch64_breeze-gtk-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-common}"
SRC_URI[aarch64_breeze-gtk-common.sha256sum] = "69371371691a248e0fe9397696beb1298123a75c2c5ec29379503bd0d31d0063"

URI_aarch64_breeze-gtk-gtk2 = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk2-6.6.4-1.el10_2.noarch.rpm;name=aarch64_breeze-gtk-gtk2;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-gtk2}"
SRC_URI[aarch64_breeze-gtk-gtk2.sha256sum] = "a0b1c65ce187ab2c2e69181e4b4b7c3834ab4a4be4fe9d9e7a2185fcffcdbb6e"

URI_aarch64_breeze-gtk-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk3-6.6.4-1.el10_2.noarch.rpm;name=aarch64_breeze-gtk-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-gtk3}"
SRC_URI[aarch64_breeze-gtk-gtk3.sha256sum] = "26971902a034f55b73ebc8ec31d307432bd5cc03c4b1d492687c999b5dc0875e"

URI_aarch64_breeze-gtk-gtk4 = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk4-6.6.4-1.el10_2.noarch.rpm;name=aarch64_breeze-gtk-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-gtk4}"
SRC_URI[aarch64_breeze-gtk-gtk4.sha256sum] = "72d490b8f68b58e5525465a613f21a4cc5f83cdda40e1c6a416649c4f76ce616"

RDEPENDS:breeze-gtk = " \
 breeze-gtk-gtk2 \
 breeze-gtk-gtk3 \
 breeze-gtk-gtk4 \
 "
RDEPENDS:breeze-gtk-common = " \
 "
RDEPENDS:breeze-gtk-gtk2 = " \
 breeze-gtk-common \
 gtk2-engines \
 "
RDEPENDS:breeze-gtk-gtk3 = " \
 breeze-gtk-common \
 "
RDEPENDS:breeze-gtk-gtk4 = " \
 breeze-gtk-common \
 "
