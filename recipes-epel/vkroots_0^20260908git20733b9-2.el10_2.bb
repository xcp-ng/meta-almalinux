# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vkroots"
PV = "0^20260908git20733b9"
PR = "2.el10_2"
PACKAGES = " \
 vkroots-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vkroots-0^20260908git20733b9-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aac70bddf017b927b0b8a52c6fdb346f10ac29a885556a2b8a3ed3fa01f6ea17"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vkroots-devel-0^20260908git20733b9-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_vkroots-devel;unpack=0"
SRC_URI[x86_64_v2_vkroots-devel.sha256sum] = "6f0c9b26741aaf9c25da35871af7c24663bb597aa8bab9e566eece8eff39c85a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vkroots-devel-0^20260908git20733b9-2.el10_2.noarch.rpm;name=aarch64_vkroots-devel;unpack=0"
SRC_URI[aarch64_vkroots-devel.sha256sum] = "a256d61b89ed454a0bb32fcf35b33d4ce8fc0b540f6f5d38d80aa8a531553738"

RDEPENDS:vkroots-devel = " \
 pkgconf-pkg-config \
 "
