# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Tk"
PV = "804.036"
PR = "17.el10"
PACKAGES = " \
 perl-Tk \
 perl-Tk-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Tk-804.036-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f569a1bce6b2564a54bb2972e76ca3b20f3046176990eb95910be995e766839b"

URI_x86_64_v2_perl-Tk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tk-804.036-17.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Tk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tk}"
SRC_URI[x86_64_v2_perl-Tk.sha256sum] = "0aa54b45d4ee31cc6777f9455dac82cab65ae36c6f65efa8efc777fb2e24ba1f"

URI_x86_64_v2_perl-Tk-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Tk-devel-804.036-17.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Tk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tk-devel}"
SRC_URI[x86_64_v2_perl-Tk-devel.sha256sum] = "e1fbd2cf60ea68912985655d88348b117e76c67739f5ca113833de975a2fd99a"

URI_aarch64_perl-Tk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tk-804.036-17.el10.aarch64.rpm;name=aarch64_perl-Tk;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tk}"
SRC_URI[aarch64_perl-Tk.sha256sum] = "3c2ef4a30415505a467cd11f28625581f81b01491e5ef58b863180e91facd820"

URI_aarch64_perl-Tk-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Tk-devel-804.036-17.el10.aarch64.rpm;name=aarch64_perl-Tk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tk-devel}"
SRC_URI[aarch64_perl-Tk-devel.sha256sum] = "a694fc5178e63805a7f56316dace9dc44035b08e5a81d9690ef7b5ac7055c591"

RDEPENDS:perl-Tk = " \
 fontconfig \
 glibc \
 libX11 \
 libXft \
 libjpeg-turbo \
 libpng \
 perl-AutoLoader \
 perl-Carp \
 perl-DirHandle \
 perl-DynaLoader \
 perl-Encode \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-PathTools \
 perl-Socket \
 perl-Symbol \
 perl-Text-Tabs+Wrap \
 perl-Tk \
 perl-base \
 perl-if \
 perl-interpreter \
 perl-libs \
 perl-locale \
 perl-open \
 perl-overload \
 perl-subs \
 perl-vars \
 "
RDEPENDS:perl-Tk-devel = " \
 perl-Carp \
 perl-Exporter \
 perl-ExtUtils-MakeMaker \
 perl-File-Basename \
 perl-PathTools \
 perl-Tk \
 perl-Tk-devel \
 perl-base \
 perl-libs \
 perl-vars \
 "
