# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clash-meta"
PV = "1.19.24"
PR = "1.el10_3"
PACKAGES = " \
 clash-meta \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clash-meta-1.19.24-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6215e4e6d833519eef3b23722f299f81923d951f30329e7f57ae614f86ef29d0"

URI_x86_64_v2_clash-meta = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clash-meta-1.19.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clash-meta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clash-meta}"
SRC_URI[x86_64_v2_clash-meta.sha256sum] = "801ae03a40f4a28a7dd9be0cc2014b1eaaf0df08931abb79cc231496737a6b8a"

URI_aarch64_clash-meta = "${EPEL_MIRROR}/aarch64/Packages/c/clash-meta-1.19.24-1.el10_3.aarch64.rpm;name=aarch64_clash-meta;unpack=0"
SRC_URI:append = " ${URI_aarch64_clash-meta}"
SRC_URI[aarch64_clash-meta.sha256sum] = "d93684fdd7e8cfb10d81824bb6d9b2a0b1616fed85a23dd7b64c8078e4976e42"

RDEPENDS:clash-meta = " \
 glibc \
 "
