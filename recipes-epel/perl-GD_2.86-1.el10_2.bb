# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GD"
PV = "2.86"
PR = "1.el10_2"
PACKAGES = " \
 perl-GD \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-GD-2.86-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa0878385617dc986f990e7803188aed4bcd67c4fd039b2d732376d3cd3bbd9d"

URI_x86_64_v2_perl-GD = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GD-2.86-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-GD;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GD}"
SRC_URI[x86_64_v2_perl-GD.sha256sum] = "bd2777df3ebca96057c7e4e0d594aec37e9e9a799580a0924790abdbc828b7fa"

URI_aarch64_perl-GD = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GD-2.86-1.el10_2.aarch64.rpm;name=aarch64_perl-GD;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GD}"
SRC_URI[aarch64_perl-GD.sha256sum] = "4c1adef2152365c368efd7f913f628b0afc1b42294520327575350d720c58c86"

RDEPENDS:perl-GD = " \
 gd \
 glibc \
 perl-AutoLoader \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-FileHandle \
 perl-GD \
 perl-Math-Complex \
 perl-Symbol \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
