# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert_cmd"
PV = "2.2.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-assert_cmd+color-auto-devel \
 rust-assert_cmd+color-devel \
 rust-assert_cmd+default-devel \
 rust-assert_cmd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-assert_cmd-2.2.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32172b90c903a6d589cd2c0e09756a0a980a113ca34a1ae89949fa6f7c1244a8"

URI_x86_64_v2_rust-assert_cmd+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd+color-auto-devel-2.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd+color-auto-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd+color-auto-devel.sha256sum] = "3af4d9a65db497b1f6f6696fc3cad9103d06a00c395d28a0731652a0d6e638d3"

URI_x86_64_v2_rust-assert_cmd+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd+color-devel-2.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd+color-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd+color-devel.sha256sum] = "dc398cfc7666577d2fb89205010e8fb00d086707863c82aa2190ace1662c91d4"

URI_x86_64_v2_rust-assert_cmd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd+default-devel-2.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd+default-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd+default-devel.sha256sum] = "da58d4275ad883959896d649b3cadaefabf892de3a2278ccf531b2e892bf812f"

URI_x86_64_v2_rust-assert_cmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd-devel-2.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd-devel.sha256sum] = "15fc47343eea1b74b794517140f95289cc66ec56b2555632551729609f7e9ee4"

URI_aarch64_rust-assert_cmd+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd+color-auto-devel-2.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-assert_cmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd+color-auto-devel}"
SRC_URI[aarch64_rust-assert_cmd+color-auto-devel.sha256sum] = "743a9c6e35edc60d76a13b9ef2cd9b013879726b83b256dd98de33cc1b6cbdc6"

URI_aarch64_rust-assert_cmd+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd+color-devel-2.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-assert_cmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd+color-devel}"
SRC_URI[aarch64_rust-assert_cmd+color-devel.sha256sum] = "b6b27bc294f13f3e70d582333bf6b2d8fdaa25eb97aa74a0d5bc05487ceed247"

URI_aarch64_rust-assert_cmd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd+default-devel-2.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-assert_cmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd+default-devel}"
SRC_URI[aarch64_rust-assert_cmd+default-devel.sha256sum] = "f4f901a8082ce50f57be399223397a92dc6d55e2f1d26d5059250f53778f1bab"

URI_aarch64_rust-assert_cmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd-devel-2.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-assert_cmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd-devel}"
SRC_URI[aarch64_rust-assert_cmd-devel.sha256sum] = "40e1e923e798cd612e791eb88c6fd4ef74e63665dc09b680dc2337d46f883c2c"

RDEPENDS:rust-assert_cmd+color-auto-devel = " \
 cargo \
 rust-assert_cmd+color-devel \
 rust-assert_cmd-devel \
 "
RDEPENDS:rust-assert_cmd+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-assert_cmd-devel \
 rust-predicates+color-devel \
 "
RDEPENDS:rust-assert_cmd+default-devel = " \
 cargo \
 rust-assert_cmd-devel \
 "
RDEPENDS:rust-assert_cmd-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-bstr+default-devel \
 rust-libc+default-devel \
 rust-predicates+diff-devel \
 rust-predicates-core+default-devel \
 rust-predicates-devel \
 rust-predicates-tree+default-devel \
 rust-wait-timeout+default-devel \
 "
