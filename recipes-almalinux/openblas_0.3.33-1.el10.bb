# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openblas"
PV = "0.3.33"
PR = "1.el10"
PACKAGES = " \
 openblas \
 openblas-devel \
 openblas-openmp \
 openblas-openmp64 \
 openblas-openmp64_ \
 openblas-serial \
 openblas-serial64 \
 openblas-serial64_ \
 openblas-static \
 openblas-threads \
 openblas-threads64 \
 openblas-threads64_ \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openblas-0.3.33-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "70da6d4c868e0fc40b4e88f49bd0df1add30125944b17d88279900e7fb49c93a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openblas-0.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas;unpack=0"
SRC_URI[x86_64_v2_openblas.sha256sum] = "8b11b2006b0014d35b30ebba27fa8dfecdacff8f9bc783741f26f1f5faba8644"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-devel-0.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-devel;unpack=0"
SRC_URI[x86_64_v2_openblas-devel.sha256sum] = "c9288a4013d1ce51a10d534801c23506b0573112b480a33c2badb0a42abeaa0d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openblas-openmp-0.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-openmp;unpack=0"
SRC_URI[x86_64_v2_openblas-openmp.sha256sum] = "abb01cb0e3f8f86b687eefe0a1ab23de3b06747af4944c42e9504d84e12035a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openblas-openmp64-0.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-openmp64;unpack=0"
SRC_URI[x86_64_v2_openblas-openmp64.sha256sum] = "bd089e614f0f1da50fc05ab223236d268f9fb5409c1d3398518e086c6530c2f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-openmp64_-0.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-openmp64_;unpack=0"
SRC_URI[x86_64_v2_openblas-openmp64_.sha256sum] = "f6345b02ec7cf44dafeb6ddf0a0c69207c0d78546068d87cccdf4c3b1de25a1f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openblas-serial-0.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-serial;unpack=0"
SRC_URI[x86_64_v2_openblas-serial.sha256sum] = "9a5d464894444ae3342962b679eac071bd7a93845791761bcaa6485a60ecad72"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-serial64-0.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-serial64;unpack=0"
SRC_URI[x86_64_v2_openblas-serial64.sha256sum] = "783abd5c3c991c96573de249a2870add78733052478362f0c4a9f33362fda714"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-serial64_-0.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-serial64_;unpack=0"
SRC_URI[x86_64_v2_openblas-serial64_.sha256sum] = "a69e030a2198707be3044776f879a858ec232da5c1288c18609aadf939b7a232"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-static-0.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-static;unpack=0"
SRC_URI[x86_64_v2_openblas-static.sha256sum] = "15ac44fe3945314f129c3bda08570e4740605b9901629f9bd9b228666c6c196b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-threads-0.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-threads;unpack=0"
SRC_URI[x86_64_v2_openblas-threads.sha256sum] = "1befeff8d4eb4f2f745618ef4c9cc7fd3496f8283f235b715ac346d623ebf171"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-threads64-0.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-threads64;unpack=0"
SRC_URI[x86_64_v2_openblas-threads64.sha256sum] = "a9435cb2548bac89a33aeaa8fbafcd8dfa3bc467866098f9ea438257bde06eaf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-threads64_-0.3.33-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-threads64_;unpack=0"
SRC_URI[x86_64_v2_openblas-threads64_.sha256sum] = "5d7c8785fe7bf45bf1ae46a4358b9a42fda283299f074c905967deea72e08835"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openblas-0.3.33-1.el10.aarch64.rpm;name=aarch64_openblas;unpack=0"
SRC_URI[aarch64_openblas.sha256sum] = "ca1a6b70e79cc90d409a6d051922ac5d2cfc5c2ff8101732e2be41e93fb356cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-devel-0.3.33-1.el10.aarch64.rpm;name=aarch64_openblas-devel;unpack=0"
SRC_URI[aarch64_openblas-devel.sha256sum] = "9c5250528f79f6d495120c732c478146b9e4859cb8357ddb37c3f9e51f5cb6a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openblas-openmp-0.3.33-1.el10.aarch64.rpm;name=aarch64_openblas-openmp;unpack=0"
SRC_URI[aarch64_openblas-openmp.sha256sum] = "1d26320d891ac9315e7cc57e8bbcec8cce2eb23afb9e6ec5863b59049e2088c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openblas-openmp64-0.3.33-1.el10.aarch64.rpm;name=aarch64_openblas-openmp64;unpack=0"
SRC_URI[aarch64_openblas-openmp64.sha256sum] = "be295e24d41ea20f5c4134dca9629dac36a8a49d6eb84430163e629cab0e2434"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-openmp64_-0.3.33-1.el10.aarch64.rpm;name=aarch64_openblas-openmp64_;unpack=0"
SRC_URI[aarch64_openblas-openmp64_.sha256sum] = "23e80587eea056a5f5c86c8c2a484d5074516e6eb475aa9bd131f4b25b2e8dc7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openblas-serial-0.3.33-1.el10.aarch64.rpm;name=aarch64_openblas-serial;unpack=0"
SRC_URI[aarch64_openblas-serial.sha256sum] = "8d65ac11deebc2a13585f5ddf218e13a12c6969e058e8577dd97dc69ee0d3486"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-serial64-0.3.33-1.el10.aarch64.rpm;name=aarch64_openblas-serial64;unpack=0"
SRC_URI[aarch64_openblas-serial64.sha256sum] = "acea7d80e3422c5b6b9e2081809902730429d31829a28d78257be81871166927"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-serial64_-0.3.33-1.el10.aarch64.rpm;name=aarch64_openblas-serial64_;unpack=0"
SRC_URI[aarch64_openblas-serial64_.sha256sum] = "61e14ed6c8ca8b95c63f7f5f3f5e60e769acdf108fcfcd28df4d9d5a5f433896"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-static-0.3.33-1.el10.aarch64.rpm;name=aarch64_openblas-static;unpack=0"
SRC_URI[aarch64_openblas-static.sha256sum] = "727534546699fc09a1840499bb23a79d4d3f4ba1feab34f148a4464b42bd8a65"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-threads-0.3.33-1.el10.aarch64.rpm;name=aarch64_openblas-threads;unpack=0"
SRC_URI[aarch64_openblas-threads.sha256sum] = "e7d78abebf1ab26cd5d56e2f3e254da429bb6efd6f0e0ec77bf283566abd1a86"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-threads64-0.3.33-1.el10.aarch64.rpm;name=aarch64_openblas-threads64;unpack=0"
SRC_URI[aarch64_openblas-threads64.sha256sum] = "9e591cba0032dcfb0fd5a5482cfc466be72dbe73b40929b73743c52d58435463"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-threads64_-0.3.33-1.el10.aarch64.rpm;name=aarch64_openblas-threads64_;unpack=0"
SRC_URI[aarch64_openblas-threads64_.sha256sum] = "cb6e4c4a94a5c2cdddfa52ec8842db5d2f2f2d378aa3f4d489bfb95441ddf3e5"

RDEPENDS:openblas = " \
 "
RDEPENDS:openblas-devel = " \
 openblas \
 openblas-openmp \
 openblas-openmp64 \
 openblas-openmp64_ \
 openblas-serial \
 openblas-serial64 \
 openblas-serial64_ \
 openblas-srpm-macros \
 openblas-threads \
 openblas-threads64 \
 openblas-threads64_ \
 pkgconf-pkg-config \
 "
RDEPENDS:openblas-openmp = " \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 openblas \
 "
RDEPENDS:openblas-openmp64 = " \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 openblas \
 "
RDEPENDS:openblas-openmp64_ = " \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 openblas \
 "
RDEPENDS:openblas-serial = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-serial64 = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-serial64_ = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-static = " \
 openblas-devel \
 "
RDEPENDS:openblas-threads = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-threads64 = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-threads64_ = " \
 glibc \
 libgfortran \
 openblas \
 "
