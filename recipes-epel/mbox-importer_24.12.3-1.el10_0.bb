# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mbox-importer"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 mbox-importer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mbox-importer-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e0ef46cb0859eebbc26be3e81970e8c48dddd91683d22613cbdf389a976a7b1"

URI_x86_64_v2_mbox-importer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbox-importer-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbox-importer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbox-importer}"
SRC_URI[x86_64_v2_mbox-importer.sha256sum] = "1a93e35828d0a09982a0797793947f85bd03f27a01c899152f962bcdab8986de"

URI_aarch64_mbox-importer = "${EPEL_MIRROR}/aarch64/Packages/m/mbox-importer-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_mbox-importer;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbox-importer}"
SRC_URI[aarch64_mbox-importer.sha256sum] = "9416f28d8dc1e220287c58f4382f13bfdae3b2b174aea45aea284593fd008659"

RDEPENDS:mbox-importer = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 libgcc \
 libstdc++ \
 mailcommon \
 mailimporter \
 mailimporter-akonadi \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
