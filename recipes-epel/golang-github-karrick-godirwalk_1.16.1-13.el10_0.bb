# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-karrick-godirwalk"
PV = "1.16.1"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-karrick-godirwalk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-karrick-godirwalk-1.16.1-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d078a298da518e53c19b065b2f069636311fce1603bfe932f86358f4f170b04e"

URI_x86_64_v2_golang-github-karrick-godirwalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-karrick-godirwalk-devel-1.16.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-karrick-godirwalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-karrick-godirwalk-devel}"
SRC_URI[x86_64_v2_golang-github-karrick-godirwalk-devel.sha256sum] = "78630c119b8ee2284cb7159fcdf815df9bd9955c9b21edf52152ddd7ce600233"

URI_aarch64_golang-github-karrick-godirwalk-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-karrick-godirwalk-devel-1.16.1-13.el10_0.noarch.rpm;name=aarch64_golang-github-karrick-godirwalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-karrick-godirwalk-devel}"
SRC_URI[aarch64_golang-github-karrick-godirwalk-devel.sha256sum] = "0a9bb6a0b50b1f163ef0de59993dbd755962ba7f3e7af9749dbdd10845ec44fe"

RDEPENDS:golang-github-karrick-godirwalk-devel = " \
 go-filesystem \
 "
