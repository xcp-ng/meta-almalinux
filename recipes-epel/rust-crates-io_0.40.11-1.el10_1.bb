# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crates-io"
PV = "0.40.11"
PR = "1.el10_1"
PACKAGES = " \
 rust-crates-io+default-devel \
 rust-crates-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crates-io-0.40.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6ad76a34264dd4fc044df82674cb2b90e68fc05e99595e197852dde242502de"

URI_x86_64_v2_rust-crates-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crates-io+default-devel-0.40.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crates-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crates-io+default-devel}"
SRC_URI[x86_64_v2_rust-crates-io+default-devel.sha256sum] = "a218f2b01332e8aee7b1dd0f2b06e95269304be9208262f988714b48e718c930"

URI_x86_64_v2_rust-crates-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crates-io-devel-0.40.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crates-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crates-io-devel}"
SRC_URI[x86_64_v2_rust-crates-io-devel.sha256sum] = "144d0414935fc33c9b4b0cfed37f002054e2dfc5cdb194092ee856c71f00ea7b"

URI_aarch64_rust-crates-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crates-io+default-devel-0.40.11-1.el10_1.noarch.rpm;name=aarch64_rust-crates-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crates-io+default-devel}"
SRC_URI[aarch64_rust-crates-io+default-devel.sha256sum] = "79221f3fab10af618611d59ae0c01bb2197014c6ecc3b477da22f72d2a7436b9"

URI_aarch64_rust-crates-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crates-io-devel-0.40.11-1.el10_1.noarch.rpm;name=aarch64_rust-crates-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crates-io-devel}"
SRC_URI[aarch64_rust-crates-io-devel.sha256sum] = "0872b6099ad2be620bfe198dbc8a6c3b8a7cba616daaccf6fa9564d48ef78651"

RDEPENDS:rust-crates-io+default-devel = " \
 cargo \
 rust-crates-io-devel \
 "
RDEPENDS:rust-crates-io-devel = " \
 cargo \
 rust \
 rust-curl+default-devel \
 rust-percent-encoding+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 rust-url+default-devel \
 "
