# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-console"
PV = "0.16.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-console+alloc-devel \
 rust-console+ansi-parsing-devel \
 rust-console+default-devel \
 rust-console+std-devel \
 rust-console+unicode-width-devel \
 rust-console-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-console-0.16.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a84ec12c49fd7f3a4c6ea5d9ab227fcac2afd0d085c826ac905e9186876759e"

URI_x86_64_v2_rust-console+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+alloc-devel-0.16.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+alloc-devel}"
SRC_URI[x86_64_v2_rust-console+alloc-devel.sha256sum] = "b518cf1aa32f10841f34bec63eaa7ff523e10a2d8b2190203246ae52b1eb680f"

URI_x86_64_v2_rust-console+ansi-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+ansi-parsing-devel-0.16.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+ansi-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+ansi-parsing-devel}"
SRC_URI[x86_64_v2_rust-console+ansi-parsing-devel.sha256sum] = "3a557c742d1252f275bb0d888df00c8b14896d45a862641bb02349cfd28b38dd"

URI_x86_64_v2_rust-console+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+default-devel-0.16.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+default-devel}"
SRC_URI[x86_64_v2_rust-console+default-devel.sha256sum] = "e7cbc0a79241bc23ed4efb13d645166480ef2fb57bd67a64735191628e5a98a3"

URI_x86_64_v2_rust-console+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+std-devel-0.16.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+std-devel}"
SRC_URI[x86_64_v2_rust-console+std-devel.sha256sum] = "6948adc98fdbc64db8daaa1da2c21fa2f4afae0312ddca66f9f4ae7993f8aa33"

URI_x86_64_v2_rust-console+unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+unicode-width-devel-0.16.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+unicode-width-devel}"
SRC_URI[x86_64_v2_rust-console+unicode-width-devel.sha256sum] = "877c47ab67f5f152627e0b49120f42b10530c33908308bb06bb56f03835771c1"

URI_x86_64_v2_rust-console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console-devel-0.16.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console-devel}"
SRC_URI[x86_64_v2_rust-console-devel.sha256sum] = "d2a1afeb86728579ef810968c52c9164a2148ee26b40b06bc3a61783b5dd928b"

URI_aarch64_rust-console+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+alloc-devel-0.16.4-1.el10_2.noarch.rpm;name=aarch64_rust-console+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+alloc-devel}"
SRC_URI[aarch64_rust-console+alloc-devel.sha256sum] = "e165f0b7c0dcfcebda51fcf204042c2dbaeefa6a02137c4d353bdf9c87122411"

URI_aarch64_rust-console+ansi-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+ansi-parsing-devel-0.16.4-1.el10_2.noarch.rpm;name=aarch64_rust-console+ansi-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+ansi-parsing-devel}"
SRC_URI[aarch64_rust-console+ansi-parsing-devel.sha256sum] = "7d2201494dc9c022d40a97403ede711bf95619e704e56090dcdac56dde8c2dcd"

URI_aarch64_rust-console+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+default-devel-0.16.4-1.el10_2.noarch.rpm;name=aarch64_rust-console+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+default-devel}"
SRC_URI[aarch64_rust-console+default-devel.sha256sum] = "f25711d0738c713ca0086f63ac59daf7216e80d363224eb177668205fecf5f9f"

URI_aarch64_rust-console+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+std-devel-0.16.4-1.el10_2.noarch.rpm;name=aarch64_rust-console+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+std-devel}"
SRC_URI[aarch64_rust-console+std-devel.sha256sum] = "b1c1d6c55dcd9e49205abaf5c54d29f74c438d702f77d46f02175346c8dddce8"

URI_aarch64_rust-console+unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+unicode-width-devel-0.16.4-1.el10_2.noarch.rpm;name=aarch64_rust-console+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+unicode-width-devel}"
SRC_URI[aarch64_rust-console+unicode-width-devel.sha256sum] = "404da72c79b287f82a9682e6d943ea27557d650a304f9789c010c69997d87e36"

URI_aarch64_rust-console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console-devel-0.16.4-1.el10_2.noarch.rpm;name=aarch64_rust-console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console-devel}"
SRC_URI[aarch64_rust-console-devel.sha256sum] = "ea1adf04daa009bedb08df653d03fedb22427a4450b670418827744c67ad0c5b"

RDEPENDS:rust-console+alloc-devel = " \
 cargo \
 rust-console-devel \
 "
RDEPENDS:rust-console+ansi-parsing-devel = " \
 cargo \
 rust-console-devel \
 "
RDEPENDS:rust-console+default-devel = " \
 cargo \
 rust-console+ansi-parsing-devel \
 rust-console+std-devel \
 rust-console+unicode-width-devel \
 rust-console-devel \
 "
RDEPENDS:rust-console+std-devel = " \
 cargo \
 rust-console+alloc-devel \
 rust-console-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-console+unicode-width-devel = " \
 cargo \
 rust-console-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-console-devel = " \
 cargo \
 rust \
 "
