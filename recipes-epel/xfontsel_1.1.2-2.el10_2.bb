# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xfontsel"
PV = "1.1.2"
PR = "2.el10_2"
PACKAGES = " \
 xfontsel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xfontsel-1.1.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85da8b719fc1ef1701c20eba5fd64c330b593e32b7f971a7f3627f8d30dd5be9"

URI_x86_64_v2_xfontsel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xfontsel-1.1.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xfontsel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfontsel}"
SRC_URI[x86_64_v2_xfontsel.sha256sum] = "73195019d21fec3971ab42ab89b2bfb87155e8040d19c35670dcf7f0756b09a4"

URI_aarch64_xfontsel = "${EPEL_MIRROR}/aarch64/Packages/x/xfontsel-1.1.2-2.el10_2.aarch64.rpm;name=aarch64_xfontsel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfontsel}"
SRC_URI[aarch64_xfontsel.sha256sum] = "8e76fff42f2223f4841d9c2a8494b9b21b135700f6b884bcc7c0ba40a0121d3e"

RDEPENDS:xfontsel = " \
 glibc \
 libX11 \
 libXaw \
 libXmu \
 libXt \
 "
