# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rc"
PV = "1.7.4"
PR = "26.el10_2"
PACKAGES = " \
 rc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rc-1.7.4-26.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7eccf7f8dc6ffa15d2a495107fd859302faf8a438693735d1ee6bc54eb407ba3"

URI_x86_64_v2_rc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rc-1.7.4-26.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rc}"
SRC_URI[x86_64_v2_rc.sha256sum] = "43032eeff7689ef0d7871536b3511b79c1f4953991590e620701732f1b733bdd"

URI_aarch64_rc = "${EPEL_MIRROR}/aarch64/Packages/r/rc-1.7.4-26.el10_2.aarch64.rpm;name=aarch64_rc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rc}"
SRC_URI[aarch64_rc.sha256sum] = "220db007eec10442bc12e205e98c2dc57e67718a3fbb3a386e7e3eb01f6fc151"

RDEPENDS:rc = " \
 bash \
 glibc \
 grep \
 readline \
 sed \
 "
