# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet9.0"
PV = "9.0.121"
PR = "1.el10_2"
PACKAGES = " \
 aspnetcore-runtime-9.0 \
 aspnetcore-runtime-dbg-9.0 \
 aspnetcore-targeting-pack-9.0 \
 dotnet-apphost-pack-9.0 \
 dotnet-hostfxr-9.0 \
 dotnet-runtime-9.0 \
 dotnet-runtime-dbg-9.0 \
 dotnet-sdk-9.0 \
 dotnet-sdk-9.0-source-built-artifacts \
 dotnet-sdk-aot-9.0 \
 dotnet-sdk-dbg-9.0 \
 dotnet-targeting-pack-9.0 \
 dotnet-templates-9.0 \
 netstandard-targeting-pack-2.1 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet9.0-9.0.121-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "82d8488b8c55dcecb4e4052da0806e6025bf42cdf88399b8fd28c5626575b2ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-9.0-9.0.20-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-9.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-9.0.sha256sum] = "2ab61857b5c2438c400a25d3dc3b63de974965f9b488ac3d1fc3c9a9feb79762"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-9.0-9.0.20-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-9.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-9.0.sha256sum] = "ce4d18400eac6095517e3ebb531a0d3c7c687c3c9c32524864e0a6963358c929"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-9.0-9.0.20-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-9.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-9.0.sha256sum] = "f57c5c2e69beef51ac34e4325f3559e9b21f893e98c05f17a9425c3e922f4745"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-9.0-9.0.20-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-apphost-pack-9.0.sha256sum] = "efa94f64c50059db6ce32433e0d88dae6823554b5a060754fd874dd3ecf7b80d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-9.0-9.0.20-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-hostfxr-9.0.sha256sum] = "db6c981e2bdc69b6dc7d281020a3077097280a0e793a9f5507b47fa8e64fb055"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-9.0-9.0.20-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-9.0.sha256sum] = "7b4a259e11b9ec12a87616a7c578173317f971d857a37b9ca7079bee2f325658"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-9.0-9.0.20-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-9.0.sha256sum] = "127903328e2111888d4836f1193c4bcc059a270928b78a6c0ba953f80dd2764f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-9.0-9.0.121-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-9.0.sha256sum] = "cd9949c0957278317e3d7d3f083226635db600fadcbebd4de321a7944fa64520"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-9.0-source-built-artifacts-9.0.121-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-9.0-source-built-artifacts;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-9.0-source-built-artifacts.sha256sum] = "8a844f11faa194ee326a9c2ad31ca79c4c3c549295b617316d178c8a5d3ee2b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-aot-9.0-9.0.121-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-aot-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-aot-9.0.sha256sum] = "86392692d33159751a696b9c398bac63cbd0fccdde5b68dfa240403cc9de0ce3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-9.0-9.0.121-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-9.0.sha256sum] = "bf258e57404662ca9a7434f0b0da4419e8363f16ed900e8b5c6c189a308fc863"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-9.0-9.0.20-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-targeting-pack-9.0.sha256sum] = "b7d6e508a290ec613787979614fb138be031899aa32bba6de7d4e37a3f7c19ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-9.0-9.0.121-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-9.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-templates-9.0.sha256sum] = "b8656228c9c7fa87b4f2e5ff3fc4d6bfddc0ad3f2c1ffee089bf0e114c7f6058"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/netstandard-targeting-pack-2.1-9.0.121-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_netstandard-targeting-pack-2.1;unpack=0"
SRC_URI[x86_64_v2_netstandard-targeting-pack-2.1.sha256sum] = "4db435dfc509cb507651bd247fb352ec68ee231bc2ac4b7addb364c8b0fea3e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-9.0-9.0.20-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-runtime-9.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-9.0.sha256sum] = "09c4127c34f2e4cfa91733cff831231047377f16a828487b751e7ec60dd69167"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-9.0-9.0.20-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-9.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-dbg-9.0.sha256sum] = "260096241fe94411dcf5ab134317e85e337e8b0064c574446a68e25b723e8e50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-9.0-9.0.20-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-9.0;unpack=0"
SRC_URI[aarch64_aspnetcore-targeting-pack-9.0.sha256sum] = "f6560eca866f46720c56c4dabcf64047f7d783da31962d6ff5b7862fa6db63d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-9.0-9.0.20-1.el10_2.aarch64.rpm;name=aarch64_dotnet-apphost-pack-9.0;unpack=0"
SRC_URI[aarch64_dotnet-apphost-pack-9.0.sha256sum] = "8945cebbda7d64200abeda636f346ffae6e90010bbc555ad7ae41aad7fcde9e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-9.0-9.0.20-1.el10_2.aarch64.rpm;name=aarch64_dotnet-hostfxr-9.0;unpack=0"
SRC_URI[aarch64_dotnet-hostfxr-9.0.sha256sum] = "1074445394ed4ee3b154a3f9cda18010437103fa4d16ea7e28ed69a1e2ba1bfe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-9.0-9.0.20-1.el10_2.aarch64.rpm;name=aarch64_dotnet-runtime-9.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-9.0.sha256sum] = "9113ef7cc61062fdb9ef223a3a6922732fb2f88fb702d54555ac1552a759dda5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-9.0-9.0.20-1.el10_2.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-9.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-dbg-9.0.sha256sum] = "80c8147f5153c5a3a034af4c3fff6535e00979a01bae047818119f57a8da9f55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-9.0-9.0.121-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-9.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-9.0.sha256sum] = "6bc35269b2267efc0409f981405ed24763ee4a5e4c19a2de51d58c380ee40cc2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-9.0-source-built-artifacts-9.0.121-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-9.0-source-built-artifacts;unpack=0"
SRC_URI[aarch64_dotnet-sdk-9.0-source-built-artifacts.sha256sum] = "c68e680a3c0ea5c9316d50457d83359d147d62a818504311fd2d77752eb39740"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-aot-9.0-9.0.121-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-aot-9.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-aot-9.0.sha256sum] = "eb687a6394474e775fb3ab053efec8e0e19f50ad5e283c107d8b0183dfe2d3fc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-9.0-9.0.121-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-9.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-dbg-9.0.sha256sum] = "45f50c3c7c9146a6b6cf4963db503e9b91f04d9de611793afe490c8d0c70226d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-9.0-9.0.20-1.el10_2.aarch64.rpm;name=aarch64_dotnet-targeting-pack-9.0;unpack=0"
SRC_URI[aarch64_dotnet-targeting-pack-9.0.sha256sum] = "01b2df6cfd6470dc5b6095cbe9bfebe14af7ec8103aaf6be8a9bed66e0a6f770"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-9.0-9.0.121-1.el10_2.aarch64.rpm;name=aarch64_dotnet-templates-9.0;unpack=0"
SRC_URI[aarch64_dotnet-templates-9.0.sha256sum] = "e60c51c76603e68caf2c22502068e668e3ba03292f862513d23be807c161a0e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/netstandard-targeting-pack-2.1-9.0.121-1.el10_2.aarch64.rpm;name=aarch64_netstandard-targeting-pack-2.1;unpack=0"
SRC_URI[aarch64_netstandard-targeting-pack-2.1.sha256sum] = "ddddb8fb69e70874c515ccf59bc686a5aa35fb63f4681f66db7ee349b8618127"

RDEPENDS:aspnetcore-runtime-9.0 = " \
 dotnet-runtime-9.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-9.0 = " \
 aspnetcore-runtime-9.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-9.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-9.0 = " \
 dotnet-host \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-hostfxr-9.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-9.0 = " \
 dotnet-hostfxr-9.0 \
 glibc \
 libbrotli \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-9.0 = " \
 dotnet-runtime-9.0 \
 "
RDEPENDS:dotnet-sdk-9.0 = " \
 aspnetcore-runtime-9.0 \
 aspnetcore-targeting-pack-9.0 \
 dotnet-apphost-pack-9.0 \
 dotnet-runtime-9.0 \
 dotnet-targeting-pack-9.0 \
 dotnet-templates-9.0 \
 glibc \
 libgcc \
 libstdc++ \
 netstandard-targeting-pack-2.1 \
 "
RDEPENDS:dotnet-sdk-9.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-aot-9.0 = " \
 bash \
 brotli-devel \
 clang \
 dotnet-sdk-9.0 \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-devel \
 openssl-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:dotnet-sdk-dbg-9.0 = " \
 dotnet-sdk-9.0 \
 "
RDEPENDS:dotnet-targeting-pack-9.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-9.0 = " \
 dotnet-host \
 "
RDEPENDS:netstandard-targeting-pack-2.1 = " \
 dotnet-host \
 "
