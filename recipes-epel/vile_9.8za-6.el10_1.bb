# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vile"
PV = "9.8za"
PR = "6.el10_1"
PACKAGES = " \
 vile \
 vile-common \
 xvile \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vile-9.8za-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2d2087b1aab3f6d60c8ed67d10c3a1a6c8d5c44ae63abaad259ad92b7c1b2366"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vile-9.8za-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vile;unpack=0"
SRC_URI[x86_64_v2_vile.sha256sum] = "32124b5a6751450bb6c1ee46fee6c3c77d05c9c6b156093f8f5c723f890dfc81"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vile-common-9.8za-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vile-common;unpack=0"
SRC_URI[x86_64_v2_vile-common.sha256sum] = "4e677223f699e237bdbcbe4480752986d15febcb2045ace1b7fc43cfdc510a63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xvile-9.8za-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xvile;unpack=0"
SRC_URI[x86_64_v2_xvile.sha256sum] = "641f62364465c6954ab7d9fb3ad16f7348545a8478912b56013243f44f6eb748"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vile-9.8za-6.el10_1.aarch64.rpm;name=aarch64_vile;unpack=0"
SRC_URI[aarch64_vile.sha256sum] = "85ad67f60e98798f95a20666154febe6d0583e817f144419fef1fa51561c5205"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vile-common-9.8za-6.el10_1.aarch64.rpm;name=aarch64_vile-common;unpack=0"
SRC_URI[aarch64_vile-common.sha256sum] = "48c4c6508a87943375c1a3ac3d9791b67c741794e9813b0bf97e5e92a466e37c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xvile-9.8za-6.el10_1.aarch64.rpm;name=aarch64_xvile;unpack=0"
SRC_URI[aarch64_xvile.sha256sum] = "bd7fcf39a0d410b9ab05b97aa90f79ce3a8a781d93abb85d737a3d41341e9fe6"

RDEPENDS:vile = " \
 bash \
 glibc \
 libxcrypt \
 ncurses-libs \
 vile-common \
 "
RDEPENDS:vile-common = " \
 glibc \
 libxcrypt \
 "
RDEPENDS:xvile = " \
 bash \
 glibc \
 libX11 \
 libXaw \
 libXpm \
 libXt \
 libxcrypt \
 perl-I18N-Langinfo \
 perl-interpreter \
 perl-libs \
 vile-common \
 xorg-x11-fonts-misc \
 "
