# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zeroize_derive"
PV = "1.4.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-zeroize_derive+default-devel \
 rust-zeroize_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zeroize_derive-1.4.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d25bb2bb2c101664fad3b32319d790cd4e0f5903ec3d71c3d9c9a6f8a7d5f73"

URI_x86_64_v2_rust-zeroize_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize_derive+default-devel-1.4.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize_derive+default-devel}"
SRC_URI[x86_64_v2_rust-zeroize_derive+default-devel.sha256sum] = "4d201a9f949e71928a0c707dae6782ea071988780b1375646cd087e8f0e81705"

URI_x86_64_v2_rust-zeroize_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize_derive-devel-1.4.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize_derive-devel}"
SRC_URI[x86_64_v2_rust-zeroize_derive-devel.sha256sum] = "a69c46b14eb704a2cee67c84117dd6b7896b0333a76d45b3b3aa0f9666a474eb"

URI_aarch64_rust-zeroize_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize_derive+default-devel-1.4.2-4.el10_0.noarch.rpm;name=aarch64_rust-zeroize_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize_derive+default-devel}"
SRC_URI[aarch64_rust-zeroize_derive+default-devel.sha256sum] = "7a739f10a998d129c9b2e445deb8e516ec0ec7d223e7129ea0840de8656791bb"

URI_aarch64_rust-zeroize_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize_derive-devel-1.4.2-4.el10_0.noarch.rpm;name=aarch64_rust-zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize_derive-devel}"
SRC_URI[aarch64_rust-zeroize_derive-devel.sha256sum] = "3e33f5f1cfc18f2af1dfeda84c298abf5593264f660926eb5d122b50ab82297a"

RDEPENDS:rust-zeroize_derive+default-devel = " \
 cargo \
 rust-zeroize_derive-devel \
 "
RDEPENDS:rust-zeroize_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+visit-devel \
 "
