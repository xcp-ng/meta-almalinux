# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-welcome"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-welcome \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-welcome-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd986fa6ea8b1cfbe0fbea4c0202c222644e6420546485305cd9f260e6fa89fb"

URI_x86_64_v2_plasma-welcome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-welcome-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-welcome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-welcome}"
SRC_URI[x86_64_v2_plasma-welcome.sha256sum] = "b26c5466462fc15adb40ba8fafe8b02cb5274ed442c91ee2e48aeb833b15c8ca"

URI_aarch64_plasma-welcome = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-welcome-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-welcome;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-welcome}"
SRC_URI[aarch64_plasma-welcome.sha256sum] = "9ee14a523709b4251529eeca35ed2132996100e5850a36f51972d325cdd809d2"

RDEPENDS:plasma-welcome = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kuserfeedback \
 kf6-kwindowsystem \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
