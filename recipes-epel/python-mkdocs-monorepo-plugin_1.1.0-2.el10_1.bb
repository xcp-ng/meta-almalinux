# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-monorepo-plugin"
PV = "1.1.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-mkdocs-monorepo-plugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-monorepo-plugin-1.1.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d0a5cd1c68a63f7ed9327d7199bc92d0f8d55376e36451c72bd21852cc0e6a0"

URI_x86_64_v2_python3-mkdocs-monorepo-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-monorepo-plugin-1.1.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-monorepo-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-monorepo-plugin}"
SRC_URI[x86_64_v2_python3-mkdocs-monorepo-plugin.sha256sum] = "6225a1571a7a3e90b540639b270c3b28daf7a85584d2315057f6829b19449ed3"

URI_aarch64_python3-mkdocs-monorepo-plugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-monorepo-plugin-1.1.0-2.el10_1.noarch.rpm;name=aarch64_python3-mkdocs-monorepo-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-monorepo-plugin}"
SRC_URI[aarch64_python3-mkdocs-monorepo-plugin.sha256sum] = "64c863ffb4013ee83ef789028a0c13b31c64e61b5f73c7ca4dc902a60d77f082"

RDEPENDS:python3-mkdocs-monorepo-plugin = " \
 mkdocs \
 python3 \
 python3-slugify \
 "
