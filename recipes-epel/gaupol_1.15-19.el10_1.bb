# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gaupol"
PV = "1.15"
PR = "19.el10_1"
PACKAGES = " \
 gaupol \
 python3-aeidon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gaupol-1.15-19.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00fb6ba69f6fe4fd57862db3ba86e0e78d1dc6a9cc98ce923e0677c8ea98daba"

URI_x86_64_v2_gaupol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gaupol-1.15-19.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gaupol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gaupol}"
SRC_URI[x86_64_v2_gaupol.sha256sum] = "5c167d45c2fe9a2735cc5bb6b70ec69ebcf296b851fcacd9e7565af89ea34477"

URI_x86_64_v2_python3-aeidon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aeidon-1.15-19.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aeidon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aeidon}"
SRC_URI[x86_64_v2_python3-aeidon.sha256sum] = "08b9f7c50e9e68057925ee7dfd428d47ae4d8645f78f0105e9b74f96d37eb8e6"

URI_aarch64_gaupol = "${EPEL_MIRROR}/aarch64/Packages/g/gaupol-1.15-19.el10_1.noarch.rpm;name=aarch64_gaupol;unpack=0"
SRC_URI:append = " ${URI_aarch64_gaupol}"
SRC_URI[aarch64_gaupol.sha256sum] = "938248dd3202ff364cf8cd241c085301017fabfba176a9ee0aa0674698d1cd28"

URI_aarch64_python3-aeidon = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aeidon-1.15-19.el10_1.noarch.rpm;name=aarch64_python3-aeidon;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aeidon}"
SRC_URI[aarch64_python3-aeidon.sha256sum] = "1601b8a83b75059f204b0ab2284f19b2f2ddf764e99390a0e43db28320717d98"

RDEPENDS:gaupol = " \
 gspell \
 gstreamer1 \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 gstreamer1-plugins-good-gtk \
 gtk3 \
 hicolor-icon-theme \
 iso-codes \
 python3 \
 python3-aeidon \
 python3-gobject-base \
 "
RDEPENDS:python3-aeidon = " \
 gspell \
 iso-codes \
 python3 \
 python3-charset-normalizer \
 python3-gobject-base \
 "
