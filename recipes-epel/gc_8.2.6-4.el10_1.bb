# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gc"
PV = "8.2.6"
PR = "4.el10_1"
PACKAGES = " \
 gc \
 gc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gc-8.2.6-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa8d8d3b6c0754adbd93d906803bf302adec5f5a2a160ac8bbfc2d16e3c7c257"

URI_x86_64_v2_gc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gc-8.2.6-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gc}"
SRC_URI[x86_64_v2_gc.sha256sum] = "c37ad805b45e48cdabbbfacdaeab9a4bf1e3829440113005a963d9631d7d726d"

URI_x86_64_v2_gc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gc-devel-8.2.6-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gc-devel}"
SRC_URI[x86_64_v2_gc-devel.sha256sum] = "6a7bc8f27e7ddf36c5a89059415030e7f501c564dc1c674c806834e513ee3a4e"

URI_aarch64_gc = "${EPEL_MIRROR}/aarch64/Packages/g/gc-8.2.6-4.el10_1.aarch64.rpm;name=aarch64_gc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gc}"
SRC_URI[aarch64_gc.sha256sum] = "68ed44cd32bb7eec9ff8a471cede5ee5f490f2608bf8f6cb4cf230ef9063b705"

URI_aarch64_gc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gc-devel-8.2.6-4.el10_1.aarch64.rpm;name=aarch64_gc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gc-devel}"
SRC_URI[aarch64_gc-devel.sha256sum] = "024e338dc5e2621a3910724249f2d79ed64a4405538bd2ff3d1297761bfbf639"

RDEPENDS:gc = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gc-devel = " \
 gc \
 pkgconf-pkg-config \
 "
