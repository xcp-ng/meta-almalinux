# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-native-certs0.7"
PV = "0.7.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-rustls-native-certs0.7+default-devel \
 rust-rustls-native-certs0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-native-certs0.7-0.7.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e64d71a85fa7e671b83ea26279539bd1dbbe09c5b0ca3b6e8bd808c48165334"

URI_x86_64_v2_rust-rustls-native-certs0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-native-certs0.7+default-devel-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-native-certs0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-native-certs0.7+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-native-certs0.7+default-devel.sha256sum] = "067a14a4773d1e96afc4b48246fd998dbb5df89adc72307e9779e05d88c49a9a"

URI_x86_64_v2_rust-rustls-native-certs0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-native-certs0.7-devel-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-native-certs0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-native-certs0.7-devel}"
SRC_URI[x86_64_v2_rust-rustls-native-certs0.7-devel.sha256sum] = "5381206f901888fd1ed23659491db61d6e8cb91f9644a7c9d280dfc9274f5345"

URI_aarch64_rust-rustls-native-certs0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-native-certs0.7+default-devel-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-native-certs0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-native-certs0.7+default-devel}"
SRC_URI[aarch64_rust-rustls-native-certs0.7+default-devel.sha256sum] = "a3fa96383808b0141a074979e62e40da3d9981c032a510fc668e91f61d070994"

URI_aarch64_rust-rustls-native-certs0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-native-certs0.7-devel-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-native-certs0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-native-certs0.7-devel}"
SRC_URI[aarch64_rust-rustls-native-certs0.7-devel.sha256sum] = "ae05314516949b537ffc2bc9dbbb2ad764c6dd606af8d2127263fcb70a3ce31b"

RDEPENDS:rust-rustls-native-certs0.7+default-devel = " \
 cargo \
 rust-rustls-native-certs0.7-devel \
 "
RDEPENDS:rust-rustls-native-certs0.7-devel = " \
 cargo \
 rust \
 rust-openssl-probe0.1+default-devel \
 rust-rustls-pemfile+default-devel \
 rust-rustls-pki-types+default-devel \
 "
