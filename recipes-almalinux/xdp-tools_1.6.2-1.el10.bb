# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdp-tools"
PV = "1.6.2"
PR = "1.el10"
PACKAGES = " \
 libxdp \
 libxdp-devel \
 libxdp-static \
 xdp-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xdp-tools-1.6.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c66c9bb38d512e5ed46c1def6cb2d85f1a2d3f5897dbc12c5cb07b9a84860fc"

URI_x86_64_v2_libxdp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxdp-1.6.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_libxdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxdp}"
SRC_URI[x86_64_v2_libxdp.sha256sum] = "0c23dcb82e663031e0bb3aaa8c5d506bdbac510810a441cac70446140500a45d"

URI_x86_64_v2_libxdp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxdp-devel-1.6.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_libxdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxdp-devel}"
SRC_URI[x86_64_v2_libxdp-devel.sha256sum] = "51f230791fa8010a0d9b8a3ae050769bcbc94b6708afa7cdd51b418f1df4abc9"

URI_x86_64_v2_libxdp-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxdp-static-1.6.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_libxdp-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxdp-static}"
SRC_URI[x86_64_v2_libxdp-static.sha256sum] = "0e8856012f19ca529f369d0bdab72a7eb28ffdbbaec56f66e2b3c4829530fd0a"

URI_x86_64_v2_xdp-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xdp-tools-1.6.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_xdp-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdp-tools}"
SRC_URI[x86_64_v2_xdp-tools.sha256sum] = "5400f776d354431d576458f1e658a59d66086d2c3eae371cfbd07e89618ec5a5"

URI_aarch64_libxdp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxdp-1.6.2-1.el10.aarch64.rpm;name=aarch64_libxdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxdp}"
SRC_URI[aarch64_libxdp.sha256sum] = "38e56c95d3f95e6d0623028d3202545584ef30b06ebc9c7d1562d107a5fde657"

URI_aarch64_libxdp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxdp-devel-1.6.2-1.el10.aarch64.rpm;name=aarch64_libxdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxdp-devel}"
SRC_URI[aarch64_libxdp-devel.sha256sum] = "9b0e294f7107b64fd178878d9b9422d83f596ff94ce1c62391a46e32bd59e5a9"

URI_aarch64_libxdp-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxdp-static-1.6.2-1.el10.aarch64.rpm;name=aarch64_libxdp-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxdp-static}"
SRC_URI[aarch64_libxdp-static.sha256sum] = "529a8404ec3235d9cdb1bcb026421c6482d3572c76f744fdf72bea56c22b8324"

URI_aarch64_xdp-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xdp-tools-1.6.2-1.el10.aarch64.rpm;name=aarch64_xdp-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdp-tools}"
SRC_URI[aarch64_xdp-tools.sha256sum] = "689265a35feb15ab515b31a3341a0318a3a990d2baab39e561d84fea7e0d86be"

RDEPENDS:libxdp = " \
 glibc \
 libbpf \
 "
RDEPENDS:libxdp-devel = " \
 kernel-headers \
 libbpf-devel \
 libxdp \
 pkgconf-pkg-config \
 "
RDEPENDS:libxdp-static = " \
 libxdp-devel \
 "
RDEPENDS:xdp-tools = " \
 bash \
 glibc \
 libbpf \
 libcap-ng \
 libpcap \
 libxdp \
 "
