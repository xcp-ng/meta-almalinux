# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-filter-repo"
PV = "2.38.0"
PR = "6.el10_0"
PACKAGES = " \
 git-filter-repo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/git-filter-repo-2.38.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0a10aca4175a50d696f7702c96d77f13582e8f8441877fb7a586f8b010b582b"

URI_x86_64_v2_git-filter-repo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-filter-repo-2.38.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_git-filter-repo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-filter-repo}"
SRC_URI[x86_64_v2_git-filter-repo.sha256sum] = "0c3891c74840644527a1fe67b1f86197a49421cdb955fe27327cabdacc95988a"

URI_aarch64_git-filter-repo = "${EPEL_MIRROR}/aarch64/Packages/g/git-filter-repo-2.38.0-6.el10_0.noarch.rpm;name=aarch64_git-filter-repo;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-filter-repo}"
SRC_URI[aarch64_git-filter-repo.sha256sum] = "6f400f5eeb108e2eb718bea242b5decc671c377107e477f1f742b6846efa6fa8"

RDEPENDS:git-filter-repo = " \
 git-core \
 python3 \
 "
