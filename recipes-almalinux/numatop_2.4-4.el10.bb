# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "numatop"
PV = "2.4"
PR = "4.el10"
PACKAGES:x86_64_v2 = " \
 numatop \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/numatop-2.4-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d37e248bc9129b8b3011d08e8c53fb7e6cb42825bc2013729049c6fcd89b44b4"

URI_x86_64_v2_numatop = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/numatop-2.4-4.el10.x86_64_v2.rpm;name=x86_64_v2_numatop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numatop}"
SRC_URI[x86_64_v2_numatop.sha256sum] = "c9e628ee2ef62283a41cf7b3222928c35df8c7fed88a131fc94b8189e5cdd816"

RDEPENDS:numatop = " \
 glibc \
 ncurses-libs \
 numactl-libs \
 "
