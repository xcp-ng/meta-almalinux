# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konqueror"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 konqueror \
 konqueror-devel \
 konqueror-libs \
 kwebenginepart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konqueror-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15d4e3b56d6e2b5ede9c3a0c4047c4a7a2d6e382726e08625dc987a19583e90f"

URI_x86_64_v2_konqueror = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konqueror}"
SRC_URI[x86_64_v2_konqueror.sha256sum] = "f3469684650e4231bea025619c7ebeaa7f7f344cd979a1c7f8ebffd1df80e985"

URI_x86_64_v2_konqueror-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konqueror-devel}"
SRC_URI[x86_64_v2_konqueror-devel.sha256sum] = "8e691fe4e57c53bf79e03b508ec94af5b02ef3fe5193be7ce6e254038fc13822"

URI_x86_64_v2_konqueror-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konqueror-libs}"
SRC_URI[x86_64_v2_konqueror-libs.sha256sum] = "c35231a47d07d8fbb573874977fdd8843cbe859bc5532ba090f29fb135caaeb7"

URI_x86_64_v2_kwebenginepart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwebenginepart-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwebenginepart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwebenginepart}"
SRC_URI[x86_64_v2_kwebenginepart.sha256sum] = "8150f8219d8fc6d28d2a93c840e5a5e8bc397f389a9063d67c198348631b15df"

URI_aarch64_konqueror = "${EPEL_MIRROR}/aarch64/Packages/k/konqueror-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_konqueror;unpack=0"
SRC_URI:append = " ${URI_aarch64_konqueror}"
SRC_URI[aarch64_konqueror.sha256sum] = "c80c88992f6a7b1646c55fe0654155ec899c79ec001224af6c45ab063423da83"

URI_aarch64_konqueror-devel = "${EPEL_MIRROR}/aarch64/Packages/k/konqueror-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_konqueror-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_konqueror-devel}"
SRC_URI[aarch64_konqueror-devel.sha256sum] = "d6292ec4d00cc3c7f2710540ed4cd2dd53819bb62ddfee690ed35099d3c3b8d3"

URI_aarch64_konqueror-libs = "${EPEL_MIRROR}/aarch64/Packages/k/konqueror-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_konqueror-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_konqueror-libs}"
SRC_URI[aarch64_konqueror-libs.sha256sum] = "cdff616d0303806c33809bb09fd98d12cdb98f230523f006c5eefc78a68272a1"

URI_aarch64_kwebenginepart = "${EPEL_MIRROR}/aarch64/Packages/k/kwebenginepart-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kwebenginepart;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwebenginepart}"
SRC_URI[aarch64_kwebenginepart.sha256sum] = "36bf79279ad3f6e05f482e44b138e9f487c0b189ba9ad5ad2851e0a9e7150a3a"

RDEPENDS:konqueror = " \
 glibc \
 hicolor-icon-theme \
 keditbookmarks \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 konqueror-libs \
 kwebenginepart \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:konqueror-devel = " \
 cmake-filesystem \
 konqueror \
 konqueror-libs \
 "
RDEPENDS:konqueror-libs = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdesu \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 konqueror \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 zlib-ng-compat \
 "
RDEPENDS:kwebenginepart = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 konqueror-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
