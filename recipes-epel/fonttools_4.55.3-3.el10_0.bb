# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fonttools"
PV = "4.55.3"
PR = "3.el10_0"
PACKAGES:x86_64_v2 = " \
  \
"
PACKAGES:aarch64 = " \
 fonttools \
 python3-fonttools \
 python3-fonttools+graphite \
 python3-fonttools+interpolatable \
 python3-fonttools+lxml \
 python3-fonttools+plot \
 python3-fonttools+type1 \
 python3-fonttools+ufo \
 python3-fonttools+unicode \
 python3-fonttools+woff \
"

URI_src = "${EPELSRC_MIRROR}/Packages/f/fonttools-4.55.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a121aab664e43e3f7f75686bdb6e470df2da7d330aa3e6e7742567bcd347d1ba"

URI_aarch64_fonttools = "${EPEL_MIRROR}/aarch64/Packages/f/fonttools-4.55.3-3.el10_0.aarch64.rpm;name=aarch64_fonttools;unpack=0"
SRC_URI:append = " ${URI_aarch64_fonttools}"
SRC_URI[aarch64_fonttools.sha256sum] = "c96ac494c17c49a81c17dd7a783afc2fa136456fdd1534d29b1f4e4d40dcf5fe"

URI_aarch64_python3-fonttools = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools-4.55.3-3.el10_0.aarch64.rpm;name=aarch64_python3-fonttools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools}"
SRC_URI[aarch64_python3-fonttools.sha256sum] = "d5c5560cd1de4d6b1763364ca98764170194c1fa489297e4b9bc9710d61bd096"

URI_aarch64_python3-fonttools+graphite = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+graphite-4.55.3-3.el10_0.aarch64.rpm;name=aarch64_python3-fonttools+graphite;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+graphite}"
SRC_URI[aarch64_python3-fonttools+graphite.sha256sum] = "a7bac05180d887f94991811f94c26c39658e8b5c7aef6d8a8bd8b361703ac76b"

URI_aarch64_python3-fonttools+interpolatable = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+interpolatable-4.55.3-3.el10_0.aarch64.rpm;name=aarch64_python3-fonttools+interpolatable;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+interpolatable}"
SRC_URI[aarch64_python3-fonttools+interpolatable.sha256sum] = "af1225c1ea317a62fcd2349c28db09cf3bcce6399c37ab55fbb1906cba1553ca"

URI_aarch64_python3-fonttools+lxml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+lxml-4.55.3-3.el10_0.aarch64.rpm;name=aarch64_python3-fonttools+lxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+lxml}"
SRC_URI[aarch64_python3-fonttools+lxml.sha256sum] = "92baa71784243b3c8da443464ad69bd6b3f1f0e3859288d53b6eff93fda35717"

URI_aarch64_python3-fonttools+plot = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+plot-4.55.3-3.el10_0.aarch64.rpm;name=aarch64_python3-fonttools+plot;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+plot}"
SRC_URI[aarch64_python3-fonttools+plot.sha256sum] = "fc835a5747a1a1fee389ea5397914c486914e84351d0317de655e6884ab2781a"

URI_aarch64_python3-fonttools+type1 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+type1-4.55.3-3.el10_0.aarch64.rpm;name=aarch64_python3-fonttools+type1;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+type1}"
SRC_URI[aarch64_python3-fonttools+type1.sha256sum] = "ddeb958e0a633c389d61786afe55bc20d303a300e208b6c814e7c57de0ce014f"

URI_aarch64_python3-fonttools+ufo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+ufo-4.55.3-3.el10_0.aarch64.rpm;name=aarch64_python3-fonttools+ufo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+ufo}"
SRC_URI[aarch64_python3-fonttools+ufo.sha256sum] = "6642fd1916ef45c2b8442a0f4efb24f72ab3ec9a13885d2b19a5802a3b93add1"

URI_aarch64_python3-fonttools+unicode = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+unicode-4.55.3-3.el10_0.aarch64.rpm;name=aarch64_python3-fonttools+unicode;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+unicode}"
SRC_URI[aarch64_python3-fonttools+unicode.sha256sum] = "38252584b5538af5a1b1d41f2183f867820959490e049a2dc9aea9ef9c4a00ff"

URI_aarch64_python3-fonttools+woff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+woff-4.55.3-3.el10_0.aarch64.rpm;name=aarch64_python3-fonttools+woff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+woff}"
SRC_URI[aarch64_python3-fonttools+woff.sha256sum] = "db88ce0dee32c5753fda44c8fc0488b55c4deb18113a47f5e319d80095812f41"

RDEPENDS:fonttools = " \
 python3 \
 python3-fonttools \
 "
RDEPENDS:python3-fonttools = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-fonttools+graphite = " \
 python3 \
 python3-fonttools \
 python3-lz4 \
 "
RDEPENDS:python3-fonttools+interpolatable = " \
 python3 \
 python3-cairo \
 python3-fonttools \
 python3-scipy \
 "
RDEPENDS:python3-fonttools+lxml = " \
 python3 \
 python3-fonttools \
 python3-lxml \
 "
RDEPENDS:python3-fonttools+plot = " \
 python3 \
 python3-fonttools \
 python3-matplotlib \
 "
RDEPENDS:python3-fonttools+type1 = " \
 python3 \
 python3-fonttools \
 "
RDEPENDS:python3-fonttools+ufo = " \
 python3 \
 python3-fonttools \
 python3-fs \
 "
RDEPENDS:python3-fonttools+unicode = " \
 python3 \
 python3-fonttools \
 python3-unicodedata2 \
 "
RDEPENDS:python3-fonttools+woff = " \
 python3 \
 python3-brotli \
 python3-fonttools \
 python3-zopfli \
 "
