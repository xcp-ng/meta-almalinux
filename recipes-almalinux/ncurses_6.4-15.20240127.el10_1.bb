# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ncurses"
PV = "6.4"
PR = "15.20240127.el10_1"
PACKAGES = " \
 ncurses \
 ncurses-base \
 ncurses-c++-libs \
 ncurses-devel \
 ncurses-libs \
 ncurses-term \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ncurses-6.4-15.20240127.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2edc0dffda8aaf4dd6844728e39558d2560bf7565f45ec24a76c0235799470f"

URI_x86_64_v2_ncurses = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ncurses-6.4-15.20240127.el10_1.x86_64_v2.rpm;name=x86_64_v2_ncurses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncurses}"
SRC_URI[x86_64_v2_ncurses.sha256sum] = "84042cd382b7cd6b3e0dded59a5d054d17b264a7237717d53f3eb9bfe8080932"

URI_x86_64_v2_ncurses-base = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ncurses-base-6.4-15.20240127.el10_1.noarch.rpm;name=x86_64_v2_ncurses-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncurses-base}"
SRC_URI[x86_64_v2_ncurses-base.sha256sum] = "efc7cace8436b8383bb62c7689de692ca32cfb54f07d50b4c8255faf9d34b82d"

URI_x86_64_v2_ncurses-c++-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ncurses-c++-libs-6.4-15.20240127.el10_1.x86_64_v2.rpm;name=x86_64_v2_ncurses-c++-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncurses-c++-libs}"
SRC_URI[x86_64_v2_ncurses-c++-libs.sha256sum] = "cb04918aeefb87f67386853b8704f6b81a77e5e87073fc1da288570123af2787"

URI_x86_64_v2_ncurses-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ncurses-devel-6.4-15.20240127.el10_1.x86_64_v2.rpm;name=x86_64_v2_ncurses-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncurses-devel}"
SRC_URI[x86_64_v2_ncurses-devel.sha256sum] = "ab4504bb5b8585a3c8cc61d07430036541c37f69cfd0ad935aec2102e1d18d61"

URI_x86_64_v2_ncurses-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ncurses-libs-6.4-15.20240127.el10_1.x86_64_v2.rpm;name=x86_64_v2_ncurses-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncurses-libs}"
SRC_URI[x86_64_v2_ncurses-libs.sha256sum] = "3d42ba3d71cb3144e5400e3a6ab9320cea057828d0e3010631dbe1f07f3a37b3"

URI_x86_64_v2_ncurses-term = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ncurses-term-6.4-15.20240127.el10_1.noarch.rpm;name=x86_64_v2_ncurses-term;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncurses-term}"
SRC_URI[x86_64_v2_ncurses-term.sha256sum] = "ee0554d1e014600aae21f0c71884a5dcbd420eac42910fff38760b60f1b9ed76"

URI_aarch64_ncurses = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ncurses-6.4-15.20240127.el10_1.aarch64.rpm;name=aarch64_ncurses;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncurses}"
SRC_URI[aarch64_ncurses.sha256sum] = "887130c42a0bb08a3102ad6837d75a7382ecd2e204b3a33e4575070f563d0cc1"

URI_aarch64_ncurses-base = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ncurses-base-6.4-15.20240127.el10_1.noarch.rpm;name=aarch64_ncurses-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncurses-base}"
SRC_URI[aarch64_ncurses-base.sha256sum] = "efc7cace8436b8383bb62c7689de692ca32cfb54f07d50b4c8255faf9d34b82d"

URI_aarch64_ncurses-c++-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ncurses-c++-libs-6.4-15.20240127.el10_1.aarch64.rpm;name=aarch64_ncurses-c++-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncurses-c++-libs}"
SRC_URI[aarch64_ncurses-c++-libs.sha256sum] = "e696b5f0f7cf31d7e3a4f62b9d7a9506ad701eab2671bce98f000b3da92b2d74"

URI_aarch64_ncurses-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ncurses-devel-6.4-15.20240127.el10_1.aarch64.rpm;name=aarch64_ncurses-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncurses-devel}"
SRC_URI[aarch64_ncurses-devel.sha256sum] = "4aff38d678a5486e9cfa9ae32b878384617c53cdac6429696fc1e28c1e06bab6"

URI_aarch64_ncurses-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ncurses-libs-6.4-15.20240127.el10_1.aarch64.rpm;name=aarch64_ncurses-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncurses-libs}"
SRC_URI[aarch64_ncurses-libs.sha256sum] = "9739c005a86afd1a4d6090c9e5ea1b5f42a4c3c5c655f59e83f99a6756e94c30"

URI_aarch64_ncurses-term = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ncurses-term-6.4-15.20240127.el10_1.noarch.rpm;name=aarch64_ncurses-term;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncurses-term}"
SRC_URI[aarch64_ncurses-term.sha256sum] = "ee0554d1e014600aae21f0c71884a5dcbd420eac42910fff38760b60f1b9ed76"

RDEPENDS:ncurses = " \
 glibc \
 ncurses-libs \
 "
RDEPENDS:ncurses-base = " \
 "
RDEPENDS:ncurses-c++-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 "
RDEPENDS:ncurses-devel = " \
 bash \
 ncurses-c++-libs \
 ncurses-devel \
 ncurses-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:ncurses-libs = " \
 glibc \
 ncurses-base \
 "
RDEPENDS:ncurses-term = " \
 ncurses-base \
 "
