# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiohappyeyeballs"
PV = "2.4.4"
PR = "5.el10_1"
PACKAGES = " \
 python3-aiohappyeyeballs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiohappyeyeballs-2.4.4-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07cea0eb012666da614f0b1f915d192c3c39268efdb8d497b6a2d480e2884936"

URI_x86_64_v2_python3-aiohappyeyeballs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiohappyeyeballs-2.4.4-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aiohappyeyeballs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiohappyeyeballs}"
SRC_URI[x86_64_v2_python3-aiohappyeyeballs.sha256sum] = "fa2f24b994e874c7f3a4f47755a4fb5088b0fda7a38f0ea176054572b57ae5c5"

URI_aarch64_python3-aiohappyeyeballs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiohappyeyeballs-2.4.4-5.el10_1.noarch.rpm;name=aarch64_python3-aiohappyeyeballs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiohappyeyeballs}"
SRC_URI[aarch64_python3-aiohappyeyeballs.sha256sum] = "b0cca4a139f89c971dc3389ecca4015b1d5efcac6ec711394f686e5e4d462f2d"

RDEPENDS:python3-aiohappyeyeballs = " \
 python3 \
 "
