# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-common"
PV = "3.18.0"
PR = "20.el10_0"
PACKAGES = " \
 gnome-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-common-3.18.0-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "069c868a38af1e9db8b00cb04a4919b6634738416612854563792dcb3714b47f"

URI_x86_64_v2_gnome-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-common-3.18.0-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-common}"
SRC_URI[x86_64_v2_gnome-common.sha256sum] = "b708b40808919c2bee370bc808b457fe480b9969f1bd6054d34090d780722d18"

URI_aarch64_gnome-common = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-common-3.18.0-20.el10_0.noarch.rpm;name=aarch64_gnome-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-common}"
SRC_URI[aarch64_gnome-common.sha256sum] = "180f3f7289cd34559283283a7c6cbad6bb14585903b99edd15a6086adf5b5e8e"

RDEPENDS:gnome-common = " \
 autoconf \
 autoconf-archive \
 automake \
 bash \
 gettext \
 libtool \
 pkgconf-pkg-config \
 yelp-tools \
 "
