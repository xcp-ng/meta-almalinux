# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-sonnet"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-sonnet \
 kf6-sonnet-aspell \
 kf6-sonnet-devel \
 kf6-sonnet-doc \
 kf6-sonnet-hspell \
 kf6-sonnet-html \
 kf6-sonnet-hunspell \
 kf6-sonnet-voikko \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-sonnet-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af2f0da472e6277fb29f11d2058eaaa7fa7cde9219a75e9afabe1219a3135be3"

URI_x86_64_v2_kf6-sonnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet}"
SRC_URI[x86_64_v2_kf6-sonnet.sha256sum] = "b3933713ca641cf0cc656489b443cd066bf3e560a0e2ce07228c780b11c3a6a9"

URI_x86_64_v2_kf6-sonnet-aspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-aspell-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-aspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-aspell}"
SRC_URI[x86_64_v2_kf6-sonnet-aspell.sha256sum] = "679e7922b1f55d4a575e8c17c468b3db92b92dc13826779fdedfcbb08e87b9bb"

URI_x86_64_v2_kf6-sonnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-devel}"
SRC_URI[x86_64_v2_kf6-sonnet-devel.sha256sum] = "bf2a7a5b7b3c0ac8c8786cc2201c926967d52601254125bcd2a1a78b28e1ded4"

URI_x86_64_v2_kf6-sonnet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-sonnet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-doc}"
SRC_URI[x86_64_v2_kf6-sonnet-doc.sha256sum] = "950ade4819cf06a66b29128630edc0ab7a8a9ebdc33683db941ec00c5d79438c"

URI_x86_64_v2_kf6-sonnet-hspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-hspell-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-hspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-hspell}"
SRC_URI[x86_64_v2_kf6-sonnet-hspell.sha256sum] = "c31a0c75757ba0f1f4ffecac1ed434f63867fa3c3be249d178013d29c9d9b3c9"

URI_x86_64_v2_kf6-sonnet-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-sonnet-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-html}"
SRC_URI[x86_64_v2_kf6-sonnet-html.sha256sum] = "2b3888035f65375de380648282c3a60cfb6caf40b792e1d5310bb0da1cc8c375"

URI_x86_64_v2_kf6-sonnet-hunspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-hunspell-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-hunspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-hunspell}"
SRC_URI[x86_64_v2_kf6-sonnet-hunspell.sha256sum] = "e4a23b1ddf2edb3a0cc6f96c75991da9fa6760f6cd3e17a2485850be6bb0ea57"

URI_x86_64_v2_kf6-sonnet-voikko = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-voikko-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-voikko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-voikko}"
SRC_URI[x86_64_v2_kf6-sonnet-voikko.sha256sum] = "4039544f2c8e5849ab547c13b03c1a34f3caae1c095a9ea3cbf570566a664a8a"

URI_aarch64_kf6-sonnet = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-sonnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet}"
SRC_URI[aarch64_kf6-sonnet.sha256sum] = "e8224f35bc9486c8593a78e5d220947b97322e990d1a9be6c837700a3c5e3e73"

URI_aarch64_kf6-sonnet-aspell = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-aspell-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-sonnet-aspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-aspell}"
SRC_URI[aarch64_kf6-sonnet-aspell.sha256sum] = "f066c725cd6ac4eee73ef496a41edb07ac1ae894358e33343e99ed0504c19dac"

URI_aarch64_kf6-sonnet-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-sonnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-devel}"
SRC_URI[aarch64_kf6-sonnet-devel.sha256sum] = "38ad51e03b6b6323dc4827952dc22463b6f2a52e83f2f87c694bb9117e134407"

URI_aarch64_kf6-sonnet-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-sonnet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-doc}"
SRC_URI[aarch64_kf6-sonnet-doc.sha256sum] = "b22feed790939e7e55730503cf4153c34cf3164cb95f715c64e0a1404b6232b1"

URI_aarch64_kf6-sonnet-hspell = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-hspell-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-sonnet-hspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-hspell}"
SRC_URI[aarch64_kf6-sonnet-hspell.sha256sum] = "ba605d0e42dd6fc56a1f038b3634dffe82c1b676ecd1dca7816d738ea04b4a15"

URI_aarch64_kf6-sonnet-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-sonnet-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-html}"
SRC_URI[aarch64_kf6-sonnet-html.sha256sum] = "3d48d1bf48496d1eaa66ac2485af2623e36e91a0d3bd42c58a31a5910f80b8c3"

URI_aarch64_kf6-sonnet-hunspell = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-hunspell-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-sonnet-hunspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-hunspell}"
SRC_URI[aarch64_kf6-sonnet-hunspell.sha256sum] = "cb2854b19c6d77b6d0c6a9ee36e864e1aefa028110d466cf3485453c3b3560e3"

URI_aarch64_kf6-sonnet-voikko = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-voikko-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-sonnet-voikko;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-voikko}"
SRC_URI[aarch64_kf6-sonnet-voikko.sha256sum] = "def966902d3ee6c6072c243fbb18fccf1a7fafc1d7ef3ae8976b5c963ab3e1d6"

RDEPENDS:kf6-sonnet = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-sonnet-aspell = " \
 aspell \
 glibc \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-devel = " \
 cmake-filesystem \
 glibc \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-sonnet-doc = " \
 "
RDEPENDS:kf6-sonnet-hspell = " \
 glibc \
 hspell \
 hunspell-he \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-html = " \
 "
RDEPENDS:kf6-sonnet-hunspell = " \
 glibc \
 hunspell \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-voikko = " \
 glibc \
 kf6-sonnet \
 libstdc++ \
 libvoikko \
 qt6-qtbase \
 "
