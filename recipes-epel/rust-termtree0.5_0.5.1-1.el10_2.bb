# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-termtree0.5"
PV = "0.5.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-termtree0.5+default-devel \
 rust-termtree0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-termtree0.5-0.5.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6d6c62af9b6690fb03d02bc1a93641a1da95fdc4d8bc766942247d3f651f755"

URI_x86_64_v2_rust-termtree0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termtree0.5+default-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termtree0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termtree0.5+default-devel}"
SRC_URI[x86_64_v2_rust-termtree0.5+default-devel.sha256sum] = "9b372dee3fabd7b8603e3b624d7d09a634ad6f3d2a6c19819b7fe2f9c7da3797"

URI_x86_64_v2_rust-termtree0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termtree0.5-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termtree0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termtree0.5-devel}"
SRC_URI[x86_64_v2_rust-termtree0.5-devel.sha256sum] = "543a07942eb0258fc9102f9297d10e438dc0f26158e25807194aa1e781595ded"

URI_aarch64_rust-termtree0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termtree0.5+default-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-termtree0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termtree0.5+default-devel}"
SRC_URI[aarch64_rust-termtree0.5+default-devel.sha256sum] = "162855ea00d660402fea69a85840d966be57eff171e9e65012c05f7733c90785"

URI_aarch64_rust-termtree0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termtree0.5-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-termtree0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termtree0.5-devel}"
SRC_URI[aarch64_rust-termtree0.5-devel.sha256sum] = "71c9c9a706c6de22f16174e9c518e10e7632934585fdd528888aed6964271ac9"

RDEPENDS:rust-termtree0.5+default-devel = " \
 cargo \
 rust-termtree0.5-devel \
 "
RDEPENDS:rust-termtree0.5-devel = " \
 cargo \
 rust \
 "
