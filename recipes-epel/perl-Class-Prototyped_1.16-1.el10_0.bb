# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Prototyped"
PV = "1.16"
PR = "1.el10_0"
PACKAGES = " \
 perl-Class-Prototyped \
 perl-Class-Prototyped-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Prototyped-1.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5dbce0cddd01a033194d05e0074db8e449449ae23e3c7ef5f253df1688efd68c"

URI_x86_64_v2_perl-Class-Prototyped = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Prototyped-1.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Prototyped;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Prototyped}"
SRC_URI[x86_64_v2_perl-Class-Prototyped.sha256sum] = "21a283301575804cbe9f2410ce4916fbb2d77d544743d1413c7c93ac2d775e1a"

URI_x86_64_v2_perl-Class-Prototyped-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Prototyped-tests-1.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Prototyped-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Prototyped-tests}"
SRC_URI[x86_64_v2_perl-Class-Prototyped-tests.sha256sum] = "1b0dea8bcee11f01cf2cca8a7e01bc57cd52a5d560891fdb46ac72785571ed02"

URI_aarch64_perl-Class-Prototyped = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Prototyped-1.16-1.el10_0.noarch.rpm;name=aarch64_perl-Class-Prototyped;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Prototyped}"
SRC_URI[aarch64_perl-Class-Prototyped.sha256sum] = "9353b4c38c3f9b085fb9323254d8a28fd36fb874ec0904024e4c732f7f68ab26"

URI_aarch64_perl-Class-Prototyped-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Prototyped-tests-1.16-1.el10_0.noarch.rpm;name=aarch64_perl-Class-Prototyped-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Prototyped-tests}"
SRC_URI[aarch64_perl-Class-Prototyped-tests.sha256sum] = "5e77691f47094bc65594834e010de579f13e8a1469a3de5e1b367a98c45db952"

RDEPENDS:perl-Class-Prototyped = " \
 perl-Carp \
 perl-Class-Prototyped \
 perl-GraphViz \
 perl-IO \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Class-Prototyped-tests = " \
 bash \
 perl-Class-Prototyped \
 perl-Data-Dumper \
 perl-IO \
 perl-Test \
 perl-Test-Harness \
 perl-lib \
 perl-libs \
 "
