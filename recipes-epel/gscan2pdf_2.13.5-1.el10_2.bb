# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gscan2pdf"
PV = "2.13.5"
PR = "1.el10_2"
PACKAGES = " \
 gscan2pdf \
 gscan2pdf-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gscan2pdf-2.13.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5576cc53531fdbcdb310f59a3cdd354a372285bafafb3817e49caef78f1d3172"

URI_x86_64_v2_gscan2pdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gscan2pdf-2.13.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gscan2pdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gscan2pdf}"
SRC_URI[x86_64_v2_gscan2pdf.sha256sum] = "6fa7a5236b8c894f8b2333b0e8e935422c53ee36f5c3cace382824c3714273d6"

URI_x86_64_v2_gscan2pdf-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gscan2pdf-tests-2.13.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gscan2pdf-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gscan2pdf-tests}"
SRC_URI[x86_64_v2_gscan2pdf-tests.sha256sum] = "9eea211c2d3b831b0629c8794ebd7d3cb6f54aa3f4e886ec53420f781351e98c"

URI_aarch64_gscan2pdf = "${EPEL_MIRROR}/aarch64/Packages/g/gscan2pdf-2.13.5-1.el10_2.noarch.rpm;name=aarch64_gscan2pdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_gscan2pdf}"
SRC_URI[aarch64_gscan2pdf.sha256sum] = "acacf1b5c6554419c307fe8212f6dc66049d3ee508d0910a189fe20de47cb2e7"

URI_aarch64_gscan2pdf-tests = "${EPEL_MIRROR}/aarch64/Packages/g/gscan2pdf-tests-2.13.5-1.el10_2.noarch.rpm;name=aarch64_gscan2pdf-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_gscan2pdf-tests}"
SRC_URI[aarch64_gscan2pdf-tests.sha256sum] = "c98a733c2b84639699319bdcdd8ba5e8691a2acba399eec22bbc93eccd05e75b"

RDEPENDS:gscan2pdf = " \
 ImageMagick \
 ImageMagick-perl \
 bash \
 gscan2pdf \
 libtiff-tools \
 perl-Archive-Tar \
 perl-Carp \
 perl-Config-General \
 perl-Data-Dumper \
 perl-Data-UUID \
 perl-Date-Calc \
 perl-Encode \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Filesys-Df \
 perl-Getopt-Long \
 perl-Glib \
 perl-Glib-Object-Introspection \
 perl-GooCanvas2 \
 perl-Gtk3 \
 perl-Gtk3-ImageView \
 perl-Gtk3-SimpleList \
 perl-HTML-Parser \
 perl-IO \
 perl-IPC-Cmd \
 perl-IPC-Open3 \
 perl-Image-Sane \
 perl-JSON-PP \
 perl-List-MoreUtils \
 perl-Locale-Codes \
 perl-Locale-gettext \
 perl-Log-Log4perl \
 perl-PDF-Builder \
 perl-POSIX \
 perl-PathTools \
 perl-Proc-ProcessTable \
 perl-Readonly \
 perl-Set-IntSpan \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Text-ParseWords \
 perl-Thread-Queue \
 perl-Time-Piece \
 perl-Try-Tiny \
 perl-base \
 perl-if \
 perl-interpreter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 perl-version \
 sane-backends \
 sane-frontends \
 "
RDEPENDS:gscan2pdf-tests = " \
 ImageMagick-djvu \
 bash \
 dejavu-sans-fonts \
 file \
 fontconfig \
 ghostscript \
 gscan2pdf \
 mutter \
 perl-Carp \
 perl-Data-Dumper \
 perl-Date-Calc \
 perl-Encode \
 perl-Exception-Class \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-File-stat \
 perl-Glib \
 perl-Gtk3 \
 perl-IPC-Cmd \
 perl-IPC-System-Simple \
 perl-Image-Sane \
 perl-Log-Log4perl \
 perl-MIME-Base64 \
 perl-PDF-Builder \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Sub-Override \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-interpreter \
 perl-libs \
 perl-version \
 poppler-utils \
 sane-backends-drivers-scanners \
 sane-frontends \
 virtual/coreutils \
 xwayland-run \
 "
