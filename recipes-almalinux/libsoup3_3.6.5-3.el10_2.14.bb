# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsoup3"
PV = "3.6.5"
PR = "3.el10_2.14"
PACKAGES = " \
 libsoup3 \
 libsoup3-devel \
 libsoup3-doc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libsoup3-3.6.5-3.el10_2.14.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e89e3417427f7fa18d165473573fc1ee623d803d16bc007a6d746f50f3366ee5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsoup3-3.6.5-3.el10_2.14.x86_64_v2.rpm;name=x86_64_v2_libsoup3;unpack=0"
SRC_URI[x86_64_v2_libsoup3.sha256sum] = "521735ddbd5d01b0730b728d8b4ea920da280a7c37dc43e424e77acc2ab9a79c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsoup3-devel-3.6.5-3.el10_2.14.x86_64_v2.rpm;name=x86_64_v2_libsoup3-devel;unpack=0"
SRC_URI[x86_64_v2_libsoup3-devel.sha256sum] = "e6e02037fb4284d54531a539bedf6f07494b63481e6f17dedc6f197679093d09"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsoup3-doc-3.6.5-3.el10_2.14.noarch.rpm;name=x86_64_v2_libsoup3-doc;unpack=0"
SRC_URI[x86_64_v2_libsoup3-doc.sha256sum] = "6bf3be055b11065a25d7112069d761fb27c69f94e9c38e76b683116273bd2f16"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsoup3-3.6.5-3.el10_2.14.aarch64.rpm;name=aarch64_libsoup3;unpack=0"
SRC_URI[aarch64_libsoup3.sha256sum] = "3213a067c7a317dc7cfbe812b5ee7fd6aba075c42b0d650de04f4c6ba240df6b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsoup3-devel-3.6.5-3.el10_2.14.aarch64.rpm;name=aarch64_libsoup3-devel;unpack=0"
SRC_URI[aarch64_libsoup3-devel.sha256sum] = "9e197aac5df885fbeb12d07f6c2fcc6ae84cf189e41b8b3994cc707ecaa68e59"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsoup3-doc-3.6.5-3.el10_2.14.noarch.rpm;name=aarch64_libsoup3-doc;unpack=0"
SRC_URI[aarch64_libsoup3-doc.sha256sum] = "6bf3be055b11065a25d7112069d761fb27c69f94e9c38e76b683116273bd2f16"

RDEPENDS:libsoup3 = " \
 glib2 \
 glibc \
 krb5-libs \
 libbrotli \
 libnghttp2 \
 libpsl \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:libsoup3-devel = " \
 brotli-devel \
 glib2-devel \
 krb5-devel \
 libnghttp2-devel \
 libpsl-devel \
 libsoup3 \
 pkgconf-pkg-config \
 sqlite-devel \
 sysprof-capture-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:libsoup3-doc = " \
 "
