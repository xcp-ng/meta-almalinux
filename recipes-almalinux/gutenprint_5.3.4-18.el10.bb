# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gutenprint"
PV = "5.3.4"
PR = "18.el10"
PACKAGES = " \
 gutenprint \
 gutenprint-cups \
 gutenprint-doc \
 gutenprint-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gutenprint-5.3.4-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "342cf675e5e656bdb6cdbf30e33353927dcc00b4e3046152c4cd44365e6fe0dd"

URI_x86_64_v2_gutenprint = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gutenprint-5.3.4-18.el10.x86_64_v2.rpm;name=x86_64_v2_gutenprint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gutenprint}"
SRC_URI[x86_64_v2_gutenprint.sha256sum] = "2131b34e20fc98a16298e4d0619d0d962ad5b071612fcc5cbc05b79f98da2c29"

URI_x86_64_v2_gutenprint-cups = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gutenprint-cups-5.3.4-18.el10.x86_64_v2.rpm;name=x86_64_v2_gutenprint-cups;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gutenprint-cups}"
SRC_URI[x86_64_v2_gutenprint-cups.sha256sum] = "7b353e0cf79f6e617f28aa8115f24f9feba44663e7f15123720aa8ef1d470842"

URI_x86_64_v2_gutenprint-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gutenprint-doc-5.3.4-18.el10.x86_64_v2.rpm;name=x86_64_v2_gutenprint-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gutenprint-doc}"
SRC_URI[x86_64_v2_gutenprint-doc.sha256sum] = "08168c2a40120322fc4828f677820cc388de8445a2d034c540e5cd02267f3505"

URI_x86_64_v2_gutenprint-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gutenprint-libs-5.3.4-18.el10.x86_64_v2.rpm;name=x86_64_v2_gutenprint-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gutenprint-libs}"
SRC_URI[x86_64_v2_gutenprint-libs.sha256sum] = "40426940ac76491d396b4e10f8f8695805cc9032518125de6add1ba87e2a2752"

URI_aarch64_gutenprint = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gutenprint-5.3.4-18.el10.aarch64.rpm;name=aarch64_gutenprint;unpack=0"
SRC_URI:append = " ${URI_aarch64_gutenprint}"
SRC_URI[aarch64_gutenprint.sha256sum] = "204a03392309443628372d562637a1b1b27836ffeb4c8a3e98199b70930d89c0"

URI_aarch64_gutenprint-cups = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gutenprint-cups-5.3.4-18.el10.aarch64.rpm;name=aarch64_gutenprint-cups;unpack=0"
SRC_URI:append = " ${URI_aarch64_gutenprint-cups}"
SRC_URI[aarch64_gutenprint-cups.sha256sum] = "857ed9432e8bb5eee3c44945b301707599ff0e45220a64d5a3185487af85a994"

URI_aarch64_gutenprint-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gutenprint-doc-5.3.4-18.el10.aarch64.rpm;name=aarch64_gutenprint-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gutenprint-doc}"
SRC_URI[aarch64_gutenprint-doc.sha256sum] = "e9d41023d57bdf72c4687e8fb1fe14bffc6b91acfe72c5c96c5ea29c4d1d1902"

URI_aarch64_gutenprint-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gutenprint-libs-5.3.4-18.el10.aarch64.rpm;name=aarch64_gutenprint-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gutenprint-libs}"
SRC_URI[aarch64_gutenprint-libs.sha256sum] = "78dadf29056a9fa804191a62b5a7f2b0cbdb090172443acaef7a864deefaa335"

RDEPENDS:gutenprint = " \
 cups-client \
 glibc \
 gutenprint-libs \
 "
RDEPENDS:gutenprint-cups = " \
 bash \
 cups \
 cups-libs \
 glibc \
 gutenprint \
 gutenprint-libs \
 libusb1 \
 python3 \
 python3-charset-normalizer \
 zlib-ng-compat \
 "
RDEPENDS:gutenprint-doc = " \
 "
RDEPENDS:gutenprint-libs = " \
 glibc \
 "
