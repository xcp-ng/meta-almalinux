# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro-hack"
PV = "0.5.20"
PR = "4.el10_0"
PACKAGES = " \
 rust-proc-macro-hack+default-devel \
 rust-proc-macro-hack-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro-hack-0.5.20-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0108680471a0220116007e22eee5b1452dd2c054876b5b8232c3891c15a0f886"

URI_x86_64_v2_rust-proc-macro-hack+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-hack+default-devel-0.5.20-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-hack+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-hack+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-hack+default-devel.sha256sum] = "85acf81d112b8fd6e7b9eafc5d369a5addad8826047918683b13dc0d8b21c2ea"

URI_x86_64_v2_rust-proc-macro-hack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-hack-devel-0.5.20-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-hack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-hack-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-hack-devel.sha256sum] = "16822016c7193a74f5556473afe02b8fca9c55772855df013809326fed8cd13e"

URI_aarch64_rust-proc-macro-hack+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-hack+default-devel-0.5.20-4.el10_0.noarch.rpm;name=aarch64_rust-proc-macro-hack+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-hack+default-devel}"
SRC_URI[aarch64_rust-proc-macro-hack+default-devel.sha256sum] = "a21c950bf52299268dfb73ddd740adc1d8551966a41f3cf7b6a7befb19b5293b"

URI_aarch64_rust-proc-macro-hack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-hack-devel-0.5.20-4.el10_0.noarch.rpm;name=aarch64_rust-proc-macro-hack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-hack-devel}"
SRC_URI[aarch64_rust-proc-macro-hack-devel.sha256sum] = "e156fd729ea266584b423ee3d9932ec1f4bafbe21e738b8a210cd15a8301458e"

RDEPENDS:rust-proc-macro-hack+default-devel = " \
 cargo \
 rust-proc-macro-hack-devel \
 "
RDEPENDS:rust-proc-macro-hack-devel = " \
 cargo \
 rust \
 "
