# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inout"
PV = "0.1.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-inout+block-padding-devel \
 rust-inout+default-devel \
 rust-inout+std-devel \
 rust-inout-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inout-0.1.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "256c17cbc0d1c5db49906f5b07f54afb9ae61522b95ae49f96a4c57702bc5ddb"

URI_x86_64_v2_rust-inout+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout+block-padding-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout+block-padding-devel}"
SRC_URI[x86_64_v2_rust-inout+block-padding-devel.sha256sum] = "b6830e2a3751c2e6f40c1c4834e91f2da9adc0c19ed2409279e957aeeca9032b"

URI_x86_64_v2_rust-inout+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout+default-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout+default-devel}"
SRC_URI[x86_64_v2_rust-inout+default-devel.sha256sum] = "8c11425a1bebede9ef520630a92b2e7d6ce0cf4eebec912d116eef4c75b05607"

URI_x86_64_v2_rust-inout+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout+std-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout+std-devel}"
SRC_URI[x86_64_v2_rust-inout+std-devel.sha256sum] = "4b5037e8d2dc5c2e5e687f414d8d2a7795754e5696aaf82d67cb61957e8ac958"

URI_x86_64_v2_rust-inout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout-devel}"
SRC_URI[x86_64_v2_rust-inout-devel.sha256sum] = "99ba14c49fdddb057f26543d81ea8f1d739845b047a3b2c11a296f363a011fa9"

URI_aarch64_rust-inout+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout+block-padding-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-inout+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout+block-padding-devel}"
SRC_URI[aarch64_rust-inout+block-padding-devel.sha256sum] = "cf5eae56a582f7930f590ef5ee7e0d621d60a93921b037ac1a6bd007644456bb"

URI_aarch64_rust-inout+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout+default-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-inout+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout+default-devel}"
SRC_URI[aarch64_rust-inout+default-devel.sha256sum] = "94a18e1d106229b5b04aeb9ea91f9f51ad58d05de1fb7802bb0822f23d61cfbe"

URI_aarch64_rust-inout+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout+std-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-inout+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout+std-devel}"
SRC_URI[aarch64_rust-inout+std-devel.sha256sum] = "54af81cb906206a494018308098965b7e22274d041a3a5e1366804eea9ff4e20"

URI_aarch64_rust-inout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-inout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout-devel}"
SRC_URI[aarch64_rust-inout-devel.sha256sum] = "607a6f4cd989ac9d0de1411abf2bbb01cc84926e5cf68c92eca2961a202bd244"

RDEPENDS:rust-inout+block-padding-devel = " \
 cargo \
 rust-block-padding+default-devel \
 rust-inout-devel \
 "
RDEPENDS:rust-inout+default-devel = " \
 cargo \
 rust-inout-devel \
 "
RDEPENDS:rust-inout+std-devel = " \
 cargo \
 rust-block-padding+default-devel \
 rust-block-padding+std-devel \
 rust-inout-devel \
 "
RDEPENDS:rust-inout-devel = " \
 cargo \
 rust \
 rust-generic-array+default-devel \
 "
