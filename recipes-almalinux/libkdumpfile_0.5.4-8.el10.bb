# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdumpfile"
PV = "0.5.4"
PR = "8.el10"
PACKAGES = " \
 libkdumpfile \
 libkdumpfile-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libkdumpfile-0.5.4-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e05c96e08192317511c9260f23b6d17ae405e832d6e338c8bb001610573f8b5"

URI_x86_64_v2_libkdumpfile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libkdumpfile-0.5.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_libkdumpfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdumpfile}"
SRC_URI[x86_64_v2_libkdumpfile.sha256sum] = "ed5408056fcfc23aafe83067ed86b461479517b6ef567ae30d8d06fbf77b0223"

URI_x86_64_v2_libkdumpfile-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libkdumpfile-devel-0.5.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_libkdumpfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdumpfile-devel}"
SRC_URI[x86_64_v2_libkdumpfile-devel.sha256sum] = "c7f06adb3acc941b01fa02f6abb145aee26944d608dcd9524690f08dd99831dc"

URI_aarch64_libkdumpfile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libkdumpfile-0.5.4-8.el10.aarch64.rpm;name=aarch64_libkdumpfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdumpfile}"
SRC_URI[aarch64_libkdumpfile.sha256sum] = "173819b8eceeab356964e1ca86773feec477da97aec3a7523b09b05cec7ae147"

URI_aarch64_libkdumpfile-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libkdumpfile-devel-0.5.4-8.el10.aarch64.rpm;name=aarch64_libkdumpfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdumpfile-devel}"
SRC_URI[aarch64_libkdumpfile-devel.sha256sum] = "369f3089eef105202fc69cdfe3b3a46c3906ad14c48f426d706a93c3cd9ec65b"

RDEPENDS:libkdumpfile = " \
 glibc \
 libzstd \
 lzo \
 snappy \
 zlib-ng-compat \
 "
RDEPENDS:libkdumpfile-devel = " \
 libkdumpfile \
 libkdumpfile-devel \
 libzstd-devel \
 lzo-devel \
 pkgconf-pkg-config \
 snappy-devel \
 zlib-ng-compat-devel \
 "
