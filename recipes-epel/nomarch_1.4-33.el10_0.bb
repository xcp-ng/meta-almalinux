# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nomarch"
PV = "1.4"
PR = "33.el10_0"
PACKAGES = " \
 nomarch \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nomarch-1.4-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "af6c41b803b5418c772154462a5b9fdc994f440c2b335a3a1e274b45c09220b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nomarch-1.4-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nomarch;unpack=0"
SRC_URI[x86_64_v2_nomarch.sha256sum] = "6d2e84f1ca4a68e4197bfbbf71cf6552d062f86b3a73951e81ec9e66b9d2dcee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nomarch-1.4-33.el10_0.aarch64.rpm;name=aarch64_nomarch;unpack=0"
SRC_URI[aarch64_nomarch.sha256sum] = "fbfaddaa741451ee5c079a22f1a33015a1a2de4108d4dbf0efc348685e5e5b92"

RDEPENDS:nomarch = " \
 glibc \
 "
