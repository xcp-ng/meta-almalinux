# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-itoap"
PV = "1.0.1"
PR = "7.el10_1"
PACKAGES = " \
 rust-itoap+alloc-devel \
 rust-itoap+default-devel \
 rust-itoap+simd-devel \
 rust-itoap+std-devel \
 rust-itoap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-itoap-1.0.1-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18ef1674eb327b630f89e6bd6a94f99e0a39f1266e889d6e5a2ffb5579e917fb"

URI_x86_64_v2_rust-itoap+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoap+alloc-devel-1.0.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoap+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoap+alloc-devel}"
SRC_URI[x86_64_v2_rust-itoap+alloc-devel.sha256sum] = "b47659faafdd52bd50c3748d14aaa24c8414c6c1033c08fcc12db0ae834e190b"

URI_x86_64_v2_rust-itoap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoap+default-devel-1.0.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoap+default-devel}"
SRC_URI[x86_64_v2_rust-itoap+default-devel.sha256sum] = "f744936840d65706b246a2e8eb1b7641caf923807b7dfb2ce933db68356b3852"

URI_x86_64_v2_rust-itoap+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoap+simd-devel-1.0.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoap+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoap+simd-devel}"
SRC_URI[x86_64_v2_rust-itoap+simd-devel.sha256sum] = "5a930bdecf3983400e19dcf8fdec5aded6fb457bb40d2e95228ceb57648dfb6d"

URI_x86_64_v2_rust-itoap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoap+std-devel-1.0.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoap+std-devel}"
SRC_URI[x86_64_v2_rust-itoap+std-devel.sha256sum] = "1ad11fa5cca2dd92d3195a3f353aa8bdcaf098999c219489eefea8370e81f406"

URI_x86_64_v2_rust-itoap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoap-devel-1.0.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoap-devel}"
SRC_URI[x86_64_v2_rust-itoap-devel.sha256sum] = "2d15406729288eb5e1095bab4118917effd96105167706bbe18b253c5a37d124"

URI_aarch64_rust-itoap+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoap+alloc-devel-1.0.1-7.el10_1.noarch.rpm;name=aarch64_rust-itoap+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoap+alloc-devel}"
SRC_URI[aarch64_rust-itoap+alloc-devel.sha256sum] = "e5aec70948e62ad010a89d51df2ac047ca4898901460072c3304b880cfb74818"

URI_aarch64_rust-itoap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoap+default-devel-1.0.1-7.el10_1.noarch.rpm;name=aarch64_rust-itoap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoap+default-devel}"
SRC_URI[aarch64_rust-itoap+default-devel.sha256sum] = "e968a146fb382a915312911d9b2907995412fdf175b3c4cd388b21b6f1f28100"

URI_aarch64_rust-itoap+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoap+simd-devel-1.0.1-7.el10_1.noarch.rpm;name=aarch64_rust-itoap+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoap+simd-devel}"
SRC_URI[aarch64_rust-itoap+simd-devel.sha256sum] = "733aae1396c9a2a6ab726e4a16711d19473ce864ad74ba7d73cada9526db1af5"

URI_aarch64_rust-itoap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoap+std-devel-1.0.1-7.el10_1.noarch.rpm;name=aarch64_rust-itoap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoap+std-devel}"
SRC_URI[aarch64_rust-itoap+std-devel.sha256sum] = "962b6a5ca58e66d2e447bf42ee407b33e2d49507b0b7a8c4b6e0d857a54cab8f"

URI_aarch64_rust-itoap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoap-devel-1.0.1-7.el10_1.noarch.rpm;name=aarch64_rust-itoap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoap-devel}"
SRC_URI[aarch64_rust-itoap-devel.sha256sum] = "6d930807d84ef0be2449c05d90e593d6d06a674d7b6d142974caf6405e6c278f"

RDEPENDS:rust-itoap+alloc-devel = " \
 cargo \
 rust-itoap-devel \
 "
RDEPENDS:rust-itoap+default-devel = " \
 cargo \
 rust-itoap+simd-devel \
 rust-itoap+std-devel \
 rust-itoap-devel \
 "
RDEPENDS:rust-itoap+simd-devel = " \
 cargo \
 rust-itoap-devel \
 "
RDEPENDS:rust-itoap+std-devel = " \
 cargo \
 rust-itoap+alloc-devel \
 rust-itoap-devel \
 "
RDEPENDS:rust-itoap-devel = " \
 cargo \
 "
