# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kio"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kio \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kio-devel \
 kf6-kio-doc \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-html \
 kf6-kio-qch-doc \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kio-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f4176e0fae6ee9f51063d31e959ea2c1051151a5df0de13129647fa25c297b47"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio;unpack=0"
SRC_URI[x86_64_v2_kf6-kio.sha256sum] = "8ad105bff431539982b05ae4b7ee7d028410f2944c6be1fcc3d02c326e92b00f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-core-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-core;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-core.sha256sum] = "9ce93cbd963a3f95ab777331d8769fd2cfc80cb55ced49f9db38b7cfeda04615"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-core-libs-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-core-libs;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-core-libs.sha256sum] = "42aeddb079e1c059e4f22977863faf92317aa6d1de634f2c0510f228b7371d11"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-devel.sha256sum] = "5fdb4956d4cff6806baab4c2f2d0ea7d4572fdcdb14a9ff3a172cee1bb78ec51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-doc.sha256sum] = "15f56634c664f1c03ffbc66db3b732d63c0e7830e157a95c69c2db57ccc933e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-file-widgets-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-file-widgets;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-file-widgets.sha256sum] = "49627627ab25a816265339e8b46c2f82eb365404dec405c9b6bcf41df9799344"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-gui-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-gui;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-gui.sha256sum] = "7aacf94d1e7bad87cc1e265cca5ce2f0db1ae5138ebb8b964bc541892f5a76ec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-html.sha256sum] = "835eff5849386ab621a7b7042e3860824d2eb6475d07d1dca14ebd2d84155316"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-qch-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-qch-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-qch-doc.sha256sum] = "14a4c0191822db205ce13636476edf973a317c3706599298a901b8642044f70f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-widgets-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-widgets;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-widgets.sha256sum] = "3045def87a68a6219f038247a9b108aff87afb594f81c8679858bb99ee00b4ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-widgets-libs-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-widgets-libs;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-widgets-libs.sha256sum] = "e04861563f68426427e13b9b979de54270cedd125abb65afa624b6c9a07fce74"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kio;unpack=0"
SRC_URI[aarch64_kf6-kio.sha256sum] = "70729d7e3a44ab5ff63c80b3f6a799a9cf91451307267248ad4887adbdb1fc8a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-core-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kio-core;unpack=0"
SRC_URI[aarch64_kf6-kio-core.sha256sum] = "d216d755f08ad8825d5bb717a8d40c06c8a97124d45aa0d739736feb82eb43cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-core-libs-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kio-core-libs;unpack=0"
SRC_URI[aarch64_kf6-kio-core-libs.sha256sum] = "114e3a08ec9c953a4a0d33ca22b56fa897ee87fb82bfc3b29e006667e7450359"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kio-devel;unpack=0"
SRC_URI[aarch64_kf6-kio-devel.sha256sum] = "5423afbeca3556b8b506fcc3ed14fe87a8328c7178e9d8b23799c4774784d7b8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kio-doc;unpack=0"
SRC_URI[aarch64_kf6-kio-doc.sha256sum] = "cecfa5e47f5533698bd85f8e9d379e227e20b6e2c0d6ae87bc339c61f2b00c2e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-file-widgets-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kio-file-widgets;unpack=0"
SRC_URI[aarch64_kf6-kio-file-widgets.sha256sum] = "4dd7e9eee944f0c085fa0c34e525d06e81c75043d0dd5c932d831744f02249ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-gui-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kio-gui;unpack=0"
SRC_URI[aarch64_kf6-kio-gui.sha256sum] = "0ef328d0e1ad884d9d252027efab66820cb9ea40fc381abf7e05febab75919df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kio-html;unpack=0"
SRC_URI[aarch64_kf6-kio-html.sha256sum] = "88ac60500464b17d146d10a11943a368ea54eef5021ca2ee4760272391b3edb9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-qch-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kio-qch-doc;unpack=0"
SRC_URI[aarch64_kf6-kio-qch-doc.sha256sum] = "2a7ed44cc7b559620ccebe277d1cfc6089fd65893605a0ac26b14ee124fe0898"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-widgets-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kio-widgets;unpack=0"
SRC_URI[aarch64_kf6-kio-widgets.sha256sum] = "deff6e64a35e3923382bf74a01c683848822d23ac3a9310256b310268af343c6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-widgets-libs-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kio-widgets-libs;unpack=0"
SRC_URI[aarch64_kf6-kio-widgets-libs.sha256sum] = "57b8f53ef10731bd17bf3f4186950c15c505d60b44d13d91f006c510db501b0a"

RDEPENDS:kf6-kio = " \
 kf6-kded \
 kf6-kio-core \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets \
 "
RDEPENDS:kf6-kio-core = " \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdoctools \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-doc \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-solid \
 libacl \
 libstdc++ \
 libxml2 \
 libxslt \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-core-libs = " \
 glibc \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kservice \
 libacl \
 libmount \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kio-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kbookmarks-devel \
 kf6-kcompletion-devel \
 kf6-kconfig-devel \
 kf6-kcoreaddons-devel \
 kf6-kio \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 kf6-kitemviews-devel \
 kf6-kjobwidgets-devel \
 kf6-kservice-devel \
 kf6-kwindowsystem-devel \
 kf6-kxmlgui-devel \
 kf6-solid-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-doc = " \
 kf6-kio-core \
 "
RDEPENDS:kf6-kio-file-widgets = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-gui = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-html = " \
 "
RDEPENDS:kf6-kio-qch-doc = " \
 "
RDEPENDS:kf6-kio-widgets = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kio-widgets-libs = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
