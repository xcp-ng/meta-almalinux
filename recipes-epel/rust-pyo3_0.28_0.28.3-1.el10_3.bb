# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3_0.28"
PV = "0.28.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-pyo3_0.28+abi3-devel \
 rust-pyo3_0.28+abi3-py310-devel \
 rust-pyo3_0.28+abi3-py311-devel \
 rust-pyo3_0.28+abi3-py312-devel \
 rust-pyo3_0.28+abi3-py313-devel \
 rust-pyo3_0.28+abi3-py314-devel \
 rust-pyo3_0.28+abi3-py37-devel \
 rust-pyo3_0.28+abi3-py38-devel \
 rust-pyo3_0.28+abi3-py39-devel \
 rust-pyo3_0.28+anyhow-devel \
 rust-pyo3_0.28+arc_lock-devel \
 rust-pyo3_0.28+auto-initialize-devel \
 rust-pyo3_0.28+bigdecimal-devel \
 rust-pyo3_0.28+bytes-devel \
 rust-pyo3_0.28+chrono-devel \
 rust-pyo3_0.28+chrono-local-devel \
 rust-pyo3_0.28+chrono-tz-devel \
 rust-pyo3_0.28+default-devel \
 rust-pyo3_0.28+either-devel \
 rust-pyo3_0.28+experimental-async-devel \
 rust-pyo3_0.28+experimental-inspect-devel \
 rust-pyo3_0.28+extension-module-devel \
 rust-pyo3_0.28+eyre-devel \
 rust-pyo3_0.28+full-devel \
 rust-pyo3_0.28+hashbrown-devel \
 rust-pyo3_0.28+indexmap-devel \
 rust-pyo3_0.28+inventory-devel \
 rust-pyo3_0.28+jiff-02-devel \
 rust-pyo3_0.28+lock_api-devel \
 rust-pyo3_0.28+macros-devel \
 rust-pyo3_0.28+multiple-pymethods-devel \
 rust-pyo3_0.28+nightly-devel \
 rust-pyo3_0.28+num-bigint-devel \
 rust-pyo3_0.28+num-complex-devel \
 rust-pyo3_0.28+num-rational-devel \
 rust-pyo3_0.28+ordered-float-devel \
 rust-pyo3_0.28+parking_lot-devel \
 rust-pyo3_0.28+py-clone-devel \
 rust-pyo3_0.28+pyo3-macros-devel \
 rust-pyo3_0.28+rust_decimal-devel \
 rust-pyo3_0.28+serde-devel \
 rust-pyo3_0.28+smallvec-devel \
 rust-pyo3_0.28+time-devel \
 rust-pyo3_0.28+uuid-devel \
 rust-pyo3_0.28-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3_0.28-0.28.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b3dbe5895978a7d5c1c07a5e2af4e7642b536313d34e2a93616b9265676506f"

URI_x86_64_v2_rust-pyo3_0.28+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+abi3-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+abi3-devel.sha256sum] = "5f7191ad9f5fe0211efcc380041e10295ddffd97c18e1c73f809aa90d7c63584"

URI_x86_64_v2_rust-pyo3_0.28+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+abi3-py310-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+abi3-py310-devel.sha256sum] = "2020ce43d49dbeef267cca3e72892ce6e5bc0384681f9bff71b63ce3fab1cccd"

URI_x86_64_v2_rust-pyo3_0.28+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+abi3-py311-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+abi3-py311-devel.sha256sum] = "c93d5b4ef2fb975da99862b53e0a43dd4d5b40ee519c276b9ce9319c85ba30ab"

URI_x86_64_v2_rust-pyo3_0.28+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+abi3-py312-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+abi3-py312-devel.sha256sum] = "182ad8a7f2e779de4e757267abb31cc5799464db3b7f4f45c154f8f64d7824dd"

URI_x86_64_v2_rust-pyo3_0.28+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+abi3-py313-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+abi3-py313-devel.sha256sum] = "a8ad55dd228c004afe5887e9dd07a65f125a18088f8e732fe4929ad1cafb3607"

URI_x86_64_v2_rust-pyo3_0.28+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+abi3-py314-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+abi3-py314-devel.sha256sum] = "c5ca862a38ec6b325f515169c2e744ddb6af6fc5881fc59196bab0f8857165a3"

URI_x86_64_v2_rust-pyo3_0.28+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+abi3-py37-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+abi3-py37-devel.sha256sum] = "b14c9272be2c5fab02b624628e5e769ae6fe63175277307a32238a3c5bab5c3e"

URI_x86_64_v2_rust-pyo3_0.28+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+abi3-py38-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+abi3-py38-devel.sha256sum] = "f820fa71939d9e0f04075c3a92ed8c3e8d7323d28ba07d40bce082e886687db6"

URI_x86_64_v2_rust-pyo3_0.28+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+abi3-py39-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+abi3-py39-devel.sha256sum] = "346b536bd6bd56635ecccf051621700920d91ffaed11adc9c4394b256a97bb45"

URI_x86_64_v2_rust-pyo3_0.28+anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+anyhow-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+anyhow-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+anyhow-devel.sha256sum] = "a07e193ec73d5821be83d5cadc50895708395d45c7e34d3bedcfed42de019df4"

URI_x86_64_v2_rust-pyo3_0.28+arc_lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+arc_lock-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+arc_lock-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+arc_lock-devel.sha256sum] = "1646841ef153620b4a6f43a06660b2881cc07aad691a19451e15292f5d6d5b3a"

URI_x86_64_v2_rust-pyo3_0.28+auto-initialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+auto-initialize-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+auto-initialize-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+auto-initialize-devel.sha256sum] = "a1b9c3a62b298a9182bb01455cd3024c7e84e98bce65283ee04039e024e1f7ce"

URI_x86_64_v2_rust-pyo3_0.28+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+bigdecimal-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+bigdecimal-devel.sha256sum] = "c9e1de2b55157c6d02ec5b8546729eb8d4777c29cf77009114777b031d0a99f7"

URI_x86_64_v2_rust-pyo3_0.28+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+bytes-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+bytes-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+bytes-devel.sha256sum] = "6b2ecce9167eeefdf23f2e1efe9a34a173e4e17d29d9cbd9c9e802517d5eb2cc"

URI_x86_64_v2_rust-pyo3_0.28+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+chrono-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+chrono-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+chrono-devel.sha256sum] = "1c4105f449e61d52ab34cec7667de3dbcc29e7280bd359c47af8f29ec13e492c"

URI_x86_64_v2_rust-pyo3_0.28+chrono-local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+chrono-local-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+chrono-local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+chrono-local-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+chrono-local-devel.sha256sum] = "7232b1a1d9adf13dfd856546059b97d345bebd2583b2f51b2d3f0fa3f8fc6f61"

URI_x86_64_v2_rust-pyo3_0.28+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+chrono-tz-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+chrono-tz-devel.sha256sum] = "006a588c1146e842160facd2a9c5da7f18a24480f0677fbdf3d7159b2dd16ea1"

URI_x86_64_v2_rust-pyo3_0.28+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+default-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+default-devel.sha256sum] = "cead32240c4f03ccf456b9bb6cf6be84328e9ff37b413b7e71bdc0d555118e3b"

URI_x86_64_v2_rust-pyo3_0.28+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+either-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+either-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+either-devel.sha256sum] = "f15ee3de190bc587dac848ef5e44ecbcbf6fe75d4ed86ec44e2dea9f23b59c02"

URI_x86_64_v2_rust-pyo3_0.28+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+experimental-async-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+experimental-async-devel.sha256sum] = "ecadd6e7f1cc7a246ce040a6f7511cfa6219c6934c38fae5dc3d015fe93b2ef8"

URI_x86_64_v2_rust-pyo3_0.28+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+experimental-inspect-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+experimental-inspect-devel.sha256sum] = "2ec4654c6694409ebcc1e48fd789d4b89c7af77db52c4ac9dfbf242822ae1b93"

URI_x86_64_v2_rust-pyo3_0.28+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+extension-module-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+extension-module-devel.sha256sum] = "ddecee5ad5424165fd63c6a830361ed50ab11709cd412ba9d98c48fa46725817"

URI_x86_64_v2_rust-pyo3_0.28+eyre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+eyre-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+eyre-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+eyre-devel.sha256sum] = "0072a25e6df662ecd76c2135d5841bdaae5e8bd6d8e65eba47ddb879bb1ad2d1"

URI_x86_64_v2_rust-pyo3_0.28+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+full-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+full-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+full-devel.sha256sum] = "00b79d4177e56f7ef02b4526b4f3f4fbd66917dcd76a459cbd9b74e2dfee0518"

URI_x86_64_v2_rust-pyo3_0.28+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+hashbrown-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+hashbrown-devel.sha256sum] = "2b4c09dd63c4866424b77f389905cca9b4a70bd95637b33384cb276e0a16d635"

URI_x86_64_v2_rust-pyo3_0.28+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+indexmap-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+indexmap-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+indexmap-devel.sha256sum] = "ec811d51edf8b2773a08934f7d6c05e9bd443b21f0aaa476e259994e9ba4282f"

URI_x86_64_v2_rust-pyo3_0.28+inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+inventory-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+inventory-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+inventory-devel.sha256sum] = "5bcd23a045d9ac96b5c983c9d41a69eddbc31ef1ab692f2eb2382a046c91c798"

URI_x86_64_v2_rust-pyo3_0.28+jiff-02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+jiff-02-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+jiff-02-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+jiff-02-devel.sha256sum] = "2ea2d4e61366db0bb07cd47b6c24e18787638ec8b3ffd9c9155da08cfba154e5"

URI_x86_64_v2_rust-pyo3_0.28+lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+lock_api-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+lock_api-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+lock_api-devel.sha256sum] = "6363963370dc83369ce51ee6a4cef3e0cc228c300d665af54ac87ae40d5c7e02"

URI_x86_64_v2_rust-pyo3_0.28+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+macros-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+macros-devel.sha256sum] = "390b2e0c96dabd74f13c29d5258019fb9293e6abda3ae0d93d92e740c716c233"

URI_x86_64_v2_rust-pyo3_0.28+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+multiple-pymethods-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+multiple-pymethods-devel.sha256sum] = "30c77e30ac6879ee9620be1d2cc4840c3b6a77a848c59fb3dddf17da87be23e2"

URI_x86_64_v2_rust-pyo3_0.28+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+nightly-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+nightly-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+nightly-devel.sha256sum] = "b88df87c0d48406042a8400721f793939bfef4c2696cea20733cfceb7e67910d"

URI_x86_64_v2_rust-pyo3_0.28+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+num-bigint-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+num-bigint-devel.sha256sum] = "fd2a747f9c3d24917191a76929be977d46741a51ec15dd3d7cbbb753534aabbc"

URI_x86_64_v2_rust-pyo3_0.28+num-complex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+num-complex-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+num-complex-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+num-complex-devel.sha256sum] = "163b7696f71d9d6926dcd6c7039c4f5a38fbbafdee0ea04fa8f3da1b76cb32d2"

URI_x86_64_v2_rust-pyo3_0.28+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+num-rational-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+num-rational-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+num-rational-devel.sha256sum] = "2dfbd1b1106bc305b5dd2873a05131c6abb8499c98fe19a5ac16b9c0bfb65de5"

URI_x86_64_v2_rust-pyo3_0.28+ordered-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+ordered-float-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+ordered-float-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+ordered-float-devel.sha256sum] = "025bc2807c729fed0e11f63235780f7fff0a7ee4ab634cd4e53f2880a180a297"

URI_x86_64_v2_rust-pyo3_0.28+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+parking_lot-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+parking_lot-devel.sha256sum] = "0a8a14871069d798508427d6e17a28051e42f2d831e3422edd82cbd97a12f529"

URI_x86_64_v2_rust-pyo3_0.28+py-clone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+py-clone-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+py-clone-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+py-clone-devel.sha256sum] = "297c54a5cd36c386a1e3e9832a0ad18f0cfa6bcb187230e4c609d9073189a937"

URI_x86_64_v2_rust-pyo3_0.28+pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+pyo3-macros-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+pyo3-macros-devel.sha256sum] = "5f12b2fed943b3210747ace75faf2ec4b18e4c98cb6f6dfb9bac0f4861b252a4"

URI_x86_64_v2_rust-pyo3_0.28+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+rust_decimal-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+rust_decimal-devel.sha256sum] = "111f0a05c3fba66a9dae1aca3d1c62df661a6b72a22cf31e2d5d17e9fd4cb0b2"

URI_x86_64_v2_rust-pyo3_0.28+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+serde-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+serde-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+serde-devel.sha256sum] = "b4b687ed0388fad490ece0736fa0591772815dbb83cce65176122a640ae020d2"

URI_x86_64_v2_rust-pyo3_0.28+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+smallvec-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+smallvec-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+smallvec-devel.sha256sum] = "886a18d5810c19aba9a9a194d407dfcd0c3e9a82219660e1497bcfd529a177c7"

URI_x86_64_v2_rust-pyo3_0.28+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+time-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+time-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+time-devel.sha256sum] = "96fa766639066c64ef3ffdeb99d022cc202c709ad9d3ac856890694ba20ebf24"

URI_x86_64_v2_rust-pyo3_0.28+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28+uuid-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28+uuid-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28+uuid-devel.sha256sum] = "1759e766fc9df621e7e6884054452cf97897e1e160ea20f5c00ac29ec4517cb1"

URI_x86_64_v2_rust-pyo3_0.28-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.28-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.28-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.28-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.28-devel.sha256sum] = "1d69bdeedaf19fcea36c4f1774441eb135d8ed5ddcb66132e16775a0ffe565c4"

URI_aarch64_rust-pyo3_0.28+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+abi3-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+abi3-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+abi3-devel.sha256sum] = "945c68af685a05169fc0c1c461e7ca58a49dc155927dcdf09f03407d7ea01a35"

URI_aarch64_rust-pyo3_0.28+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+abi3-py310-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+abi3-py310-devel.sha256sum] = "1303fcc9323cf0dcb6f04b0f2a5a6e2e9b78915eadb2b54c60bb3d72bcc5e838"

URI_aarch64_rust-pyo3_0.28+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+abi3-py311-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+abi3-py311-devel.sha256sum] = "7c02e1fbe262b215e4e55ecff44b908d67ce74eeef5d39f2c505ae32fd7e3863"

URI_aarch64_rust-pyo3_0.28+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+abi3-py312-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+abi3-py312-devel.sha256sum] = "abac8675963607c3e09ee65f4de7ac70d2f11b6ed07cd8aec81e1125f4e21fb2"

URI_aarch64_rust-pyo3_0.28+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+abi3-py313-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+abi3-py313-devel.sha256sum] = "7663a3b4c68f5bb4b9779d95f6480356e9845710ae5f9e8bb5b4daa2c6481ea7"

URI_aarch64_rust-pyo3_0.28+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+abi3-py314-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+abi3-py314-devel.sha256sum] = "8b14ab25a7432a09fbee844625b6e247a7c07da4f6e5989a6a3e2a08b21dd5b7"

URI_aarch64_rust-pyo3_0.28+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+abi3-py37-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+abi3-py37-devel.sha256sum] = "d07f216e78b0a1295326bf5dd92bf9503f6b76ffbc4ff7b8b45813c99ef33bc1"

URI_aarch64_rust-pyo3_0.28+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+abi3-py38-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+abi3-py38-devel.sha256sum] = "7843017376d132f6d2a78ec37b17272ef44525de150d5e8e01612a4f3bd89c11"

URI_aarch64_rust-pyo3_0.28+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+abi3-py39-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+abi3-py39-devel.sha256sum] = "b570a13c966cbd76b89aa11d49385b4c1d239baf9b91d84a76e54a0235bf998a"

URI_aarch64_rust-pyo3_0.28+anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+anyhow-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+anyhow-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+anyhow-devel.sha256sum] = "cf1c272a7cade36d4ed4ecbb2f4f4e248afd3be0294a8e4051cfd88b72084bc4"

URI_aarch64_rust-pyo3_0.28+arc_lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+arc_lock-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+arc_lock-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+arc_lock-devel.sha256sum] = "fa64c3df82f65d9b9bcf8cd2bf93ad447bab6411c3dc629a7586575bd866b635"

URI_aarch64_rust-pyo3_0.28+auto-initialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+auto-initialize-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+auto-initialize-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+auto-initialize-devel.sha256sum] = "955d1bd5312a679ae6ca4a52c06b6c545fa81309948e6d17d4536e008b79c8ef"

URI_aarch64_rust-pyo3_0.28+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+bigdecimal-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+bigdecimal-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+bigdecimal-devel.sha256sum] = "3fafd9e1d92751bc686b541d645a230b95cae720fc382b042e38623be1d00b91"

URI_aarch64_rust-pyo3_0.28+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+bytes-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+bytes-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+bytes-devel.sha256sum] = "dbe1f029ccfddb8c6a91d9d2245bddfaf6472e2dfeadaa3b53b5f8e761362f08"

URI_aarch64_rust-pyo3_0.28+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+chrono-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+chrono-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+chrono-devel.sha256sum] = "1b80d64f85f509663c8dee8a87a62c874c8d5c36fc17ad55ea140b90c17eb5df"

URI_aarch64_rust-pyo3_0.28+chrono-local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+chrono-local-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+chrono-local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+chrono-local-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+chrono-local-devel.sha256sum] = "62a4f5665988deb76c218668f374e5e2c30459c71ad0bd9fb81677043869710c"

URI_aarch64_rust-pyo3_0.28+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+chrono-tz-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+chrono-tz-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+chrono-tz-devel.sha256sum] = "a55b33eae3a694aba13afe3484d31f0f87be18fb8f1cc8405aa6a78cb2d81dab"

URI_aarch64_rust-pyo3_0.28+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+default-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+default-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+default-devel.sha256sum] = "df96237ce68668fa468b462ab8b4f12f09e41e37983892b66834d36895d5d0a5"

URI_aarch64_rust-pyo3_0.28+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+either-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+either-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+either-devel.sha256sum] = "49a4cac82692ff7a88b5310d33eab282a199cae8fd521007181337d272de1b61"

URI_aarch64_rust-pyo3_0.28+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+experimental-async-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+experimental-async-devel.sha256sum] = "2c74b545a9b162c4a1ee76bf27b7679dd426a96300573ee6d5fd17bd0a149e7f"

URI_aarch64_rust-pyo3_0.28+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+experimental-inspect-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+experimental-inspect-devel.sha256sum] = "a242a1fdd5bac26e1bacbd3640707df4dd287b60affff351e483da3befe6f5ff"

URI_aarch64_rust-pyo3_0.28+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+extension-module-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+extension-module-devel.sha256sum] = "8db9340e287c25c7a0a93c96fb101e252f8ce88fe703c4904a58d3be84e8e8f5"

URI_aarch64_rust-pyo3_0.28+eyre-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+eyre-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+eyre-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+eyre-devel.sha256sum] = "c1031fe694054f5b909ac0531624d8142040be212855fff760d56965b16060cc"

URI_aarch64_rust-pyo3_0.28+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+full-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+full-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+full-devel.sha256sum] = "dd2c39f6e5a21731fd13e4e4490042df304b79c637a268820ec4ef8ca9a2938b"

URI_aarch64_rust-pyo3_0.28+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+hashbrown-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+hashbrown-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+hashbrown-devel.sha256sum] = "753d031f42d9b262876194688dddb19372d6821208ddde5796b2853e522d291a"

URI_aarch64_rust-pyo3_0.28+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+indexmap-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+indexmap-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+indexmap-devel.sha256sum] = "dc82ce2f712ca525ee1f09fb38bbb5700af001a8c3caa73d1ab9633f7d61270e"

URI_aarch64_rust-pyo3_0.28+inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+inventory-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+inventory-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+inventory-devel.sha256sum] = "d0dab67342a6bd9623f9a18c9775acbb7871072096328c8fb600141cf015207e"

URI_aarch64_rust-pyo3_0.28+jiff-02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+jiff-02-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+jiff-02-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+jiff-02-devel.sha256sum] = "12d487ee03741ceceae8076217f218ba7681b38e5485006494fa0be38812a6de"

URI_aarch64_rust-pyo3_0.28+lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+lock_api-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+lock_api-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+lock_api-devel.sha256sum] = "24c5237ada5d3d1277fe6be8c37dbbe5dd540af7993e5c2dcb48149fa72b229f"

URI_aarch64_rust-pyo3_0.28+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+macros-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+macros-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+macros-devel.sha256sum] = "51ede47e4dfbc3f185b87b3415c7ad6cff4ab498e246067ef039c8a10b011108"

URI_aarch64_rust-pyo3_0.28+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+multiple-pymethods-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+multiple-pymethods-devel.sha256sum] = "131de0ca33fc5cfff20764eaec67ae9cff82108de748a1adb55e41da84393616"

URI_aarch64_rust-pyo3_0.28+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+nightly-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+nightly-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+nightly-devel.sha256sum] = "a3bb5b39a685c3afce1c46687bee95dff562e6c6b241c8f9e0b04e226de71c58"

URI_aarch64_rust-pyo3_0.28+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+num-bigint-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+num-bigint-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+num-bigint-devel.sha256sum] = "df825764ffab0e64f969da4b02ba6e576315979178521c4f4d4e8a2840be3f26"

URI_aarch64_rust-pyo3_0.28+num-complex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+num-complex-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+num-complex-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+num-complex-devel.sha256sum] = "a8b7b7efc2687b3256db966170b2bb0f62ebb248b0a1e314d150f2fffedbce82"

URI_aarch64_rust-pyo3_0.28+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+num-rational-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+num-rational-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+num-rational-devel.sha256sum] = "8be55f4516dc6a15940c7d0da54feca9d7ed7931074a11f8bece10aa1b0439e5"

URI_aarch64_rust-pyo3_0.28+ordered-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+ordered-float-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+ordered-float-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+ordered-float-devel.sha256sum] = "6242428aff62c7b9f24f48e5762ef6402e8f74a62753efbc5ac76ace7a4cf783"

URI_aarch64_rust-pyo3_0.28+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+parking_lot-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+parking_lot-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+parking_lot-devel.sha256sum] = "c9e5949baeb35a36b8155b37cd138610a705f313bb22a61756f53ba66f5597c4"

URI_aarch64_rust-pyo3_0.28+py-clone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+py-clone-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+py-clone-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+py-clone-devel.sha256sum] = "da6419ebffa70b87d057d6c58cca062f240176a593fec9e2dbafeb7a3e77fbba"

URI_aarch64_rust-pyo3_0.28+pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+pyo3-macros-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+pyo3-macros-devel.sha256sum] = "593e611ed64bd7b637b70e2ae2e43f160dc2ac0137979b9aed081d11daff773e"

URI_aarch64_rust-pyo3_0.28+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+rust_decimal-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+rust_decimal-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+rust_decimal-devel.sha256sum] = "73457b70582178ef41043a43c42acec4c8bf7ac1d61dd70169b47fccbca7cc09"

URI_aarch64_rust-pyo3_0.28+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+serde-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+serde-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+serde-devel.sha256sum] = "7b29502e2b15100fe1f0aabcb40e874ac2d5ebf9330132e25eefeefb2ca6b303"

URI_aarch64_rust-pyo3_0.28+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+smallvec-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+smallvec-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+smallvec-devel.sha256sum] = "4264dfb72c91d80c9a33e1d69585b3e4e7a60de1f2d265bd274d816f2e473cec"

URI_aarch64_rust-pyo3_0.28+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+time-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+time-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+time-devel.sha256sum] = "6d5212ed48d5612cc16f372a1897d4d4ad6e1738ee692ace1c40c434b2d565ca"

URI_aarch64_rust-pyo3_0.28+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28+uuid-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28+uuid-devel}"
SRC_URI[aarch64_rust-pyo3_0.28+uuid-devel.sha256sum] = "e5d2468a65e61e37cc2a348491f8ad642a74152f80e6361f740175b827977025"

URI_aarch64_rust-pyo3_0.28-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.28-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3_0.28-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.28-devel}"
SRC_URI[aarch64_rust-pyo3_0.28-devel.sha256sum] = "2aa6eff44f2b29e28b79b15bc31f6f14168b0da162f72e2052eeeafa91bbfda0"

RDEPENDS:rust-pyo3_0.28+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py310-devel \
 rust-pyo3_0.28+abi3-py311-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py311-devel \
 rust-pyo3_0.28+abi3-py312-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py312-devel \
 rust-pyo3_0.28+abi3-py313-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+abi3-py313-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py313-devel \
 rust-pyo3_0.28+abi3-py314-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+abi3-py314-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py314-devel \
 rust-pyo3_0.28+abi3-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py37-devel \
 rust-pyo3_0.28+abi3-py38-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py38-devel \
 rust-pyo3_0.28+abi3-py39-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py39-devel \
 rust-pyo3_0.28+abi3-py310-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+anyhow-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+arc_lock-devel = " \
 cargo \
 rust-lock_api+arc_lock-devel \
 rust-lock_api+default-devel \
 rust-parking_lot+arc_lock-devel \
 rust-parking_lot+default-devel \
 rust-pyo3_0.28+lock_api-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+auto-initialize-devel = " \
 cargo \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+bigdecimal-devel = " \
 cargo \
 rust-bigdecimal+default-devel \
 rust-pyo3_0.28+num-bigint-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+chrono-local-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-iana-time-zone+default-devel \
 rust-iana-time-zone+fallback-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+default-devel = " \
 cargo \
 rust-pyo3_0.28+macros-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+either-devel = " \
 cargo \
 rust-either+default-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros0.28+default-devel \
 rust-pyo3-macros0.28+experimental-async-devel \
 rust-pyo3_0.28+macros-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros0.28+default-devel \
 rust-pyo3-macros0.28+experimental-inspect-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.28+extension-module-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+eyre-devel = " \
 cargo \
 rust-eyre+default-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+full-devel = " \
 cargo \
 rust-pyo3_0.28+anyhow-devel \
 rust-pyo3_0.28+arc_lock-devel \
 rust-pyo3_0.28+bigdecimal-devel \
 rust-pyo3_0.28+bytes-devel \
 rust-pyo3_0.28+chrono-devel \
 rust-pyo3_0.28+chrono-local-devel \
 rust-pyo3_0.28+chrono-tz-devel \
 rust-pyo3_0.28+either-devel \
 rust-pyo3_0.28+experimental-async-devel \
 rust-pyo3_0.28+experimental-inspect-devel \
 rust-pyo3_0.28+eyre-devel \
 rust-pyo3_0.28+hashbrown-devel \
 rust-pyo3_0.28+indexmap-devel \
 rust-pyo3_0.28+jiff-02-devel \
 rust-pyo3_0.28+lock_api-devel \
 rust-pyo3_0.28+macros-devel \
 rust-pyo3_0.28+num-bigint-devel \
 rust-pyo3_0.28+num-complex-devel \
 rust-pyo3_0.28+num-rational-devel \
 rust-pyo3_0.28+ordered-float-devel \
 rust-pyo3_0.28+parking_lot-devel \
 rust-pyo3_0.28+py-clone-devel \
 rust-pyo3_0.28+rust_decimal-devel \
 rust-pyo3_0.28+serde-devel \
 rust-pyo3_0.28+smallvec-devel \
 rust-pyo3_0.28+time-devel \
 rust-pyo3_0.28+uuid-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+hashbrown-devel = " \
 cargo \
 rust-pyo3_0.28-devel \
 virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~ \
 "
RDEPENDS:rust-pyo3_0.28+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+inventory-devel = " \
 cargo \
 rust-inventory+default-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+jiff-02-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+lock_api-devel = " \
 cargo \
 rust-lock_api+default-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+macros-devel = " \
 cargo \
 rust-pyo3_0.28+pyo3-macros-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.28+default-devel \
 rust-pyo3-macros0.28+multiple-pymethods-devel \
 rust-pyo3_0.28+inventory-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+nightly-devel = " \
 cargo \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-num-traits+default-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+num-complex-devel = " \
 cargo \
 rust-num-complex+default-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+num-rational-devel = " \
 cargo \
 rust-num-rational+default-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+ordered-float-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-pyo3_0.28+lock_api-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+py-clone-devel = " \
 cargo \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+pyo3-macros-devel = " \
 cargo \
 rust-pyo3-macros0.28+default-devel \
 rust-pyo3_0.28-devel \
 "
RDEPENDS:rust-pyo3_0.28+rust_decimal-devel = " \
 cargo \
 rust-pyo3_0.28-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-pyo3_0.28+serde-devel = " \
 cargo \
 rust-pyo3_0.28-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-pyo3_0.28+smallvec-devel = " \
 cargo \
 rust-pyo3_0.28-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-pyo3_0.28+time-devel = " \
 cargo \
 rust-pyo3_0.28-devel \
 rust-time-devel \
 "
RDEPENDS:rust-pyo3_0.28+uuid-devel = " \
 cargo \
 rust-pyo3_0.28-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-pyo3_0.28-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 rust-pyo3-build-config0.28+default-devel \
 rust-pyo3-build-config0.28+resolve-config-devel \
 rust-pyo3-ffi0.28+default-devel \
 "
