# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-editables"
PV = "0.6"
PR = "1.el10_1"
PACKAGES = " \
 python3-editables \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-editables-0.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd2c83e9adba68357c62c7946581d3f3f0958752170d24e3db28e01661d7f653"

URI_x86_64_v2_python3-editables = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-editables-0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-editables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-editables}"
SRC_URI[x86_64_v2_python3-editables.sha256sum] = "6f57d9965ece171b67f95fd1708841879dbd9fc700ce853ae4ca15de6e6ae7d3"

URI_aarch64_python3-editables = "${EPEL_MIRROR}/aarch64/Packages/p/python3-editables-0.6-1.el10_1.noarch.rpm;name=aarch64_python3-editables;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-editables}"
SRC_URI[aarch64_python3-editables.sha256sum] = "8758974dda3b0b8e128b646d52800d78235f7873b016ebb7e565c095cc7931d9"

RDEPENDS:python3-editables = " \
 python3 \
 "
