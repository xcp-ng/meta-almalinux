# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pappl"
PV = "1.4.6"
PR = "5.el10"
PACKAGES = " \
 pappl \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pappl-1.4.6-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "051aa638e04efde03e7cdb3a23f1e91ce4b1eed83c53c0083314b87296365489"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pappl-1.4.6-5.el10.x86_64_v2.rpm;name=x86_64_v2_pappl;unpack=0"
SRC_URI[x86_64_v2_pappl.sha256sum] = "519fd25c14e113ad21b05a3d3fd75a27580a6101d8d773198eff7ddef6ae305a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pappl-1.4.6-5.el10.aarch64.rpm;name=aarch64_pappl;unpack=0"
SRC_URI[aarch64_pappl.sha256sum] = "97eb824f1a23d3a4eaca0c8f5b1401d42b06117630b3cd6a3b68248713c00656"

RDEPENDS:pappl = " \
 avahi-libs \
 cups-libs \
 glibc \
 gnutls \
 libjpeg-turbo \
 libpng \
 libusb1 \
 pam-libs \
 "
