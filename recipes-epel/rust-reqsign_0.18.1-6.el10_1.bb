# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign"
PV = "0.18.1"
PR = "6.el10_1"
PACKAGES = " \
 rust-reqsign+aliyun-devel \
 rust-reqsign+aws-devel \
 rust-reqsign+azure-devel \
 rust-reqsign+default-context-devel \
 rust-reqsign+default-devel \
 rust-reqsign+full-devel \
 rust-reqsign+google-devel \
 rust-reqsign+huaweicloud-devel \
 rust-reqsign+oracle-devel \
 rust-reqsign+tencent-devel \
 rust-reqsign-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-0.18.1-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a308f92bf9cfeeea14d06d9afab7096fd003ef22356faaf196c548fe12927e20"

URI_x86_64_v2_rust-reqsign+aliyun-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+aliyun-devel-0.18.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+aliyun-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+aliyun-devel}"
SRC_URI[x86_64_v2_rust-reqsign+aliyun-devel.sha256sum] = "21144ce6091917075cf270d060b3dd7f8a9bb731cedb6cef2cea3bd96bc41cf6"

URI_x86_64_v2_rust-reqsign+aws-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+aws-devel-0.18.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+aws-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+aws-devel}"
SRC_URI[x86_64_v2_rust-reqsign+aws-devel.sha256sum] = "a5593896799a4805ae59df659a762079eab784a48b4f38b0d628126b946c2bef"

URI_x86_64_v2_rust-reqsign+azure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+azure-devel-0.18.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+azure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+azure-devel}"
SRC_URI[x86_64_v2_rust-reqsign+azure-devel.sha256sum] = "f1e22c6265a12bc3eba60a5b77f6e6b49d04bfa32565819d69ba3143195910cb"

URI_x86_64_v2_rust-reqsign+default-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+default-context-devel-0.18.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+default-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+default-context-devel}"
SRC_URI[x86_64_v2_rust-reqsign+default-context-devel.sha256sum] = "43edce6ba4c8872c2650ba6ac44a98caaa2ff4291f9ed4ccd60a206c27a4d4b7"

URI_x86_64_v2_rust-reqsign+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+default-devel-0.18.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign+default-devel.sha256sum] = "472f3264d9f0626216ee9e0011175571c6a56421886ff4fea003330e784f1b28"

URI_x86_64_v2_rust-reqsign+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+full-devel-0.18.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+full-devel}"
SRC_URI[x86_64_v2_rust-reqsign+full-devel.sha256sum] = "8f437102deb354c892a553e21dd15ae7bd1a2ea08485a0dfce5fa2b0e6b4094a"

URI_x86_64_v2_rust-reqsign+google-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+google-devel-0.18.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+google-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+google-devel}"
SRC_URI[x86_64_v2_rust-reqsign+google-devel.sha256sum] = "bdeab1bd7ec95a8fd6f55d2e93a7ae56ad95f2f1b5b15c1071e3ccf754f9758e"

URI_x86_64_v2_rust-reqsign+huaweicloud-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+huaweicloud-devel-0.18.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+huaweicloud-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+huaweicloud-devel}"
SRC_URI[x86_64_v2_rust-reqsign+huaweicloud-devel.sha256sum] = "df7c59cb6dee57095fb5fc60be7ca12f8642f8c5ba06683e03fdc00d073ac8c9"

URI_x86_64_v2_rust-reqsign+oracle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+oracle-devel-0.18.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+oracle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+oracle-devel}"
SRC_URI[x86_64_v2_rust-reqsign+oracle-devel.sha256sum] = "c175a2f77751581a2f83b26ff3ba8b54223f05765cb5ed5ce668b872bc6cccc0"

URI_x86_64_v2_rust-reqsign+tencent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign+tencent-devel-0.18.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign+tencent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign+tencent-devel}"
SRC_URI[x86_64_v2_rust-reqsign+tencent-devel.sha256sum] = "4e1f25293f943ac47847abd3a219dda97e40e17d498a23d5f44a737673fcb000"

URI_x86_64_v2_rust-reqsign-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-devel-0.18.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-devel}"
SRC_URI[x86_64_v2_rust-reqsign-devel.sha256sum] = "84bf67276a8e8e7dcd8ae8fb12463bdf90aa5575d385979cb156ed4763ff5dfa"

URI_aarch64_rust-reqsign+aliyun-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+aliyun-devel-0.18.1-6.el10_1.noarch.rpm;name=aarch64_rust-reqsign+aliyun-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+aliyun-devel}"
SRC_URI[aarch64_rust-reqsign+aliyun-devel.sha256sum] = "7b22ee943f7af4ac6d7b4eec86edbd6cd76e7df3a8582d93155336adb254307a"

URI_aarch64_rust-reqsign+aws-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+aws-devel-0.18.1-6.el10_1.noarch.rpm;name=aarch64_rust-reqsign+aws-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+aws-devel}"
SRC_URI[aarch64_rust-reqsign+aws-devel.sha256sum] = "ec07f40b03c58be9f125a8266f6c3c47d8661c2ef20f8a80210facbfcb084a7e"

URI_aarch64_rust-reqsign+azure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+azure-devel-0.18.1-6.el10_1.noarch.rpm;name=aarch64_rust-reqsign+azure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+azure-devel}"
SRC_URI[aarch64_rust-reqsign+azure-devel.sha256sum] = "7f31201786b267462b2805937fc4587cdac356aaf43a54cfbaf87a2edfb8e0f9"

URI_aarch64_rust-reqsign+default-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+default-context-devel-0.18.1-6.el10_1.noarch.rpm;name=aarch64_rust-reqsign+default-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+default-context-devel}"
SRC_URI[aarch64_rust-reqsign+default-context-devel.sha256sum] = "a09cc0f312a35581071fee2b7674bcc06fda11a11c63aa5fde6435ac1f1c0301"

URI_aarch64_rust-reqsign+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+default-devel-0.18.1-6.el10_1.noarch.rpm;name=aarch64_rust-reqsign+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+default-devel}"
SRC_URI[aarch64_rust-reqsign+default-devel.sha256sum] = "e1c06f98e14a50dedcc3d44dadcc6ef54ebaa152acfe534ad4ce30057f1f6add"

URI_aarch64_rust-reqsign+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+full-devel-0.18.1-6.el10_1.noarch.rpm;name=aarch64_rust-reqsign+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+full-devel}"
SRC_URI[aarch64_rust-reqsign+full-devel.sha256sum] = "f4571ebec0140e609d417e8d769e442ed677f65aa2cada57ba2e61e77cd95b4e"

URI_aarch64_rust-reqsign+google-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+google-devel-0.18.1-6.el10_1.noarch.rpm;name=aarch64_rust-reqsign+google-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+google-devel}"
SRC_URI[aarch64_rust-reqsign+google-devel.sha256sum] = "e7bb088860dde77136956957eb56b53b6441152e7a8343e6b91d1e7f6c960014"

URI_aarch64_rust-reqsign+huaweicloud-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+huaweicloud-devel-0.18.1-6.el10_1.noarch.rpm;name=aarch64_rust-reqsign+huaweicloud-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+huaweicloud-devel}"
SRC_URI[aarch64_rust-reqsign+huaweicloud-devel.sha256sum] = "4ac548f0766d1085ab4f05f946d29b57adad20f6d9091cd5329c1e6155fa9f0b"

URI_aarch64_rust-reqsign+oracle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+oracle-devel-0.18.1-6.el10_1.noarch.rpm;name=aarch64_rust-reqsign+oracle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+oracle-devel}"
SRC_URI[aarch64_rust-reqsign+oracle-devel.sha256sum] = "ced6e5a5212d5a21416f91ea3ef936d908083032139f1458e0e0dbb641cbf8c2"

URI_aarch64_rust-reqsign+tencent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign+tencent-devel-0.18.1-6.el10_1.noarch.rpm;name=aarch64_rust-reqsign+tencent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign+tencent-devel}"
SRC_URI[aarch64_rust-reqsign+tencent-devel.sha256sum] = "880b9a3d85692114a792892faf92521a83b600ae08bbf3721085af0f947420a6"

URI_aarch64_rust-reqsign-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-devel-0.18.1-6.el10_1.noarch.rpm;name=aarch64_rust-reqsign-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-devel}"
SRC_URI[aarch64_rust-reqsign-devel.sha256sum] = "6b0d43df5edbec002815024ea1c330e8340e6d100898b8d89b4bb688022aff37"

RDEPENDS:rust-reqsign+aliyun-devel = " \
 cargo \
 rust-reqsign-aliyun-oss+default-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+aws-devel = " \
 cargo \
 rust-reqsign-aws-v4+default-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+azure-devel = " \
 cargo \
 rust-reqsign-azure-storage+default-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+default-context-devel = " \
 cargo \
 rust-reqsign-command-execute-tokio+default-devel \
 rust-reqsign-devel \
 rust-reqsign-file-read-tokio+default-devel \
 rust-reqsign-http-send-reqwest+default-devel \
 "
RDEPENDS:rust-reqsign+default-devel = " \
 cargo \
 rust-reqsign+default-context-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+full-devel = " \
 cargo \
 rust-reqsign+aliyun-devel \
 rust-reqsign+aws-devel \
 rust-reqsign+azure-devel \
 rust-reqsign+google-devel \
 rust-reqsign+huaweicloud-devel \
 rust-reqsign+oracle-devel \
 rust-reqsign+tencent-devel \
 rust-reqsign-devel \
 "
RDEPENDS:rust-reqsign+google-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-google+default-devel \
 "
RDEPENDS:rust-reqsign+huaweicloud-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-huaweicloud-obs+default-devel \
 "
RDEPENDS:rust-reqsign+oracle-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-oracle+default-devel \
 "
RDEPENDS:rust-reqsign+tencent-devel = " \
 cargo \
 rust-reqsign-devel \
 rust-reqsign-tencent-cos+default-devel \
 "
RDEPENDS:rust-reqsign-devel = " \
 cargo \
 rust \
 rust-reqsign-core+default-devel \
 "
