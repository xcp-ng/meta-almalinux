# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpeople"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kpeople \
 kf6-kpeople-devel \
 kf6-kpeople-doc \
 kf6-kpeople-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kpeople-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7fe49824e00362890a2cdbe3d9d3987a0a36556b41ce0164a8874d7381a18e1"

URI_x86_64_v2_kf6-kpeople = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpeople;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople}"
SRC_URI[x86_64_v2_kf6-kpeople.sha256sum] = "b6f99060b8b98bcaee87750a6fb8b5e7c2a929e7bc9fba0e4379ca105e29d40c"

URI_x86_64_v2_kf6-kpeople-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpeople-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople-devel}"
SRC_URI[x86_64_v2_kf6-kpeople-devel.sha256sum] = "a8d4b5fa97d8064ce1ceb03bce4046d3e5c9267394849b0373565417bd72ad94"

URI_x86_64_v2_kf6-kpeople-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpeople-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople-doc}"
SRC_URI[x86_64_v2_kf6-kpeople-doc.sha256sum] = "c7092c652f28b400fda8146b6c8ee519ad8dfc11af488babcfbd9ab0b4bc30b4"

URI_x86_64_v2_kf6-kpeople-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpeople-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople-html}"
SRC_URI[x86_64_v2_kf6-kpeople-html.sha256sum] = "6c9859eb6afbf7d297fec65c55ed0f4970bc68c88b5f44e2ecaf627cecf58476"

URI_aarch64_kf6-kpeople = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kpeople;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople}"
SRC_URI[aarch64_kf6-kpeople.sha256sum] = "1c0bf43df1911d64a16cd2173e02190f2123cc6c0c98510eba7d85b76b54d288"

URI_aarch64_kf6-kpeople-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kpeople-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople-devel}"
SRC_URI[aarch64_kf6-kpeople-devel.sha256sum] = "385a52db86f3fd069864bf91929943602452181f44427313ff0e617818a2492b"

URI_aarch64_kf6-kpeople-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kpeople-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople-doc}"
SRC_URI[aarch64_kf6-kpeople-doc.sha256sum] = "1bc2f96b051b5fe9c751872a74ee097e255a5edbd82afdd35922a18eb9820bb9"

URI_aarch64_kf6-kpeople-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kpeople-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople-html}"
SRC_URI[aarch64_kf6-kpeople-html.sha256sum] = "b42a7260c4a0187081639b8321e315273efaed49a93c5b1aaa01cd989ec5b3e9"

RDEPENDS:kf6-kpeople = " \
 glibc \
 kf6-filesystem \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kpeople-devel = " \
 cmake-filesystem \
 kf6-kpeople \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kpeople-doc = " \
 "
RDEPENDS:kf6-kpeople-html = " \
 "
