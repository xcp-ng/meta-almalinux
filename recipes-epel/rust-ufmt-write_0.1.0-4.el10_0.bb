# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ufmt-write"
PV = "0.1.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-ufmt-write+default-devel \
 rust-ufmt-write+std-devel \
 rust-ufmt-write-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ufmt-write-0.1.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c19875b45ebee82bdd549df82d3dc9f4e90e08cf92bb008701736bb51bb53001"

URI_x86_64_v2_rust-ufmt-write+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ufmt-write+default-devel-0.1.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ufmt-write+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ufmt-write+default-devel}"
SRC_URI[x86_64_v2_rust-ufmt-write+default-devel.sha256sum] = "6bd802106b1bf63d89017814dbd3c1260d92aac3abb14a51e6df40f9ce9b74c7"

URI_x86_64_v2_rust-ufmt-write+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ufmt-write+std-devel-0.1.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ufmt-write+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ufmt-write+std-devel}"
SRC_URI[x86_64_v2_rust-ufmt-write+std-devel.sha256sum] = "2de4a1b03bf0b2f5e50bfff3211ba4c70773469aebd68dd702b5af4dfae5b288"

URI_x86_64_v2_rust-ufmt-write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ufmt-write-devel-0.1.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ufmt-write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ufmt-write-devel}"
SRC_URI[x86_64_v2_rust-ufmt-write-devel.sha256sum] = "9ea99cc2c92969f6d1e0d1020fe992e8a782a80418fe6541e64e930188c41ddd"

URI_aarch64_rust-ufmt-write+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ufmt-write+default-devel-0.1.0-4.el10_0.noarch.rpm;name=aarch64_rust-ufmt-write+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ufmt-write+default-devel}"
SRC_URI[aarch64_rust-ufmt-write+default-devel.sha256sum] = "553ce65711a20f250a6f81f1c7d51a0230dda42f005694ca4f82df8cefd6aede"

URI_aarch64_rust-ufmt-write+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ufmt-write+std-devel-0.1.0-4.el10_0.noarch.rpm;name=aarch64_rust-ufmt-write+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ufmt-write+std-devel}"
SRC_URI[aarch64_rust-ufmt-write+std-devel.sha256sum] = "dab6e7d8d36d8c12e78dd268703f2df2f5c3137646933477a1d62c0c90fa9b81"

URI_aarch64_rust-ufmt-write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ufmt-write-devel-0.1.0-4.el10_0.noarch.rpm;name=aarch64_rust-ufmt-write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ufmt-write-devel}"
SRC_URI[aarch64_rust-ufmt-write-devel.sha256sum] = "dc86881b439b14e4298ddcc26aed43b3e20670ff7d5fa275b3555b1bbd0961f2"

RDEPENDS:rust-ufmt-write+default-devel = " \
 cargo \
 rust-ufmt-write-devel \
 "
RDEPENDS:rust-ufmt-write+std-devel = " \
 cargo \
 rust-ufmt-write-devel \
 "
RDEPENDS:rust-ufmt-write-devel = " \
 cargo \
 "
