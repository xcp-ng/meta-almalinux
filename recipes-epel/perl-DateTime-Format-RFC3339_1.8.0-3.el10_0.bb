# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-Format-RFC3339"
PV = "1.8.0"
PR = "3.el10_0"
PACKAGES = " \
 perl-DateTime-Format-RFC3339 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-Format-RFC3339-1.8.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5dd21d42e10ae5de6a438fea5b95ee82a8a38be4aa26c87f45b01e201e869dac"

URI_x86_64_v2_perl-DateTime-Format-RFC3339 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-Format-RFC3339-1.8.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-Format-RFC3339;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-Format-RFC3339}"
SRC_URI[x86_64_v2_perl-DateTime-Format-RFC3339.sha256sum] = "cedb52a2003f80db62570f3b44d44d14526d0fbf03b06f9ddcfbd6d1fae863ed"

URI_aarch64_perl-DateTime-Format-RFC3339 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-Format-RFC3339-1.8.0-3.el10_0.noarch.rpm;name=aarch64_perl-DateTime-Format-RFC3339;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-Format-RFC3339}"
SRC_URI[aarch64_perl-DateTime-Format-RFC3339.sha256sum] = "9a4fa604ab0903e75f089a6cec1711ecea4a70bfaab50fdcc70f715f16724170"

RDEPENDS:perl-DateTime-Format-RFC3339 = " \
 perl-Carp \
 perl-DateTime \
 perl-constant \
 perl-libs \
 perl-version \
 "
