# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "packit"
PV = "1.16.2"
PR = "1.el10_2"
PACKAGES = " \
 packit \
 python3-packit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/packit-1.16.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e636fd4aca22b722829d3889253ceeb726eef48807db44824560cf5f3524b67a"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3-packit: python3.12dist(gitpython)

URI_x86_64_v2_packit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/packit-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_packit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_packit}"
SRC_URI[x86_64_v2_packit.sha256sum] = "feceec8900537be2c4455b2644dc25a3a0ec6a15e85d6ff834b56ad60ccdc458"

URI_x86_64_v2_python3-packit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-packit-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-packit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-packit}"
SRC_URI[x86_64_v2_python3-packit.sha256sum] = "1d359b2cb8ee8be7e3aeda044b230a8dadd0cb019ccab7ee6dda91f270641602"

URI_aarch64_packit = "${EPEL_MIRROR}/aarch64/Packages/p/packit-1.16.2-1.el10_2.noarch.rpm;name=aarch64_packit;unpack=0"
SRC_URI:append = " ${URI_aarch64_packit}"
SRC_URI[aarch64_packit.sha256sum] = "aac4495daf8535a8c23e359c404b8561477fd9848ef9fb9acbd3375ce484a1f7"

URI_aarch64_python3-packit = "${EPEL_MIRROR}/aarch64/Packages/p/python3-packit-1.16.2-1.el10_2.noarch.rpm;name=aarch64_python3-packit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-packit}"
SRC_URI[aarch64_python3-packit.sha256sum] = "d93155e24c0177ae430e4027128f93fc690ddf095b57f85492f991ef3bb229de"

RDEPENDS:packit = " \
 python3 \
 python3-packit \
 "
RDEPENDS:python3-packit:x86_64_v2 = " \
 bash \
 bodhi-client \
 fedpkg \
 git-core \
 krb5-workstation \
 osc \
 python3 \
 python3-backoff \
 python3-bugzilla \
 python3-cachetools \
 python3-cccolutils \
 python3-click \
 python3-copr \
 python3-fedora-distro-aliases \
 python3-gnupg \
 python3-koji \
 python3-lazy-object-proxy \
 python3-marshmallow \
 python3-munch \
 python3-ogr \
 python3-opensuse-distro-aliases \
 python3-packaging \
 python3-pyyaml \
 python3-requests \
 python3-requests-kerberos \
 python3-rpkg \
 python3-specfile \
 python3-tabulate \
 rpm-build \
 rpmdevtools \
 rsync \
"
RDEPENDS:python3-packit:aarch64 = " \
 bash \
 bodhi-client \
 fedpkg \
 git-core \
 krb5-workstation \
 osc \
 python3 \
 python3-GitPython \
 python3-backoff \
 python3-bugzilla \
 python3-cachetools \
 python3-cccolutils \
 python3-click \
 python3-copr \
 python3-fedora-distro-aliases \
 python3-gnupg \
 python3-koji \
 python3-lazy-object-proxy \
 python3-marshmallow \
 python3-munch \
 python3-ogr \
 python3-opensuse-distro-aliases \
 python3-packaging \
 python3-pyyaml \
 python3-requests \
 python3-requests-kerberos \
 python3-rpkg \
 python3-specfile \
 python3-tabulate \
 rpm-build \
 rpmdevtools \
 rsync \
"
