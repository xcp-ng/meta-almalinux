# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nkf"
PE = "1"
PV = "2.1.4"
PR = "35.el10_0"
PACKAGES = " \
 nkf \
 perl-NKF \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nkf-2.1.4-35.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a76cd5634cb1766726085f61a457d7f34ce62a23411c1229375b38f0489bbfbd"

URI_x86_64_v2_nkf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nkf-2.1.4-35.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nkf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nkf}"
SRC_URI[x86_64_v2_nkf.sha256sum] = "a261f125704f236db3252f89ab83248dd3ad26f54c0e2c7ef2a305b0f8c0dba2"

URI_x86_64_v2_perl-NKF = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-NKF-2.1.4-35.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-NKF;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-NKF}"
SRC_URI[x86_64_v2_perl-NKF.sha256sum] = "606ac3826991d073e36668c415c23118429a8eb91fad277026acff773f3a022b"

URI_aarch64_nkf = "${EPEL_MIRROR}/aarch64/Packages/n/nkf-2.1.4-35.el10_0.aarch64.rpm;name=aarch64_nkf;unpack=0"
SRC_URI:append = " ${URI_aarch64_nkf}"
SRC_URI[aarch64_nkf.sha256sum] = "6cc9dbf1c699a557ec7709cbb2a2c63d73ecea0e07b7a201a9f49b41a1c8062e"

URI_aarch64_perl-NKF = "${EPEL_MIRROR}/aarch64/Packages/p/perl-NKF-2.1.4-35.el10_0.aarch64.rpm;name=aarch64_perl-NKF;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-NKF}"
SRC_URI[aarch64_perl-NKF.sha256sum] = "cd85f19281f31af7e54bf8406d1dd1b05cdace548490e9ea7a99161461011600"

RDEPENDS:nkf = " \
 glibc \
 "
RDEPENDS:perl-NKF = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
