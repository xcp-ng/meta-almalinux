# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koko"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 koko \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/koko-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "decffada393dc2b8fb8538cab8f4b525327991952692e38db84f1a10874fceb5"

URI_x86_64_v2_koko = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koko-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_koko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koko}"
SRC_URI[x86_64_v2_koko.sha256sum] = "7e32983a62cab1a68bf847c3ab74539c3864f64d778ffc9454cd958f023ee1f5"

URI_aarch64_koko = "${EPEL_MIRROR}/aarch64/Packages/k/koko-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_koko;unpack=0"
SRC_URI:append = " ${URI_aarch64_koko}"
SRC_URI[aarch64_koko.sha256sum] = "b423f20da0d7a3ad982e383b368238ed3530528dbfeba54f881c83290e4e1383"

RDEPENDS:koko = " \
 exiv2-libs \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kwindowsystem \
 kf6-purpose \
 kquickimageeditor-qt6 \
 libgcc \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qt6-qtsvg \
 "
