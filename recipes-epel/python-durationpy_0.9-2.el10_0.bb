# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-durationpy"
PV = "0.9"
PR = "2.el10_0"
PACKAGES = " \
 python3-durationpy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-durationpy-0.9-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4aa036d9d7ee888f8b789e0d6fdb0a85d27ad4479a49574c06766bb36642aac7"

URI_x86_64_v2_python3-durationpy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-durationpy-0.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-durationpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-durationpy}"
SRC_URI[x86_64_v2_python3-durationpy.sha256sum] = "bd0cf49a4f5933039741d457501fac6943e4fdf039302428711cffd2336f34ed"

URI_aarch64_python3-durationpy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-durationpy-0.9-2.el10_0.noarch.rpm;name=aarch64_python3-durationpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-durationpy}"
SRC_URI[aarch64_python3-durationpy.sha256sum] = "34af35eda6d9729cea98c276e04f4bea8e501f67dd662dac518f43e937480e6c"

RDEPENDS:python3-durationpy = " \
 python3 \
 "
