# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libqmi"
PV = "1.34.0"
PR = "8.el10"
PACKAGES = " \
 libqmi \
 libqmi-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libqmi-1.34.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9578a5b55a4e128acf5067966b3b5b80ef382c3df4e121a13f5e1fa499368a2"

URI_x86_64_v2_libqmi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libqmi-1.34.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_libqmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libqmi}"
SRC_URI[x86_64_v2_libqmi.sha256sum] = "105adc0d2ab00c722d3e35f545e8f97d7cad9f689fcb55792b62690bfda18c63"

URI_x86_64_v2_libqmi-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libqmi-utils-1.34.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_libqmi-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libqmi-utils}"
SRC_URI[x86_64_v2_libqmi-utils.sha256sum] = "e0a76d98504ef76bfb422071701637b729681cec130752878b293dede9e89eda"

URI_aarch64_libqmi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libqmi-1.34.0-8.el10.aarch64.rpm;name=aarch64_libqmi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libqmi}"
SRC_URI[aarch64_libqmi.sha256sum] = "e7147178c4f9624f2b990acb5bd70c354955fe3144479b2f5f779dd97e78c0fd"

URI_aarch64_libqmi-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libqmi-utils-1.34.0-8.el10.aarch64.rpm;name=aarch64_libqmi-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libqmi-utils}"
SRC_URI[aarch64_libqmi-utils.sha256sum] = "f2930d145d70c87404f7b249dba1aff2b97aa75b5725e0914d90e5641245f04e"

RDEPENDS:libqmi = " \
 glib2 \
 glibc \
 libgcc \
 libmbim \
 libqrtr-glib \
 "
RDEPENDS:libqmi-utils = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libgudev \
 libmbim \
 libqmi \
 libqrtr-glib \
 "
