# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Lexical-SealRequireHints"
PV = "0.012"
PR = "1.el10_0"
PACKAGES = " \
 perl-Lexical-SealRequireHints \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Lexical-SealRequireHints-0.012-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7856c7b9691fd71842fd6d7e40116e81a6a0bec488eb7b419b246ff15a892014"

URI_x86_64_v2_perl-Lexical-SealRequireHints = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Lexical-SealRequireHints-0.012-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Lexical-SealRequireHints;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Lexical-SealRequireHints}"
SRC_URI[x86_64_v2_perl-Lexical-SealRequireHints.sha256sum] = "5184ab4ee95eb175675a69d447858c143f46e282b2f2d6d68d87329414790322"

URI_aarch64_perl-Lexical-SealRequireHints = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Lexical-SealRequireHints-0.012-1.el10_0.aarch64.rpm;name=aarch64_perl-Lexical-SealRequireHints;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Lexical-SealRequireHints}"
SRC_URI[aarch64_perl-Lexical-SealRequireHints.sha256sum] = "d22312a77692ce5cc4217b18abed6d041d8aa2018620cf4d316ddeb2dae0f447"

RDEPENDS:perl-Lexical-SealRequireHints = " \
 glibc \
 perl-libs \
 "
