# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiriki"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kiriki \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiriki-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3cfdb3f22dd9e89c902e2fc8d0846b4bf3f6ea7fcdd5cace27d3ce96512d39a"

URI_x86_64_v2_kiriki = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiriki-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiriki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiriki}"
SRC_URI[x86_64_v2_kiriki.sha256sum] = "6b18553cc807a5b4aefe48ab85217b967ad9d13d587a42dea76390ffb2692b56"

URI_aarch64_kiriki = "${EPEL_MIRROR}/aarch64/Packages/k/kiriki-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kiriki;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiriki}"
SRC_URI[aarch64_kiriki.sha256sum] = "539617d9363a1865780debc32b5b3334c2ec94af9bff7eabcb11d8d816cfb818"

RDEPENDS:kiriki = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
