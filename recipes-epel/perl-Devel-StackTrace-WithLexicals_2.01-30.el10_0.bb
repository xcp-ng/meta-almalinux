# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-StackTrace-WithLexicals"
PV = "2.01"
PR = "30.el10_0"
PACKAGES = " \
 perl-Devel-StackTrace-WithLexicals \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-StackTrace-WithLexicals-2.01-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5f4b0ab2df16444989026a99d3c688f4032975a0cd59f53d62b7bfb9d046d2d"

URI_x86_64_v2_perl-Devel-StackTrace-WithLexicals = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-StackTrace-WithLexicals-2.01-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-StackTrace-WithLexicals;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-StackTrace-WithLexicals}"
SRC_URI[x86_64_v2_perl-Devel-StackTrace-WithLexicals.sha256sum] = "0f8d7f8722cf5e0418cc0fd8450ec372b91bbb7fa1110cfac2768a714fde9da7"

URI_aarch64_perl-Devel-StackTrace-WithLexicals = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-StackTrace-WithLexicals-2.01-30.el10_0.noarch.rpm;name=aarch64_perl-Devel-StackTrace-WithLexicals;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-StackTrace-WithLexicals}"
SRC_URI[aarch64_perl-Devel-StackTrace-WithLexicals.sha256sum] = "e3b60aebc247d848482e8f41d77654ce66a5c4a6857b813adafb7746b4d963d6"

RDEPENDS:perl-Devel-StackTrace-WithLexicals = " \
 perl-Devel-StackTrace \
 perl-PadWalker \
 perl-base \
 perl-libs \
 "
