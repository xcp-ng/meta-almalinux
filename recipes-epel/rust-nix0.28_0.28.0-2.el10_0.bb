# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nix0.28"
PV = "0.28.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-nix0.28+acct-devel \
 rust-nix0.28+aio-devel \
 rust-nix0.28+default-devel \
 rust-nix0.28+dir-devel \
 rust-nix0.28+env-devel \
 rust-nix0.28+event-devel \
 rust-nix0.28+fanotify-devel \
 rust-nix0.28+feature-devel \
 rust-nix0.28+fs-devel \
 rust-nix0.28+hostname-devel \
 rust-nix0.28+inotify-devel \
 rust-nix0.28+ioctl-devel \
 rust-nix0.28+kmod-devel \
 rust-nix0.28+memoffset-devel \
 rust-nix0.28+mman-devel \
 rust-nix0.28+mount-devel \
 rust-nix0.28+mqueue-devel \
 rust-nix0.28+net-devel \
 rust-nix0.28+personality-devel \
 rust-nix0.28+pin-utils-devel \
 rust-nix0.28+poll-devel \
 rust-nix0.28+process-devel \
 rust-nix0.28+pthread-devel \
 rust-nix0.28+ptrace-devel \
 rust-nix0.28+quota-devel \
 rust-nix0.28+reboot-devel \
 rust-nix0.28+resource-devel \
 rust-nix0.28+sched-devel \
 rust-nix0.28+signal-devel \
 rust-nix0.28+socket-devel \
 rust-nix0.28+term-devel \
 rust-nix0.28+time-devel \
 rust-nix0.28+ucontext-devel \
 rust-nix0.28+uio-devel \
 rust-nix0.28+user-devel \
 rust-nix0.28+zerocopy-devel \
 rust-nix0.28-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nix0.28-0.28.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4760592c5d643dc147f05ba7b365afad6c71edb5c045e8f9bbba801b8c7ae1c"

URI_x86_64_v2_rust-nix0.28+acct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+acct-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+acct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+acct-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+acct-devel.sha256sum] = "4b55d8dee204d2d8cdbd6536481d444f6e97194fe4bd27c98c7ea0cf855d277f"

URI_x86_64_v2_rust-nix0.28+aio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+aio-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+aio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+aio-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+aio-devel.sha256sum] = "35fc80a850c1d1634e6122303be80860639c9fc7085c9d8565053d7ad3ad27d3"

URI_x86_64_v2_rust-nix0.28+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+default-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+default-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+default-devel.sha256sum] = "04595878ea0cac32b6711e485975ede3f391103971097a9364a7b65e432f490f"

URI_x86_64_v2_rust-nix0.28+dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+dir-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+dir-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+dir-devel.sha256sum] = "3e376d5264b1d2651eeb1829776a42153ce3fcf2bea40a58fe5e5132ff03f67c"

URI_x86_64_v2_rust-nix0.28+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+env-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+env-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+env-devel.sha256sum] = "8a71f434aa900feb9a6cfbe66c2127c83f0a9d44e87a5bee564d66ba19510d8a"

URI_x86_64_v2_rust-nix0.28+event-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+event-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+event-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+event-devel.sha256sum] = "95ddc53b49fc8a57ac1a85386f6a1ef7dde765a33693b332137bd770d57e8950"

URI_x86_64_v2_rust-nix0.28+fanotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+fanotify-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+fanotify-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+fanotify-devel.sha256sum] = "385dfb353fec5c1a144c39649732f3577328814399b5c371f1f3db4abc836066"

URI_x86_64_v2_rust-nix0.28+feature-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+feature-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+feature-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+feature-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+feature-devel.sha256sum] = "9817f8dcf7cd107195b08793c5ca404a9ac01c185656e2f68b9f83a5b96eb756"
RPROVIDES:rust-nix0.28+feature-devel:x86_64_v2 = "virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~"

URI_x86_64_v2_rust-nix0.28+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+fs-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+fs-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+fs-devel.sha256sum] = "464ffccc803f126373e94d48b76ee0c058f9977a27be5542bfa36cd0b6df84cf"

URI_x86_64_v2_rust-nix0.28+hostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+hostname-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+hostname-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+hostname-devel.sha256sum] = "cfd8b8ef2861e089474922c2e02e1ca30899aa54f8ad877133c9e0fe76c88bf1"

URI_x86_64_v2_rust-nix0.28+inotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+inotify-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+inotify-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+inotify-devel.sha256sum] = "79a51d9854793458192f4c5d5b5ede2bf8608b14b2004f984b9a0f4f2561d05b"

URI_x86_64_v2_rust-nix0.28+ioctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+ioctl-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+ioctl-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+ioctl-devel.sha256sum] = "9f9227b8aed8e52b78a29f8efabb3f186b67eed001a5f1d9dabb6c1411eb0b47"

URI_x86_64_v2_rust-nix0.28+kmod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+kmod-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+kmod-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+kmod-devel.sha256sum] = "d13372ed701b85b6650ceeb8e4a05500fc5a1676f06deda962a7db3c41983b9f"

URI_x86_64_v2_rust-nix0.28+memoffset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+memoffset-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+memoffset-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+memoffset-devel.sha256sum] = "14059d9b23e9c9609d2d24f2eacaebcbb0fee2174a4219289159db2b0599e2ec"

URI_x86_64_v2_rust-nix0.28+mman-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+mman-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+mman-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+mman-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+mman-devel.sha256sum] = "e34726109c0cfbd2802643b315be60745c35b13d6bcf68457888a4896f281d4f"

URI_x86_64_v2_rust-nix0.28+mount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+mount-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+mount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+mount-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+mount-devel.sha256sum] = "7dafe0763fa8a81e5636c9e4386486fbb0df1fda8662164766b1f9112a11f678"

URI_x86_64_v2_rust-nix0.28+mqueue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+mqueue-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+mqueue-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+mqueue-devel.sha256sum] = "52a4a10bbd8f29ac92c47651bbd0b4878a17f967eea9f19b0a640cc7ec1c9c86"

URI_x86_64_v2_rust-nix0.28+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+net-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+net-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+net-devel.sha256sum] = "90d6268e07644e6fc425112f73a4401b575d04a6137a0788c67a216753ba7148"

URI_x86_64_v2_rust-nix0.28+personality-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+personality-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+personality-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+personality-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+personality-devel.sha256sum] = "c225da2930309182257f971fafd99ca705b70a38140dc444ecb5256e681c889f"

URI_x86_64_v2_rust-nix0.28+pin-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+pin-utils-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+pin-utils-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+pin-utils-devel.sha256sum] = "56f25716928bdcbc2d38a715578cf10e577f1c0c91f6dcbbae59140829ff0c7b"

URI_x86_64_v2_rust-nix0.28+poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+poll-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+poll-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+poll-devel.sha256sum] = "be394934c396fa5af9af9ac473ddce4668f04a7130e92951aab6a01750128031"

URI_x86_64_v2_rust-nix0.28+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+process-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+process-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+process-devel.sha256sum] = "18ca1257b5978a568bbb7f5e0df560647b0e4a5baefc718a38abd3fb6a56aba4"

URI_x86_64_v2_rust-nix0.28+pthread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+pthread-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+pthread-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+pthread-devel.sha256sum] = "9f2dcb9a2882d24f2f637d8b751e3bb68bf698c58d9ff3db469b4912a17af6d8"

URI_x86_64_v2_rust-nix0.28+ptrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+ptrace-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+ptrace-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+ptrace-devel.sha256sum] = "aa47ea872cbf9acf49b2b3c77875bce4eb3971559a9ce700beed3c47fe5130d7"

URI_x86_64_v2_rust-nix0.28+quota-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+quota-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+quota-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+quota-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+quota-devel.sha256sum] = "6b8c52f60aa752df537b1da6f13782aff7b0ac68485b89d72f1f9b40ac15e29b"

URI_x86_64_v2_rust-nix0.28+reboot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+reboot-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+reboot-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+reboot-devel.sha256sum] = "4241edbb38b7d5268513fc19c1c16c3112947ba69223b4e96a8afdef0abdc119"

URI_x86_64_v2_rust-nix0.28+resource-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+resource-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+resource-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+resource-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+resource-devel.sha256sum] = "5edf296a9304db7cdc9203683d62b76aab301fdef0e40ce7f6e3c26fe73e4506"

URI_x86_64_v2_rust-nix0.28+sched-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+sched-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+sched-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+sched-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+sched-devel.sha256sum] = "b6b4a45c8176e05cd795ddf59d7aa8e794f6d92bc6c54686d27410295431bb7e"

URI_x86_64_v2_rust-nix0.28+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+signal-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+signal-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+signal-devel.sha256sum] = "baada255266f8eee35da7f3acba9f52262f501be17a50f84824d403cded88a6e"

URI_x86_64_v2_rust-nix0.28+socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+socket-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+socket-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+socket-devel.sha256sum] = "1af5fa0c0e18ae22d865e15213745e295553f54fba945966f9b52838748dbcb7"

URI_x86_64_v2_rust-nix0.28+term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+term-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+term-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+term-devel.sha256sum] = "61d67beda745da0ce6fd83125460b478260ebe317d058db239bdd0ba3c7b013c"

URI_x86_64_v2_rust-nix0.28+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+time-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+time-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+time-devel.sha256sum] = "5ec79228c12591360bb881aaa63220a97f049f6c3d184a082e5bd634a894e729"

URI_x86_64_v2_rust-nix0.28+ucontext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+ucontext-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+ucontext-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+ucontext-devel.sha256sum] = "fef7084a21721dc5bfd98bbe7f4c8405e8772486ffc4ede34446bd4b8cba1547"

URI_x86_64_v2_rust-nix0.28+uio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+uio-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+uio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+uio-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+uio-devel.sha256sum] = "f03186e5ef3aead15c7a6539255d1e196907840359b66907cf7d35dde104b3db"

URI_x86_64_v2_rust-nix0.28+user-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+user-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+user-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+user-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+user-devel.sha256sum] = "a5a7062a085548d368c4e7402a01cec734bc7d62a33c43952fcb3b7b4d195b30"

URI_x86_64_v2_rust-nix0.28+zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28+zerocopy-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28+zerocopy-devel}"
SRC_URI[x86_64_v2_rust-nix0.28+zerocopy-devel.sha256sum] = "ffc1b78ec353aca3b09ac27f41fe5d6c2d611506e2f72d3177661bf2e5345ff3"

URI_x86_64_v2_rust-nix0.28-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.28-devel-0.28.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.28-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.28-devel}"
SRC_URI[x86_64_v2_rust-nix0.28-devel.sha256sum] = "6c620cbb044ddb1c56f8e0f0680a300e84304c48077e06a4cf77ff8c80632268"
RPROVIDES:rust-nix0.28-devel:x86_64_v2 = "virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~"

URI_aarch64_rust-nix0.28+acct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+acct-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+acct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+acct-devel}"
SRC_URI[aarch64_rust-nix0.28+acct-devel.sha256sum] = "e1d6bda77e6335c34cad09f03b8711e9274718e1746e695503c687e0aa33ccf6"

URI_aarch64_rust-nix0.28+aio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+aio-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+aio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+aio-devel}"
SRC_URI[aarch64_rust-nix0.28+aio-devel.sha256sum] = "e8dcc8a8cc6f722b83feeb41ad79108a3cad970dfdde7e4d44a9ef25b07284df"

URI_aarch64_rust-nix0.28+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+default-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+default-devel}"
SRC_URI[aarch64_rust-nix0.28+default-devel.sha256sum] = "e328ff269db9dd61c58046a30667c56c3de818b6f6c6265b8bfe87e490766f5b"

URI_aarch64_rust-nix0.28+dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+dir-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+dir-devel}"
SRC_URI[aarch64_rust-nix0.28+dir-devel.sha256sum] = "4af687ce59964dab3d7ea99531d109caa7e9072538dc6f93352bc68cfd1b4a6c"

URI_aarch64_rust-nix0.28+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+env-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+env-devel}"
SRC_URI[aarch64_rust-nix0.28+env-devel.sha256sum] = "e27560ea3bfc01373152bc7f80827c8663c6b096e409bd43dc4ed167a6051105"

URI_aarch64_rust-nix0.28+event-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+event-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+event-devel}"
SRC_URI[aarch64_rust-nix0.28+event-devel.sha256sum] = "ebb66f3b9c45dc51fd7396e0115ac4410dc4b372d5bb8d20bd253c4a24114ad7"

URI_aarch64_rust-nix0.28+fanotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+fanotify-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+fanotify-devel}"
SRC_URI[aarch64_rust-nix0.28+fanotify-devel.sha256sum] = "4c3d3919f239052ea04f6cc44699c8aa06d7b2be0902ed956f538a27ff584d63"

URI_aarch64_rust-nix0.28+feature-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+feature-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+feature-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+feature-devel}"
SRC_URI[aarch64_rust-nix0.28+feature-devel.sha256sum] = "6e422a21bb77278dbabc457c382bc2706a9e2f033f59c789cb9dc08f1c678494"
RPROVIDES:rust-nix0.28+feature-devel:aarch64 = "virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~"

URI_aarch64_rust-nix0.28+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+fs-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+fs-devel}"
SRC_URI[aarch64_rust-nix0.28+fs-devel.sha256sum] = "4c6ae2793acf010662a6eaeff3cad19d5d80c4a6cfbc2d6a1c6b1b44f6a7545f"

URI_aarch64_rust-nix0.28+hostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+hostname-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+hostname-devel}"
SRC_URI[aarch64_rust-nix0.28+hostname-devel.sha256sum] = "796ee5a4670823e0843c2da006d1caf63e30927242fde326885826c23b6c67d1"

URI_aarch64_rust-nix0.28+inotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+inotify-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+inotify-devel}"
SRC_URI[aarch64_rust-nix0.28+inotify-devel.sha256sum] = "d38a44d84ab45e5df19861e37ee6ebfc5812a6cc4705c6738ea368b14d09a7b6"

URI_aarch64_rust-nix0.28+ioctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+ioctl-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+ioctl-devel}"
SRC_URI[aarch64_rust-nix0.28+ioctl-devel.sha256sum] = "405cc934aa435f6cdac88f623550ca889486a16c0d5c10f8d9a4def6c86499ba"

URI_aarch64_rust-nix0.28+kmod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+kmod-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+kmod-devel}"
SRC_URI[aarch64_rust-nix0.28+kmod-devel.sha256sum] = "4fc0d11e0c2a4fceae62efb83ed5fc17597f129967f2f3d75906f0f3eac5eed4"

URI_aarch64_rust-nix0.28+memoffset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+memoffset-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+memoffset-devel}"
SRC_URI[aarch64_rust-nix0.28+memoffset-devel.sha256sum] = "3b30b9d0396009d3b4e369f99b5ce43d21802703f179ab9c9581f5502724782a"

URI_aarch64_rust-nix0.28+mman-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+mman-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+mman-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+mman-devel}"
SRC_URI[aarch64_rust-nix0.28+mman-devel.sha256sum] = "34459e07373268e186fe15e1a4d2db717f120c4a7f2a251dd16f1bbc09945f5b"

URI_aarch64_rust-nix0.28+mount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+mount-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+mount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+mount-devel}"
SRC_URI[aarch64_rust-nix0.28+mount-devel.sha256sum] = "249630b9ebb48e2b72ddcbe86f19797f8b6fff789b4d041f2a0d1d0b5b176557"

URI_aarch64_rust-nix0.28+mqueue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+mqueue-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+mqueue-devel}"
SRC_URI[aarch64_rust-nix0.28+mqueue-devel.sha256sum] = "470187edc57c83415f0bffc7b8f21db7ea2d93508a4e954a2b0fb910aa5747a0"

URI_aarch64_rust-nix0.28+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+net-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+net-devel}"
SRC_URI[aarch64_rust-nix0.28+net-devel.sha256sum] = "82d49446f0119fed443126adbb7cab642d4ff1a5b33b3e3404a53b4e9c9c85dc"

URI_aarch64_rust-nix0.28+personality-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+personality-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+personality-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+personality-devel}"
SRC_URI[aarch64_rust-nix0.28+personality-devel.sha256sum] = "f8097bb3a50bf323d6b5d57eb9e57cd8ec8a0c1371e8a475a40ed493c0af5bf7"

URI_aarch64_rust-nix0.28+pin-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+pin-utils-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+pin-utils-devel}"
SRC_URI[aarch64_rust-nix0.28+pin-utils-devel.sha256sum] = "eda5eeec85f5c373b935d48e98b25601a3fe8ec5e567b0c3fa69183ccf7df558"

URI_aarch64_rust-nix0.28+poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+poll-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+poll-devel}"
SRC_URI[aarch64_rust-nix0.28+poll-devel.sha256sum] = "99d95cb78d6820f640f5e88409526b7adc547362ea7c7a3b9df5d5c49b985f7d"

URI_aarch64_rust-nix0.28+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+process-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+process-devel}"
SRC_URI[aarch64_rust-nix0.28+process-devel.sha256sum] = "dc94816e55ffbf39255398dbfe2c4658728f0d2206020efd36660921a26a4ea8"

URI_aarch64_rust-nix0.28+pthread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+pthread-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+pthread-devel}"
SRC_URI[aarch64_rust-nix0.28+pthread-devel.sha256sum] = "a0f428fe813a73d46a471a963b6378f33c362846dce0f636be58a59893e2a469"

URI_aarch64_rust-nix0.28+ptrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+ptrace-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+ptrace-devel}"
SRC_URI[aarch64_rust-nix0.28+ptrace-devel.sha256sum] = "5a0c1bcf9c2e052b98651d2ad97927c811aca30f0863bfa028b159f09e8c1275"

URI_aarch64_rust-nix0.28+quota-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+quota-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+quota-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+quota-devel}"
SRC_URI[aarch64_rust-nix0.28+quota-devel.sha256sum] = "19711f9369a00e30fab48c294f5b1b398684b2923acc9b89adc405214bdf25c0"

URI_aarch64_rust-nix0.28+reboot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+reboot-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+reboot-devel}"
SRC_URI[aarch64_rust-nix0.28+reboot-devel.sha256sum] = "92fd78513c034ab2c2193193db3535556b9df4f2a9b09fd1c33ae1e839cd6d4c"

URI_aarch64_rust-nix0.28+resource-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+resource-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+resource-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+resource-devel}"
SRC_URI[aarch64_rust-nix0.28+resource-devel.sha256sum] = "5fbdecb40f4d3c6c6313c8d7d3929f3971f274148f60b20306c8e11e167dda7b"

URI_aarch64_rust-nix0.28+sched-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+sched-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+sched-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+sched-devel}"
SRC_URI[aarch64_rust-nix0.28+sched-devel.sha256sum] = "b85f486d6843e6e515cc33b611c44c3c2d739d89cc34786131485a7c0804c236"

URI_aarch64_rust-nix0.28+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+signal-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+signal-devel}"
SRC_URI[aarch64_rust-nix0.28+signal-devel.sha256sum] = "a84b9aa91a738d603e0a2636d2d0c72c2bf484f889415ec2050fbd7cc2657bd3"

URI_aarch64_rust-nix0.28+socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+socket-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+socket-devel}"
SRC_URI[aarch64_rust-nix0.28+socket-devel.sha256sum] = "211b71764d03ec08227a34e8a2ac5378f90a876d9d684de0b9627c2c6ee0d96e"

URI_aarch64_rust-nix0.28+term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+term-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+term-devel}"
SRC_URI[aarch64_rust-nix0.28+term-devel.sha256sum] = "4889ff56c17a881353d702c73de812f7a7a281c43f0417fa35373f6332611e05"

URI_aarch64_rust-nix0.28+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+time-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+time-devel}"
SRC_URI[aarch64_rust-nix0.28+time-devel.sha256sum] = "e3b4ded156ee783b5775d000ce795af58d79a5cb86393556d8baa43522c1df24"

URI_aarch64_rust-nix0.28+ucontext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+ucontext-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+ucontext-devel}"
SRC_URI[aarch64_rust-nix0.28+ucontext-devel.sha256sum] = "6b7598e93b76064afe342a1bd05a57e256a013299e87cb46eac674fecbb93fd8"

URI_aarch64_rust-nix0.28+uio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+uio-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+uio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+uio-devel}"
SRC_URI[aarch64_rust-nix0.28+uio-devel.sha256sum] = "77d590c6d42a0274b9e0f49a464d352676d0612cfaabe6e5a566a4d1b1e0596c"

URI_aarch64_rust-nix0.28+user-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+user-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+user-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+user-devel}"
SRC_URI[aarch64_rust-nix0.28+user-devel.sha256sum] = "1246fe7b74466fc1f6b0b431fed241b36b005b0a491a0878498a2cf7f094b7c5"

URI_aarch64_rust-nix0.28+zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28+zerocopy-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28+zerocopy-devel}"
SRC_URI[aarch64_rust-nix0.28+zerocopy-devel.sha256sum] = "480f236e3ef454543a8117889722a4ed680d420e75a871a3931eb8c56c996714"

URI_aarch64_rust-nix0.28-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.28-devel-0.28.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix0.28-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.28-devel}"
SRC_URI[aarch64_rust-nix0.28-devel.sha256sum] = "067a862be84a737dda48f0308a6a528022e648200ec7ff2fa07f118fdc069f05"
RPROVIDES:rust-nix0.28-devel:aarch64 = "virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~"

RDEPENDS:rust-nix0.28+acct-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+aio-devel = " \
 cargo \
 rust-nix0.28+pin-utils-devel \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+default-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+dir-devel = " \
 cargo \
 rust-nix0.28+fs-devel \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+env-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+event-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+fanotify-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+feature-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+fs-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+hostname-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+inotify-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+ioctl-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+kmod-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+memoffset-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+mman-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+mount-devel = " \
 cargo \
 rust-nix0.28+uio-devel \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+mqueue-devel = " \
 cargo \
 rust-nix0.28+fs-devel \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+net-devel = " \
 cargo \
 rust-nix0.28+socket-devel \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+personality-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+pin-utils-devel = " \
 cargo \
 rust-nix0.28-devel \
 rust-pin-utils+default-devel \
 "
RDEPENDS:rust-nix0.28+poll-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+process-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+pthread-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+ptrace-devel = " \
 cargo \
 rust-nix0.28+process-devel \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+quota-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+reboot-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+resource-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+sched-devel = " \
 cargo \
 rust-nix0.28+process-devel \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+signal-devel = " \
 cargo \
 rust-nix0.28+process-devel \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+socket-devel = " \
 cargo \
 rust-nix0.28+memoffset-devel \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+term-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+time-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+ucontext-devel = " \
 cargo \
 rust-nix0.28+signal-devel \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+uio-devel = " \
 cargo \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+user-devel = " \
 cargo \
 rust-nix0.28+feature-devel \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28+zerocopy-devel = " \
 cargo \
 rust-nix0.28+fs-devel \
 rust-nix0.28+uio-devel \
 rust-nix0.28-devel \
 "
RDEPENDS:rust-nix0.28-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-cfg_aliases0.1+default-devel \
 rust-libc+default-devel \
 rust-libc+extra_traits-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~ rpm/virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~ rpm/virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~"
