# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-validation-layers"
PV = "1.4.313.0"
PR = "1.el10"
PACKAGES = " \
 vulkan-validation-layers \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-validation-layers-1.4.313.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0075df968951399584822f2bb076810e8360f9957846cb5f4a44265149ff339"

URI_x86_64_v2_vulkan-validation-layers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-validation-layers-1.4.313.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-validation-layers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-validation-layers}"
SRC_URI[x86_64_v2_vulkan-validation-layers.sha256sum] = "afe10450f769d0f8cbba66b832f3896370f95174e5b8a56de9200d6ad8a5b11b"

URI_aarch64_vulkan-validation-layers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-validation-layers-1.4.313.0-1.el10.aarch64.rpm;name=aarch64_vulkan-validation-layers;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-validation-layers}"
SRC_URI[aarch64_vulkan-validation-layers.sha256sum] = "b00fb2900421702fa8ee008e3f9ba2d423075fc7efbf1d5432ea467771bf78fa"

RDEPENDS:vulkan-validation-layers = " \
 glibc \
 libgcc \
 libstdc++ \
 spirv-tools-libs \
 "
