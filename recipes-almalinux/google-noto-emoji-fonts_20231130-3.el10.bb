# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-noto-emoji-fonts"
PV = "20231130"
PR = "3.el10"
PACKAGES = " \
 google-noto-color-emoji-fonts \
 google-noto-emoji-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/google-noto-emoji-fonts-20231130-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "180d55fc29ab270e2c88de844f9de575210614d149ae1400bbe459032172f9ac"

URI_x86_64_v2_google-noto-color-emoji-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/google-noto-color-emoji-fonts-20231130-3.el10.noarch.rpm;name=x86_64_v2_google-noto-color-emoji-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-noto-color-emoji-fonts}"
SRC_URI[x86_64_v2_google-noto-color-emoji-fonts.sha256sum] = "cebaf6dbd64f3f75455d67408ab15d5dc2563fecf3648516ab10eb9f3b663ee4"

URI_x86_64_v2_google-noto-emoji-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/google-noto-emoji-fonts-20231130-3.el10.noarch.rpm;name=x86_64_v2_google-noto-emoji-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-noto-emoji-fonts}"
SRC_URI[x86_64_v2_google-noto-emoji-fonts.sha256sum] = "a94a1b3f4aeeaebb2af94d6b2d6fc9719cb7d03b0c6892324b867fa00523054b"

URI_aarch64_google-noto-color-emoji-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/google-noto-color-emoji-fonts-20231130-3.el10.noarch.rpm;name=aarch64_google-noto-color-emoji-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-noto-color-emoji-fonts}"
SRC_URI[aarch64_google-noto-color-emoji-fonts.sha256sum] = "cebaf6dbd64f3f75455d67408ab15d5dc2563fecf3648516ab10eb9f3b663ee4"

URI_aarch64_google-noto-emoji-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/google-noto-emoji-fonts-20231130-3.el10.noarch.rpm;name=aarch64_google-noto-emoji-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-noto-emoji-fonts}"
SRC_URI[aarch64_google-noto-emoji-fonts.sha256sum] = "a94a1b3f4aeeaebb2af94d6b2d6fc9719cb7d03b0c6892324b867fa00523054b"

RDEPENDS:google-noto-color-emoji-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:google-noto-emoji-fonts = " \
 fonts-filesystem \
 "
