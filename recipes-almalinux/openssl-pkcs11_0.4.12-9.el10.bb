# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssl-pkcs11"
PV = "0.4.12"
PR = "9.el10"
PACKAGES = " \
 openssl-pkcs11 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openssl-pkcs11-0.4.12-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2d7cda17c945c023c40df2364c8c30e49ba46fe52f2cb899cfafb8c2cb10a5e"

URI_x86_64_v2_openssl-pkcs11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssl-pkcs11-0.4.12-9.el10.x86_64_v2.rpm;name=x86_64_v2_openssl-pkcs11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-pkcs11}"
SRC_URI[x86_64_v2_openssl-pkcs11.sha256sum] = "03d01e3ff081ce9fb2511e7c16ea0c822f2dd32309f3c64c145e30aad7ea03c6"

URI_aarch64_openssl-pkcs11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssl-pkcs11-0.4.12-9.el10.aarch64.rpm;name=aarch64_openssl-pkcs11;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-pkcs11}"
SRC_URI[aarch64_openssl-pkcs11.sha256sum] = "28b818d4638e5a2d46a6ffcee719cc4cebcaecc3b8a723c1bc4212583b2e36d1"

RDEPENDS:openssl-pkcs11 = " \
 glibc \
 openssl-libs \
 p11-kit-trust \
 "
