# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-hvac"
PV = "2.4.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-hvac \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-hvac-2.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bafad0664011db9c18a54c3ae1a1e19a6900561d6422cb1b07cea5274244a689"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hvac-2.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hvac;unpack=0"
SRC_URI[x86_64_v2_python3-hvac.sha256sum] = "69cfef1fd433235acf0575fc3626754367c397af007336206e9ee9bf5324903d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-hvac-2.4.0-1.el10_1.noarch.rpm;name=aarch64_python3-hvac;unpack=0"
SRC_URI[aarch64_python3-hvac.sha256sum] = "4cb134ff56a0f69e955c8c8c432cc93ddb9cb2606223091dadbc33875abd225f"

RDEPENDS:python3-hvac = " \
 python3 \
 python3-requests \
 "
