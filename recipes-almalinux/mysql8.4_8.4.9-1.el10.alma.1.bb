# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mysql8.4"
PV = "8.4.9"
PR = "1.el10.alma.1"
PACKAGES = " \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-devel \
 mysql8.4-errmsg \
 mysql8.4-libs \
 mysql8.4-server \
 mysql8.4-test \
 mysql8.4-test-data \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mysql8.4-8.4.9-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb3a11148086e9281ec5cddec1847fe565043f433f67c117535b022dcdce22d0"

URI_x86_64_v2_mysql8.4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-8.4.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4}"
SRC_URI[x86_64_v2_mysql8.4.sha256sum] = "86f5b3ea5b9f6f94849ac900914f7c9fea79bd5847739632a8c93789a80d214a"
RPROVIDES:mysql8.4:x86_64_v2 = "virtual//usr/bin/mysqldump virtual/mysql-any_or_mariadb-any"

URI_x86_64_v2_mysql8.4-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-common-8.4.9-1.el10.alma.1.noarch.rpm;name=x86_64_v2_mysql8.4-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-common}"
SRC_URI[x86_64_v2_mysql8.4-common.sha256sum] = "261ad0ec49a47588d0c43634ba939cd7663c5e46273ca495400cf764e2c107e3"

URI_x86_64_v2_mysql8.4-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mysql8.4-devel-8.4.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-devel}"
SRC_URI[x86_64_v2_mysql8.4-devel.sha256sum] = "f5409dcbc65e9dd9c77bd32be87dc827c3f26ed019108fac1f20161e3a0dc380"

URI_x86_64_v2_mysql8.4-errmsg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-errmsg-8.4.9-1.el10.alma.1.noarch.rpm;name=x86_64_v2_mysql8.4-errmsg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-errmsg}"
SRC_URI[x86_64_v2_mysql8.4-errmsg.sha256sum] = "53bbeea8aca22d5d2bd0af3c9482f600cf19b90407c07407e246a308fb33e9a9"

URI_x86_64_v2_mysql8.4-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-libs-8.4.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-libs}"
SRC_URI[x86_64_v2_mysql8.4-libs.sha256sum] = "aed4ac79ddf1abe600e5c3018d418b68d46328427a55d01e7d07358c872cd83d"

URI_x86_64_v2_mysql8.4-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-server-8.4.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-server}"
SRC_URI[x86_64_v2_mysql8.4-server.sha256sum] = "26a861a9b41b52477c84d08745dea6ac13d0235666746002389603dcb5a20936"

URI_x86_64_v2_mysql8.4-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mysql8.4-test-8.4.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-test}"
SRC_URI[x86_64_v2_mysql8.4-test.sha256sum] = "7d53b18dd8bfc1bace24678882761c8f3c7158f6d2ea86de8385262e0bc0e16b"

URI_x86_64_v2_mysql8.4-test-data = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mysql8.4-test-data-8.4.9-1.el10.alma.1.noarch.rpm;name=x86_64_v2_mysql8.4-test-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql8.4-test-data}"
SRC_URI[x86_64_v2_mysql8.4-test-data.sha256sum] = "f056fbffe529aa4bbe242fe2094d41a903f3b44a509da18b19e3a31250565929"

URI_aarch64_mysql8.4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-8.4.9-1.el10.alma.1.aarch64.rpm;name=aarch64_mysql8.4;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4}"
SRC_URI[aarch64_mysql8.4.sha256sum] = "6bfa914620f6967143de70bb39a74a23cb3d71346a5a903235d93223b80d2756"
RPROVIDES:mysql8.4:aarch64 = "virtual//usr/bin/mysqldump virtual/mysql-any_or_mariadb-any"

URI_aarch64_mysql8.4-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-common-8.4.9-1.el10.alma.1.noarch.rpm;name=aarch64_mysql8.4-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-common}"
SRC_URI[aarch64_mysql8.4-common.sha256sum] = "261ad0ec49a47588d0c43634ba939cd7663c5e46273ca495400cf764e2c107e3"

URI_aarch64_mysql8.4-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mysql8.4-devel-8.4.9-1.el10.alma.1.aarch64.rpm;name=aarch64_mysql8.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-devel}"
SRC_URI[aarch64_mysql8.4-devel.sha256sum] = "02fdcd333f3faf6e69ca7ab542d6967d8eb00cd12d929c7e7e6c5aea09ad97f5"

URI_aarch64_mysql8.4-errmsg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-errmsg-8.4.9-1.el10.alma.1.noarch.rpm;name=aarch64_mysql8.4-errmsg;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-errmsg}"
SRC_URI[aarch64_mysql8.4-errmsg.sha256sum] = "53bbeea8aca22d5d2bd0af3c9482f600cf19b90407c07407e246a308fb33e9a9"

URI_aarch64_mysql8.4-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-libs-8.4.9-1.el10.alma.1.aarch64.rpm;name=aarch64_mysql8.4-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-libs}"
SRC_URI[aarch64_mysql8.4-libs.sha256sum] = "bf0f07e09f1b51dbb2f210a2ed4ab0d16ca3cba9773efe53b4e7864e3156cee0"

URI_aarch64_mysql8.4-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-server-8.4.9-1.el10.alma.1.aarch64.rpm;name=aarch64_mysql8.4-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-server}"
SRC_URI[aarch64_mysql8.4-server.sha256sum] = "98508d1c417bb4d9186c62a042116fba7a78ca8ed464b9459c64a0657805e850"

URI_aarch64_mysql8.4-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mysql8.4-test-8.4.9-1.el10.alma.1.aarch64.rpm;name=aarch64_mysql8.4-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-test}"
SRC_URI[aarch64_mysql8.4-test.sha256sum] = "c523f32a957b7321eeabf77373143069311ffa8542a4c2756a067431a03c2dad"

URI_aarch64_mysql8.4-test-data = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mysql8.4-test-data-8.4.9-1.el10.alma.1.noarch.rpm;name=aarch64_mysql8.4-test-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql8.4-test-data}"
SRC_URI[aarch64_mysql8.4-test-data.sha256sum] = "f056fbffe529aa4bbe242fe2094d41a903f3b44a509da18b19e3a31250565929"

RDEPENDS:mysql8.4 = " \
 bash \
 glibc \
 grep \
 libedit \
 libgcc \
 libstdc++ \
 libzstd \
 mysql8.4-common \
 openssl-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:mysql8.4-common = " \
 mariadb-connector-c-config \
 "
RDEPENDS:mysql8.4-devel = " \
 bash \
 libzstd-devel \
 mysql8.4-libs \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:mysql8.4-errmsg = " \
 mysql8.4-common \
 "
RDEPENDS:mysql8.4-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 mysql8.4-common \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:mysql8.4-server:x86_64_v2 = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libicu \
 libstdc++ \
 libtirpc \
 libzstd \
 lz4-libs \
 mariadb-connector-c-config \
 mecab \
 mysql-selinux \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-errmsg \
 numactl-libs \
 openssl-libs \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 policycoreutils-python-utils \
 protobuf-lite \
 shadow-utils \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:mysql8.4-server:aarch64 = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libicu \
 libstdc++ \
 libtirpc \
 libzstd \
 lz4-libs \
 mariadb-connector-c-config \
 mecab \
 mysql-selinux \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-errmsg \
 openssl-libs \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 policycoreutils-python-utils \
 protobuf-lite \
 shadow-utils \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:mysql8.4-test = " \
 bash \
 glibc \
 gzip \
 libgcc \
 libstdc++ \
 libzstd \
 lz4 \
 lz4-libs \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-server \
 mysql8.4-test-data \
 openssl \
 openssl-libs \
 perl-Data-Dumper \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Env \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Compare \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-JSON \
 perl-Memoize \
 perl-Socket \
 perl-Sys-Hostname \
 perl-Test-Simple \
 perl-Time-HiRes \
 perl-libwww-perl \
 protobuf \
 zlib-ng-compat \
 "
RDEPENDS:mysql8.4-test-data = " \
 bash \
 mysql8.4-test \
 perl-Carp \
 perl-Data-Dumper \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IO \
 perl-JSON \
 perl-Memoize \
 perl-POSIX \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Test-Simple \
 perl-Time \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-if \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 perl-threads \
 perl-threads-shared \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/mysqldump rpm/virtual/mysql-any_or_mariadb-any"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/mysqldump rpm/virtual/mysql-any_or_mariadb-any"
