# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deadpool"
PV = "0.13.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-deadpool+default-devel \
 rust-deadpool+managed-devel \
 rust-deadpool+rt_smol_2-devel \
 rust-deadpool+rt_tokio_1-devel \
 rust-deadpool+serde-devel \
 rust-deadpool+unmanaged-devel \
 rust-deadpool-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deadpool-0.13.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7006288bb638fc2d2e7970440e927e4f4305e93a907554023498af0a040c5844"

URI_x86_64_v2_rust-deadpool+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+default-devel-0.13.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+default-devel}"
SRC_URI[x86_64_v2_rust-deadpool+default-devel.sha256sum] = "2615c1e1d459cee83ead591004a241a77cfa0ba46553241827d73d4cb200d4a5"

URI_x86_64_v2_rust-deadpool+managed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+managed-devel-0.13.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+managed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+managed-devel}"
SRC_URI[x86_64_v2_rust-deadpool+managed-devel.sha256sum] = "265d0ba39c3cb9d76b4f9089f55f7cdb3663b6dfcfa68f7a7cdfea0fa8bffa32"

URI_x86_64_v2_rust-deadpool+rt_smol_2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+rt_smol_2-devel-0.13.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+rt_smol_2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+rt_smol_2-devel}"
SRC_URI[x86_64_v2_rust-deadpool+rt_smol_2-devel.sha256sum] = "0209e73cc8c0180e946aa21808d73e8c78965417e569d0e887a1a1d5b297c7f3"

URI_x86_64_v2_rust-deadpool+rt_tokio_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+rt_tokio_1-devel-0.13.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+rt_tokio_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+rt_tokio_1-devel}"
SRC_URI[x86_64_v2_rust-deadpool+rt_tokio_1-devel.sha256sum] = "b33bf8d796285839f8f06e644d799c1255b0b71e41ee41ea7f4585f780ea5f10"

URI_x86_64_v2_rust-deadpool+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+serde-devel-0.13.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+serde-devel}"
SRC_URI[x86_64_v2_rust-deadpool+serde-devel.sha256sum] = "a706f45d90b1ffb4ac27c7386108320349c12048b996d69bddfd61a490bfed88"

URI_x86_64_v2_rust-deadpool+unmanaged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+unmanaged-devel-0.13.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+unmanaged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+unmanaged-devel}"
SRC_URI[x86_64_v2_rust-deadpool+unmanaged-devel.sha256sum] = "6a162622f578be7afbf9e9606576ced84530a404d80eb01820d3578b471096f1"

URI_x86_64_v2_rust-deadpool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-devel-0.13.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-devel}"
SRC_URI[x86_64_v2_rust-deadpool-devel.sha256sum] = "b16d5a82cc19abe358ba5c00a19d82a7bb36f8bf995078be5548889fbd8330e9"

URI_aarch64_rust-deadpool+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+default-devel-0.13.0-2.el10_2.noarch.rpm;name=aarch64_rust-deadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+default-devel}"
SRC_URI[aarch64_rust-deadpool+default-devel.sha256sum] = "109d5e560ddebfbea96df00505b83cf754b3b600158ea76399bb3fd352777a54"

URI_aarch64_rust-deadpool+managed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+managed-devel-0.13.0-2.el10_2.noarch.rpm;name=aarch64_rust-deadpool+managed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+managed-devel}"
SRC_URI[aarch64_rust-deadpool+managed-devel.sha256sum] = "4f8cce09758bf579584a08604c53827be5c37d633a6664a68769c08354b6f975"

URI_aarch64_rust-deadpool+rt_smol_2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+rt_smol_2-devel-0.13.0-2.el10_2.noarch.rpm;name=aarch64_rust-deadpool+rt_smol_2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+rt_smol_2-devel}"
SRC_URI[aarch64_rust-deadpool+rt_smol_2-devel.sha256sum] = "9d62477a95bdc61d35fa2377e3aa274e3ec04a1a89f0badd1a2f611a56b0a5a8"

URI_aarch64_rust-deadpool+rt_tokio_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+rt_tokio_1-devel-0.13.0-2.el10_2.noarch.rpm;name=aarch64_rust-deadpool+rt_tokio_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+rt_tokio_1-devel}"
SRC_URI[aarch64_rust-deadpool+rt_tokio_1-devel.sha256sum] = "ee93eb48da228a1e23fe202ed0cda5ca595ebaf2f42ffb5d1fe75405350509bc"

URI_aarch64_rust-deadpool+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+serde-devel-0.13.0-2.el10_2.noarch.rpm;name=aarch64_rust-deadpool+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+serde-devel}"
SRC_URI[aarch64_rust-deadpool+serde-devel.sha256sum] = "7777ff84ef3117e5c625bbab9baa0d7792b07f873b36c62a68ec6abbb778d15d"

URI_aarch64_rust-deadpool+unmanaged-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+unmanaged-devel-0.13.0-2.el10_2.noarch.rpm;name=aarch64_rust-deadpool+unmanaged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+unmanaged-devel}"
SRC_URI[aarch64_rust-deadpool+unmanaged-devel.sha256sum] = "bc48a1dea92702ea984de80610b65eda7797585eb5185e8bbc9ca55cdf02ee4a"

URI_aarch64_rust-deadpool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-devel-0.13.0-2.el10_2.noarch.rpm;name=aarch64_rust-deadpool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-devel}"
SRC_URI[aarch64_rust-deadpool-devel.sha256sum] = "a95c9aa0ba843057e043e88cfe05a255a858b5c61333f24ec19e3db4d250bd31"

RDEPENDS:rust-deadpool+default-devel = " \
 cargo \
 rust-deadpool+managed-devel \
 rust-deadpool+unmanaged-devel \
 rust-deadpool-devel \
 "
RDEPENDS:rust-deadpool+managed-devel = " \
 cargo \
 rust-deadpool-devel \
 "
RDEPENDS:rust-deadpool+rt_smol_2-devel = " \
 cargo \
 rust-deadpool-devel \
 rust-deadpool-runtime+smol_2-devel \
 "
RDEPENDS:rust-deadpool+rt_tokio_1-devel = " \
 cargo \
 rust-deadpool-devel \
 rust-deadpool-runtime+tokio_1-devel \
 "
RDEPENDS:rust-deadpool+serde-devel = " \
 cargo \
 rust-deadpool-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-deadpool+unmanaged-devel = " \
 cargo \
 rust-deadpool-devel \
 "
RDEPENDS:rust-deadpool-devel = " \
 cargo \
 rust \
 rust-deadpool-runtime+default-devel \
 rust-num_cpus+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
