# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postfix"
PE = "2"
PV = "3.8.5"
PR = "8.el10"
PACKAGES = " \
 postfix \
 postfix-cdb \
 postfix-ldap \
 postfix-lmdb \
 postfix-mysql \
 postfix-pcre \
 postfix-perl-scripts \
 postfix-pgsql \
 postfix-sqlite \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postfix-3.8.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3f2f446c30894df638bfca612c331d5bd55a398ef3b164ab388e37fee49a4f6"

URI_x86_64_v2_postfix = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-3.8.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_postfix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix}"
SRC_URI[x86_64_v2_postfix.sha256sum] = "516306df2a76cbed1e0d741a48dc013d69dbc59bf1fed110829e80192cb6e3f0"
RPROVIDES:postfix:append:x86_64_v2 = " virtual//usr/bin/mailq virtual//usr/sbin/sendmail virtual/smtpdaemon"

URI_x86_64_v2_postfix-cdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-cdb-3.8.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_postfix-cdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-cdb}"
SRC_URI[x86_64_v2_postfix-cdb.sha256sum] = "1152f8ee8a352b5e6c7e88c8c5a77ac1945fccb4ee0152f3989859238052758c"

URI_x86_64_v2_postfix-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-ldap-3.8.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_postfix-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-ldap}"
SRC_URI[x86_64_v2_postfix-ldap.sha256sum] = "338393cca45e6be02fde0b13c73f34bd3bbb3024f7979fcbfe42f5f1f47f7df2"

URI_x86_64_v2_postfix-lmdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-lmdb-3.8.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_postfix-lmdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-lmdb}"
SRC_URI[x86_64_v2_postfix-lmdb.sha256sum] = "0fdd172deef48393f572ecc7c1025b1fd6b61ded54f4e02cc7c1ca150ada487e"

URI_x86_64_v2_postfix-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-mysql-3.8.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_postfix-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-mysql}"
SRC_URI[x86_64_v2_postfix-mysql.sha256sum] = "2d5ddadb58b825d62c8a7f6c4afb38a2003a30fe70ab231ddd5dd670f5d0c970"

URI_x86_64_v2_postfix-pcre = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-pcre-3.8.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_postfix-pcre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-pcre}"
SRC_URI[x86_64_v2_postfix-pcre.sha256sum] = "69e09e4378412798265068bcbbaeffede2f5ec80bb57c804fed71caf03425df8"

URI_x86_64_v2_postfix-perl-scripts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-perl-scripts-3.8.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_postfix-perl-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-perl-scripts}"
SRC_URI[x86_64_v2_postfix-perl-scripts.sha256sum] = "64452fae3ce5786ee2f0406ed650d4e25aac1e6c9a4999d06b444699abbb792b"

URI_x86_64_v2_postfix-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-pgsql-3.8.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_postfix-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-pgsql}"
SRC_URI[x86_64_v2_postfix-pgsql.sha256sum] = "949731055153ba24f4020ab0d3007282a461926ff19da7cc0546772e2ad05942"

URI_x86_64_v2_postfix-sqlite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postfix-sqlite-3.8.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_postfix-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfix-sqlite}"
SRC_URI[x86_64_v2_postfix-sqlite.sha256sum] = "8cafa9821751e993ef0404080b19109802b94885f97f9fd88c32e4064c7ae7ec"

URI_aarch64_postfix = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-3.8.5-8.el10.aarch64.rpm;name=aarch64_postfix;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix}"
SRC_URI[aarch64_postfix.sha256sum] = "abe43aad94cc6b116ea9bdfb1fdbee90df6946bbb334161e52ecfd2f047a52d9"
RPROVIDES:postfix:append:aarch64 = " virtual//usr/bin/mailq virtual//usr/sbin/sendmail virtual/smtpdaemon"

URI_aarch64_postfix-cdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-cdb-3.8.5-8.el10.aarch64.rpm;name=aarch64_postfix-cdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-cdb}"
SRC_URI[aarch64_postfix-cdb.sha256sum] = "bb3ddb02072e6c2078fad02acc16013346b49199e7f2d35e40e35862e362d211"

URI_aarch64_postfix-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-ldap-3.8.5-8.el10.aarch64.rpm;name=aarch64_postfix-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-ldap}"
SRC_URI[aarch64_postfix-ldap.sha256sum] = "8fbff1f322b1756260ca53baac098f0c0da1045c53519008157c3a6c2789ffed"

URI_aarch64_postfix-lmdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-lmdb-3.8.5-8.el10.aarch64.rpm;name=aarch64_postfix-lmdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-lmdb}"
SRC_URI[aarch64_postfix-lmdb.sha256sum] = "c075c749ecb870d051014a025777720d51dbb4607d592779a48670130e144600"

URI_aarch64_postfix-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-mysql-3.8.5-8.el10.aarch64.rpm;name=aarch64_postfix-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-mysql}"
SRC_URI[aarch64_postfix-mysql.sha256sum] = "104aac3dfe79cd9cea84d2c6349d523ecfa5cd56bb7c2ae01fede6ab47dc01f2"

URI_aarch64_postfix-pcre = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-pcre-3.8.5-8.el10.aarch64.rpm;name=aarch64_postfix-pcre;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-pcre}"
SRC_URI[aarch64_postfix-pcre.sha256sum] = "d673ec3e3e7176e569bf906f0e559dd1b82351a00aa4ac7b3ee6e62d8d342d4d"

URI_aarch64_postfix-perl-scripts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-perl-scripts-3.8.5-8.el10.aarch64.rpm;name=aarch64_postfix-perl-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-perl-scripts}"
SRC_URI[aarch64_postfix-perl-scripts.sha256sum] = "b9eaf69ea8d958572a46d83d7f14d7a33dd80cae7386c9e15b4dac66341c4ee1"

URI_aarch64_postfix-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-pgsql-3.8.5-8.el10.aarch64.rpm;name=aarch64_postfix-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-pgsql}"
SRC_URI[aarch64_postfix-pgsql.sha256sum] = "2bb64ee9c7508598fbbf27ab0360ac421e7748a215bb10cbaf60be66eded4d68"

URI_aarch64_postfix-sqlite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postfix-sqlite-3.8.5-8.el10.aarch64.rpm;name=aarch64_postfix-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfix-sqlite}"
SRC_URI[aarch64_postfix-sqlite.sha256sum] = "7206b8f5a7350dc757f79dfffb284e73c5a4684c99dec47ab32b74f86cd1ebbd"

RDEPENDS:postfix = " \
 alternatives \
 bash \
 cyrus-sasl-lib \
 diffutils \
 findutils \
 glibc \
 hostname \
 libicu \
 openssl \
 openssl-libs \
 policycoreutils \
 postfix-lmdb \
 systemd \
 "
RDEPENDS:postfix-cdb = " \
 glibc \
 postfix \
 tinycdb \
 "
RDEPENDS:postfix-ldap = " \
 glibc \
 openldap \
 postfix \
 "
RDEPENDS:postfix-lmdb = " \
 glibc \
 lmdb-libs \
 postfix \
 "
RDEPENDS:postfix-mysql = " \
 glibc \
 mariadb-connector-c \
 postfix \
 "
RDEPENDS:postfix-pcre = " \
 glibc \
 pcre2 \
 postfix \
 "
RDEPENDS:postfix-perl-scripts = " \
 perl-Date-Calc \
 perl-File-Find \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-interpreter \
 perl-libs \
 perl-locale \
 perl-vars \
 postfix \
 "
RDEPENDS:postfix-pgsql = " \
 glibc \
 libpq \
 postfix \
 "
RDEPENDS:postfix-sqlite = " \
 glibc \
 postfix \
 sqlite-libs \
 "
