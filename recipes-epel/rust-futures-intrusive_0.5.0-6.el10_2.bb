# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-intrusive"
PV = "0.5.0"
PR = "6.el10_2"
PACKAGES = " \
 rust-futures-intrusive+alloc-devel \
 rust-futures-intrusive+default-devel \
 rust-futures-intrusive+parking_lot-devel \
 rust-futures-intrusive+std-devel \
 rust-futures-intrusive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-intrusive-0.5.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14cb8f67a1fe42b75aa26b97a98d23bc83693601cb0a7f763e23bd4b6d329df5"

URI_x86_64_v2_rust-futures-intrusive+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-intrusive+alloc-devel-0.5.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-intrusive+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-intrusive+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-intrusive+alloc-devel.sha256sum] = "626047edf026b9c603b36ccbad0f103dbd6c47bbff4503582e7cb2ddd0dc4196"

URI_x86_64_v2_rust-futures-intrusive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-intrusive+default-devel-0.5.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-intrusive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-intrusive+default-devel}"
SRC_URI[x86_64_v2_rust-futures-intrusive+default-devel.sha256sum] = "28e4de32f976b2c903eb0d91e3a52ed499af9d7670dab2e347553e8855406cb9"

URI_x86_64_v2_rust-futures-intrusive+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-intrusive+parking_lot-devel-0.5.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-intrusive+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-intrusive+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-futures-intrusive+parking_lot-devel.sha256sum] = "54ce8405435c85a3bfac8a2d9477770ac39ea060b3b42c0de16e1d465e6c89d2"

URI_x86_64_v2_rust-futures-intrusive+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-intrusive+std-devel-0.5.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-intrusive+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-intrusive+std-devel}"
SRC_URI[x86_64_v2_rust-futures-intrusive+std-devel.sha256sum] = "c2f21ea11cf02121680501a5282e4eb13c252996c5dbfc36d8be58811dda18f2"

URI_x86_64_v2_rust-futures-intrusive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-intrusive-devel-0.5.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-intrusive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-intrusive-devel}"
SRC_URI[x86_64_v2_rust-futures-intrusive-devel.sha256sum] = "feb833adb2a2cabc8dbb443d6258f899d6f7657139969e6cf6b6e19072b03ec6"

URI_aarch64_rust-futures-intrusive+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-intrusive+alloc-devel-0.5.0-6.el10_2.noarch.rpm;name=aarch64_rust-futures-intrusive+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-intrusive+alloc-devel}"
SRC_URI[aarch64_rust-futures-intrusive+alloc-devel.sha256sum] = "ece9fe47b0099a8607b105affa481657a0a08ffb29dcc86e0241945262d42bd9"

URI_aarch64_rust-futures-intrusive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-intrusive+default-devel-0.5.0-6.el10_2.noarch.rpm;name=aarch64_rust-futures-intrusive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-intrusive+default-devel}"
SRC_URI[aarch64_rust-futures-intrusive+default-devel.sha256sum] = "5efd77cd4ffa48949a743a79af3c7599db13c2cd03f6791cd72f05f582385728"

URI_aarch64_rust-futures-intrusive+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-intrusive+parking_lot-devel-0.5.0-6.el10_2.noarch.rpm;name=aarch64_rust-futures-intrusive+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-intrusive+parking_lot-devel}"
SRC_URI[aarch64_rust-futures-intrusive+parking_lot-devel.sha256sum] = "be7d73eb242bdce29eac2c4e02dc4efdb7500c2a8761553da74bcdf6bf9926bf"

URI_aarch64_rust-futures-intrusive+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-intrusive+std-devel-0.5.0-6.el10_2.noarch.rpm;name=aarch64_rust-futures-intrusive+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-intrusive+std-devel}"
SRC_URI[aarch64_rust-futures-intrusive+std-devel.sha256sum] = "f73ca32feb073a39974856a6d1863c56e5deb67da5caeee76b4e1a9c2fbd9c5d"

URI_aarch64_rust-futures-intrusive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-intrusive-devel-0.5.0-6.el10_2.noarch.rpm;name=aarch64_rust-futures-intrusive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-intrusive-devel}"
SRC_URI[aarch64_rust-futures-intrusive-devel.sha256sum] = "dbf7af194912ab47bfc2b7f27b2bd091b4eda00311de970b0411794243ea4a98"

RDEPENDS:rust-futures-intrusive+alloc-devel = " \
 cargo \
 rust-futures-core+alloc-devel \
 rust-futures-intrusive-devel \
 "
RDEPENDS:rust-futures-intrusive+default-devel = " \
 cargo \
 rust-futures-intrusive+std-devel \
 rust-futures-intrusive-devel \
 "
RDEPENDS:rust-futures-intrusive+parking_lot-devel = " \
 cargo \
 rust-futures-intrusive-devel \
 rust-parking_lot+default-devel \
 "
RDEPENDS:rust-futures-intrusive+std-devel = " \
 cargo \
 rust-futures-intrusive+alloc-devel \
 rust-futures-intrusive+parking_lot-devel \
 rust-futures-intrusive-devel \
 "
RDEPENDS:rust-futures-intrusive-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-lock_api+default-devel \
 "
