# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dav1d"
PV = "1.5.4"
PR = "1.el10_3"
PACKAGES = " \
 dav1d \
 libdav1d \
 libdav1d-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dav1d-1.5.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2c8d45ec02cbef345f3a565c5713b1cfa22e85b8893247baae4a34f92fb4553e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dav1d-1.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dav1d;unpack=0"
SRC_URI[x86_64_v2_dav1d.sha256sum] = "af3b8e12d72b1db6f83b14b6f378bee41de3c6580ccf97d9a20462ab56a8c03c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdav1d-1.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdav1d;unpack=0"
SRC_URI[x86_64_v2_libdav1d.sha256sum] = "fa584e2dc91f670a82c4fef97fdf85cdf8843fabb2c5538658e6aa2e1e916dc2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdav1d-devel-1.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdav1d-devel;unpack=0"
SRC_URI[x86_64_v2_libdav1d-devel.sha256sum] = "ce0118c0df2d0b96dce89faac6a85d5b67bdbc23ec840bb9c360bb3e1515607b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dav1d-1.5.4-1.el10_3.aarch64.rpm;name=aarch64_dav1d;unpack=0"
SRC_URI[aarch64_dav1d.sha256sum] = "0353dab5262e9a09ca39da69b41d6e5d2a5f8a70045b8cdf3b2ce5566f7620d0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdav1d-1.5.4-1.el10_3.aarch64.rpm;name=aarch64_libdav1d;unpack=0"
SRC_URI[aarch64_libdav1d.sha256sum] = "b07eaf351cd02fce603f3a0fa093f9fb061324ed1a33b0ac2acb885be7755fc7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdav1d-devel-1.5.4-1.el10_3.aarch64.rpm;name=aarch64_libdav1d-devel;unpack=0"
SRC_URI[aarch64_libdav1d-devel.sha256sum] = "18ab6195c45d43ff3097d1696bd4152217812b24202490178c2b0f8e979aae36"

RDEPENDS:dav1d = " \
 glibc \
 libdav1d \
 "
RDEPENDS:libdav1d = " \
 glibc \
 "
RDEPENDS:libdav1d-devel = " \
 libdav1d \
 pkgconf-pkg-config \
 "
