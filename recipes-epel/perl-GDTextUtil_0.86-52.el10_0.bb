# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GDTextUtil"
PV = "0.86"
PR = "52.el10_0"
PACKAGES = " \
 perl-GDTextUtil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-GDTextUtil-0.86-52.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "589d7406cdd4a8debed99c530c75d8459d7ef972a84c34953c5da0d61bb59242"

URI_x86_64_v2_perl-GDTextUtil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GDTextUtil-0.86-52.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GDTextUtil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GDTextUtil}"
SRC_URI[x86_64_v2_perl-GDTextUtil.sha256sum] = "6b119698ccd06f3cd94919952a6949f3473a3c5708aadc43a94d3024c612dfb9"

URI_aarch64_perl-GDTextUtil = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GDTextUtil-0.86-52.el10_0.noarch.rpm;name=aarch64_perl-GDTextUtil;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GDTextUtil}"
SRC_URI[aarch64_perl-GDTextUtil.sha256sum] = "2765fbdcf5d0d23981e2f76e30dccad277cb1291c10da10a19c01fd2f2c2aa1e"

RDEPENDS:perl-GDTextUtil = " \
 perl-Carp \
 perl-GD \
 perl-GDTextUtil \
 perl-POSIX \
 perl-PathTools \
 perl-libs \
 perl-vars \
 "
