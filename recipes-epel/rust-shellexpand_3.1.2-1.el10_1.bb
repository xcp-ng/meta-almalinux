# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-shellexpand"
PV = "3.1.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-shellexpand+base-0-devel \
 rust-shellexpand+bstr-devel \
 rust-shellexpand+default-devel \
 rust-shellexpand+dirs-devel \
 rust-shellexpand+full-devel \
 rust-shellexpand+full-msrv-1-31-devel \
 rust-shellexpand+full-msrv-1-51-devel \
 rust-shellexpand+os_str_bytes-devel \
 rust-shellexpand+path-devel \
 rust-shellexpand+tilde-devel \
 rust-shellexpand-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-shellexpand-3.1.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "010463484c0c6bde6e28eb486a25d6d7330a6e18136f41d1344585ec14e8e8f0"

URI_x86_64_v2_rust-shellexpand+base-0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+base-0-devel-3.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+base-0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+base-0-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+base-0-devel.sha256sum] = "30453a287540560bb5458e9f697794a3bac8691d578ce46189a9781f097bcb02"

URI_x86_64_v2_rust-shellexpand+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+bstr-devel-3.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+bstr-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+bstr-devel.sha256sum] = "fb7ff20533160631c01a0d5bae53c67b12c8db1fcff6cf4ed79f0e4dcb96144f"

URI_x86_64_v2_rust-shellexpand+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+default-devel-3.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+default-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+default-devel.sha256sum] = "a92f637cbd32e786211c6fe9a7c3fd98b704af3ee42ae0c58e5666f5673ebe95"

URI_x86_64_v2_rust-shellexpand+dirs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+dirs-devel-3.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+dirs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+dirs-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+dirs-devel.sha256sum] = "25f3a5883b2bfc450f49679686813fa052bee4b5cf3f3a0d110135a79e86241b"

URI_x86_64_v2_rust-shellexpand+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+full-devel-3.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+full-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+full-devel.sha256sum] = "3793cca9029706e77102f3cf3d466a46fd3338e455f4b6b604e26f8da6c4de60"

URI_x86_64_v2_rust-shellexpand+full-msrv-1-31-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+full-msrv-1-31-devel-3.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+full-msrv-1-31-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+full-msrv-1-31-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+full-msrv-1-31-devel.sha256sum] = "135e4d633108a092b57dcaefb7b26f492ed64c736bc70b9d55a013a8806f88e9"

URI_x86_64_v2_rust-shellexpand+full-msrv-1-51-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+full-msrv-1-51-devel-3.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+full-msrv-1-51-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+full-msrv-1-51-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+full-msrv-1-51-devel.sha256sum] = "96060542e97ccea033c2a32a9e3d285bf34aefa8be77263624f545d192230af9"

URI_x86_64_v2_rust-shellexpand+os_str_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+os_str_bytes-devel-3.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+os_str_bytes-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+os_str_bytes-devel.sha256sum] = "6aa39fc4ac5e1457b8c6200c0c0800c165457c94c22bfd34c8baeb44328a7852"

URI_x86_64_v2_rust-shellexpand+path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+path-devel-3.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+path-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+path-devel.sha256sum] = "a89051a3f46d46e0b33c1dd3e297cebf67b4b88636e8694f4d4d1c75f5ae7876"

URI_x86_64_v2_rust-shellexpand+tilde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+tilde-devel-3.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+tilde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+tilde-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+tilde-devel.sha256sum] = "d0098f49ee46f7f1388199cb3fc7808277d4be0eceeeaf13e36170f643b22c5c"

URI_x86_64_v2_rust-shellexpand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand-devel-3.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand-devel}"
SRC_URI[x86_64_v2_rust-shellexpand-devel.sha256sum] = "76a560249483d9b5d26bba6fe1950ceee5a5d362b7f9feb3db1fe83c2ff53ef8"

URI_aarch64_rust-shellexpand+base-0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+base-0-devel-3.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-shellexpand+base-0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+base-0-devel}"
SRC_URI[aarch64_rust-shellexpand+base-0-devel.sha256sum] = "e28c6355449eefdb266ffd3a85b2135e9defc993e77de7fa586dc737f9be04c1"

URI_aarch64_rust-shellexpand+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+bstr-devel-3.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-shellexpand+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+bstr-devel}"
SRC_URI[aarch64_rust-shellexpand+bstr-devel.sha256sum] = "ce7c1a5e03a4729a80abef27633b0b420e2a12d5d1424c4fc7e4708143c6775a"

URI_aarch64_rust-shellexpand+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+default-devel-3.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-shellexpand+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+default-devel}"
SRC_URI[aarch64_rust-shellexpand+default-devel.sha256sum] = "7ce7655106c695af82d41b33f42e6b1d57417418f58f152bccd8fb53b6918c17"

URI_aarch64_rust-shellexpand+dirs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+dirs-devel-3.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-shellexpand+dirs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+dirs-devel}"
SRC_URI[aarch64_rust-shellexpand+dirs-devel.sha256sum] = "0b53afe90198585fd480307a4c2480dc8729f1dd0f6d59f0de7acffe27ea0193"

URI_aarch64_rust-shellexpand+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+full-devel-3.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-shellexpand+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+full-devel}"
SRC_URI[aarch64_rust-shellexpand+full-devel.sha256sum] = "39091cfe8f67cad4cc8d8e5d8862e47eb64d8a8c27e3ebc195775c10589b4858"

URI_aarch64_rust-shellexpand+full-msrv-1-31-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+full-msrv-1-31-devel-3.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-shellexpand+full-msrv-1-31-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+full-msrv-1-31-devel}"
SRC_URI[aarch64_rust-shellexpand+full-msrv-1-31-devel.sha256sum] = "0ce2a0474e4670c8612d5cc076df68fd57efe53a9f5b4babcad94d1ddecaa388"

URI_aarch64_rust-shellexpand+full-msrv-1-51-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+full-msrv-1-51-devel-3.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-shellexpand+full-msrv-1-51-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+full-msrv-1-51-devel}"
SRC_URI[aarch64_rust-shellexpand+full-msrv-1-51-devel.sha256sum] = "6491a27cb33251055ed2b0800b4082d222f01a4d148a2e6b7401f3e8dcf8aa24"

URI_aarch64_rust-shellexpand+os_str_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+os_str_bytes-devel-3.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-shellexpand+os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+os_str_bytes-devel}"
SRC_URI[aarch64_rust-shellexpand+os_str_bytes-devel.sha256sum] = "b31c1c1d05f0a8c07798703cb9a5b791b590f207787d2da1399acace96c6fd4b"

URI_aarch64_rust-shellexpand+path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+path-devel-3.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-shellexpand+path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+path-devel}"
SRC_URI[aarch64_rust-shellexpand+path-devel.sha256sum] = "be8e4c80f8af9b370b2420f5971878ee018ae50ad8c7553e43a31b699b8e1b87"

URI_aarch64_rust-shellexpand+tilde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+tilde-devel-3.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-shellexpand+tilde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+tilde-devel}"
SRC_URI[aarch64_rust-shellexpand+tilde-devel.sha256sum] = "38c5bbab0016ba1afd0f93eeebd2c450051ffa7888b19ed588d3e94043aad0c1"

URI_aarch64_rust-shellexpand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand-devel-3.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-shellexpand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand-devel}"
SRC_URI[aarch64_rust-shellexpand-devel.sha256sum] = "86760411fddfa9bdb0054a977883e3231cb84bc3ab8b37c8cdf5d841f8dddac9"

RDEPENDS:rust-shellexpand+base-0-devel = " \
 cargo \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+bstr-devel = " \
 cargo \
 rust-bstr+default-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+default-devel = " \
 cargo \
 rust-shellexpand+base-0-devel \
 rust-shellexpand+tilde-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+dirs-devel = " \
 cargo \
 rust-dirs+default-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+full-devel = " \
 cargo \
 rust-shellexpand+full-msrv-1-51-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+full-msrv-1-31-devel = " \
 cargo \
 rust-shellexpand+base-0-devel \
 rust-shellexpand+tilde-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+full-msrv-1-51-devel = " \
 cargo \
 rust-shellexpand+full-msrv-1-31-devel \
 rust-shellexpand+path-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+os_str_bytes-devel = " \
 cargo \
 rust-os_str_bytes6+default-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+path-devel = " \
 cargo \
 rust-shellexpand+bstr-devel \
 rust-shellexpand+os_str_bytes-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+tilde-devel = " \
 cargo \
 rust-shellexpand+dirs-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand-devel = " \
 bash \
 cargo \
 rust \
 "
