# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kreversi"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kreversi \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kreversi-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0c2372f0137cb6f3cd59ddebbd787c18d7bda02722eaa9965a0dbfb763c11fc7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kreversi-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kreversi;unpack=0"
SRC_URI[x86_64_v2_kreversi.sha256sum] = "b3747e9cfd21795be1f2c231f12d3c3accb013f35a56c6d9384bdcd226455db3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kreversi-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kreversi;unpack=0"
SRC_URI[aarch64_kreversi.sha256sum] = "80bd7798c3ccd1f6ac101ce8d3c7b35eb05e23437a9feb78fefb4560095b0f58"

RDEPENDS:kreversi = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
