# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-betamax"
PV = "0.9.0"
PR = "3.el10_0"
PACKAGES = " \
 python3-betamax \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-betamax-0.9.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32f5b3c927e358cd7ed1f565d2e6501174bb91a787191f3dac7842978545c071"

URI_x86_64_v2_python3-betamax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-betamax-0.9.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-betamax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-betamax}"
SRC_URI[x86_64_v2_python3-betamax.sha256sum] = "578f739848ca104a5f934bf152291acd6b7a4e8a625b4fc37b1f20b702ad8594"

URI_aarch64_python3-betamax = "${EPEL_MIRROR}/aarch64/Packages/p/python3-betamax-0.9.0-3.el10_0.noarch.rpm;name=aarch64_python3-betamax;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-betamax}"
SRC_URI[aarch64_python3-betamax.sha256sum] = "0bf846dd59063c3e64215a835efc3e30f5ddc00dd8b039e12cb29c5387e68c67"

RDEPENDS:python3-betamax = " \
 python3 \
 python3-requests \
 "
