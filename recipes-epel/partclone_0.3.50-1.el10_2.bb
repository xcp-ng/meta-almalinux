# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "partclone"
PV = "0.3.50"
PR = "1.el10_2"
PACKAGES = " \
 partclone \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/partclone-0.3.50-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e7be6fd08c7f28e9ef9416211ad82815fad5f55a7bbb8c7d0ed27ba97e8a0d86"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/partclone-0.3.50-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_partclone;unpack=0"
SRC_URI[x86_64_v2_partclone.sha256sum] = "35962dd343a57f8535b933838fab80a590156598d35df87fc6c1f352a149ea4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/partclone-0.3.50-1.el10_2.aarch64.rpm;name=aarch64_partclone;unpack=0"
SRC_URI[aarch64_partclone.sha256sum] = "32d89aa3260c48ab28be7409b21cc79d5b94f967553f1dffec35f1392cba3e28"

RDEPENDS:partclone = " \
 e2fsprogs-libs \
 fuse3-libs \
 glibc \
 libblkid \
 libuuid \
 ncurses-libs \
 ntfs-3g-libs \
 openssl-libs \
 userspace-rcu \
 xxhash-libs \
 "
