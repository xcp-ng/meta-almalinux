# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-runtime"
PV = "7.2.1"
PR = "3.el10_3"
PACKAGES:x86_64_v2 = " \
 kfdtest \
 rocm-runtime \
 rocm-runtime-devel \
 rocm-runtime-static \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-runtime-7.2.1-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bf51dcf7aeba9b8d599e15b8e8e38e780187f42e3cd20d69e7260471df6993c"

URI_x86_64_v2_kfdtest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kfdtest-7.2.1-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kfdtest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kfdtest}"
SRC_URI[x86_64_v2_kfdtest.sha256sum] = "9e567eb73764b66cf566d49dfca5cece84a68f45dc5e7a447211976a6c29cdae"

URI_x86_64_v2_rocm-runtime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-runtime-7.2.1-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-runtime}"
SRC_URI[x86_64_v2_rocm-runtime.sha256sum] = "39c74543ffe85ab676d1918baa283019cdf2a8484fa74b0879a85173c58a32ab"

URI_x86_64_v2_rocm-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-runtime-devel-7.2.1-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-runtime-devel}"
SRC_URI[x86_64_v2_rocm-runtime-devel.sha256sum] = "57954ff12192a6a642b56c74f0e7415f8b891cc248a6aa8f65d990f9ba2ef8b7"

URI_x86_64_v2_rocm-runtime-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-runtime-static-7.2.1-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-runtime-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-runtime-static}"
SRC_URI[x86_64_v2_rocm-runtime-static.sha256sum] = "a06a18010e9d3b1dc98a7dcc95c848dea9573c4e08f895718757fe6cc13248c3"

RDEPENDS:kfdtest = " \
 bash \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libzstd \
 numactl-libs \
 rocm-filesystem \
 rocm-runtime \
 rocm-smi \
 zlib-ng-compat \
 "
RDEPENDS:rocm-runtime = " \
 elfutils-libelf \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 numactl-libs \
 rocm-filesystem \
 "
RDEPENDS:rocm-runtime-devel = " \
 cmake-filesystem \
 rocm-filesystem \
 rocm-runtime \
 "
RDEPENDS:rocm-runtime-static = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 rocm-runtime-devel \
 "
