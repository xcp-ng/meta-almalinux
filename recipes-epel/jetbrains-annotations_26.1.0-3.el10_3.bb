# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jetbrains-annotations"
PV = "26.1.0"
PR = "3.el10_3"
PACKAGES = " \
 jetbrains-annotations \
 jetbrains-annotations-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jetbrains-annotations-26.1.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa1e1594ce5065da38cfd7181b667c19ae1e2944f2df270ddb153d6534a899d5"

URI_x86_64_v2_jetbrains-annotations = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jetbrains-annotations-26.1.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_jetbrains-annotations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jetbrains-annotations}"
SRC_URI[x86_64_v2_jetbrains-annotations.sha256sum] = "ba8009c752ccddd44a64e136f2b4af764c5ef418ac1a628765e4c5c4ad988dee"

URI_x86_64_v2_jetbrains-annotations-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jetbrains-annotations-javadoc-26.1.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_jetbrains-annotations-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jetbrains-annotations-javadoc}"
SRC_URI[x86_64_v2_jetbrains-annotations-javadoc.sha256sum] = "73c298f3333bf45dc86e8150c21e6d38ae3f86d6a64e81bd0b2e94a58e4c90fc"

URI_aarch64_jetbrains-annotations = "${EPEL_MIRROR}/aarch64/Packages/j/jetbrains-annotations-26.1.0-3.el10_3.noarch.rpm;name=aarch64_jetbrains-annotations;unpack=0"
SRC_URI:append = " ${URI_aarch64_jetbrains-annotations}"
SRC_URI[aarch64_jetbrains-annotations.sha256sum] = "84855647fa005e791327370e7507985567bc44fa42848d929f4b8a8e4ae9de87"

URI_aarch64_jetbrains-annotations-javadoc = "${EPEL_MIRROR}/aarch64/Packages/j/jetbrains-annotations-javadoc-26.1.0-3.el10_3.noarch.rpm;name=aarch64_jetbrains-annotations-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jetbrains-annotations-javadoc}"
SRC_URI[aarch64_jetbrains-annotations-javadoc.sha256sum] = "6340e1b80df64788e6fd7938f30e33d4f24860ab4e418f038275c6832c99ee05"

RDEPENDS:jetbrains-annotations = " \
 javapackages-filesystem \
 "
RDEPENDS:jetbrains-annotations-javadoc = " \
 javapackages-filesystem \
 "
