# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-filetime"
PV = "0.2.26"
PR = "1.el10_0"
PACKAGES = " \
 rust-filetime+default-devel \
 rust-filetime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-filetime-0.2.26-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b13ee15fd512451b5d90f0874dd986138dc819d523ff5a344474e967c13634b4"

URI_x86_64_v2_rust-filetime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-filetime+default-devel-0.2.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-filetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-filetime+default-devel}"
SRC_URI[x86_64_v2_rust-filetime+default-devel.sha256sum] = "4f05e6fd20e00834859a651baccd10d33337359a90f7665256a48f3ce47d6d26"

URI_x86_64_v2_rust-filetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-filetime-devel-0.2.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-filetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-filetime-devel}"
SRC_URI[x86_64_v2_rust-filetime-devel.sha256sum] = "f744d3e5e26f202aab29908f9e18d354d10aee7eef4b2f7dca3f438240793d75"

URI_aarch64_rust-filetime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-filetime+default-devel-0.2.26-1.el10_0.noarch.rpm;name=aarch64_rust-filetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-filetime+default-devel}"
SRC_URI[aarch64_rust-filetime+default-devel.sha256sum] = "a656559de123610ad6a11ac3184ab5f5512217fdcd14fa2bc0f330aab33f0e27"

URI_aarch64_rust-filetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-filetime-devel-0.2.26-1.el10_0.noarch.rpm;name=aarch64_rust-filetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-filetime-devel}"
SRC_URI[aarch64_rust-filetime-devel.sha256sum] = "8496a2c07ffcd36bea5b50bb6be24f048538aa0355b4f23adb31c5c64fbd7a7a"

RDEPENDS:rust-filetime+default-devel = " \
 cargo \
 rust-filetime-devel \
 "
RDEPENDS:rust-filetime-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 "
