# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpq"
PV = "16.8"
PR = "2.el10_0"
PACKAGES = " \
 libpq \
 libpq-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libpq-16.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "025be9ffa939a639076e7994dab662117f14c5c53633c234d2792a6c8e8e8ba5"

URI_x86_64_v2_libpq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpq-16.8-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_libpq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpq}"
SRC_URI[x86_64_v2_libpq.sha256sum] = "ab25500af0c440cc9a440efbabdedbee34c7f474d38824c53622ab71e5460fa8"

URI_x86_64_v2_libpq-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpq-devel-16.8-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_libpq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpq-devel}"
SRC_URI[x86_64_v2_libpq-devel.sha256sum] = "4a3608cf21b694d98d9ba287546a043a1f2a1fc754cea25342b468ff7d0ec566"

URI_aarch64_libpq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpq-16.8-2.el10_0.aarch64.rpm;name=aarch64_libpq;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpq}"
SRC_URI[aarch64_libpq.sha256sum] = "7d23a1ba2e52203f46090aa6d2411d842d03c2fa8c9db173712263dcedb62733"

URI_aarch64_libpq-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpq-devel-16.8-2.el10_0.aarch64.rpm;name=aarch64_libpq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpq-devel}"
SRC_URI[aarch64_libpq-devel.sha256sum] = "47270e1fdfcc6c6b50c49f8397086e5687fc6305ac59b83d80ba9e0fee88e1cc"

RDEPENDS:libpq = " \
 glibc \
 krb5-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:libpq-devel = " \
 glibc \
 libpq \
 openssl-devel \
 pkgconf-pkg-config \
 "
