# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "containerd"
PV = "2.2.7"
PR = "1.el10_2"
PACKAGES = " \
 containerd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/containerd-2.2.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1bd1afc5492cefea2d2d39495feca8fb04fe1834ba14518e5268f1344cc6745b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/containerd-2.2.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_containerd;unpack=0"
SRC_URI[x86_64_v2_containerd.sha256sum] = "6e3ef8f35ce46b9feef8137341e31e6f1a52ce56d50d81a0501d1918de2d3bbf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/containerd-2.2.7-1.el10_2.aarch64.rpm;name=aarch64_containerd;unpack=0"
SRC_URI[aarch64_containerd.sha256sum] = "4e48e718aabb37918185c85e589b09370a5aa7580131839aeb82fe3af9f06e70"

RDEPENDS:containerd = " \
 bash \
 glibc \
 runc \
 "
