# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-ds"
PV = "1.5.0"
PR = "7.el10_0"
PACKAGES = " \
 php-pecl-ds \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-ds-1.5.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31d0f84e07ec3594d261dd0705cf4652cbe4a1f04099ac2ca3257550471e9e93"

URI_x86_64_v2_php-pecl-ds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-ds-1.5.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-ds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-ds}"
SRC_URI[x86_64_v2_php-pecl-ds.sha256sum] = "fc62c9c2533e5ed8c2a63520e0b10a43d01c7889a460707b30ca2b991036c4d0"

URI_aarch64_php-pecl-ds = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-ds-1.5.0-7.el10_0.aarch64.rpm;name=aarch64_php-pecl-ds;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-ds}"
SRC_URI[aarch64_php-pecl-ds.sha256sum] = "2967c57f6921e1d2f8d2cd980821b85a0f4aae3caf10e27697c7ec76b5454b6d"

RDEPENDS:php-pecl-ds = " \
 glibc \
 php-common \
 "
