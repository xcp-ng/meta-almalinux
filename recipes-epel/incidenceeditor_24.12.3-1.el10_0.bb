# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "incidenceeditor"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 incidenceeditor \
 incidenceeditor-devel \
 incidenceeditor-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/incidenceeditor-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74351d0c313bfd4e738aa54ca8ce57ae06e8d2b9c37dfcd06d08f0d0295bf7c6"

URI_x86_64_v2_incidenceeditor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/incidenceeditor-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_incidenceeditor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_incidenceeditor}"
SRC_URI[x86_64_v2_incidenceeditor.sha256sum] = "69fac08cb13912e86b37eb28dd2d887c2f30c165c2e9f7f3b59c59501e07faca"

URI_x86_64_v2_incidenceeditor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/incidenceeditor-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_incidenceeditor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_incidenceeditor-devel}"
SRC_URI[x86_64_v2_incidenceeditor-devel.sha256sum] = "4806a31e88046aa74a02e371227c53a1e8d339a1721590565ae152a677d0a32c"

URI_x86_64_v2_incidenceeditor-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/incidenceeditor-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_incidenceeditor-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_incidenceeditor-doc}"
SRC_URI[x86_64_v2_incidenceeditor-doc.sha256sum] = "2f44bb2abb791ac68906e9be88c14b6e7bc6e4ee47c4e9662013e178f63fd84c"

URI_aarch64_incidenceeditor = "${EPEL_MIRROR}/aarch64/Packages/i/incidenceeditor-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_incidenceeditor;unpack=0"
SRC_URI:append = " ${URI_aarch64_incidenceeditor}"
SRC_URI[aarch64_incidenceeditor.sha256sum] = "d19ec0f15130cd0695da49bda799d5c6f4c4ef8797f77f4dbc6ead10e841e9ac"

URI_aarch64_incidenceeditor-devel = "${EPEL_MIRROR}/aarch64/Packages/i/incidenceeditor-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_incidenceeditor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_incidenceeditor-devel}"
SRC_URI[aarch64_incidenceeditor-devel.sha256sum] = "b44bd2f4b7891f4ab8b7236d5c829a5cf7cf4cf18b86b75cd0b2094b0a858645"

URI_aarch64_incidenceeditor-doc = "${EPEL_MIRROR}/aarch64/Packages/i/incidenceeditor-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_incidenceeditor-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_incidenceeditor-doc}"
SRC_URI[aarch64_incidenceeditor-doc.sha256sum] = "52c7d25546c3130be3c9c9e564270ae0a9d183091c2675b8fcee2bb28d4f9570"

RDEPENDS:incidenceeditor = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 calendarsupport \
 eventviews \
 glibc \
 kcalutils \
 kdiagram \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kldap \
 kmime \
 kpimtextedit \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:incidenceeditor-devel = " \
 calendarsupport-devel \
 cmake-filesystem \
 eventviews-devel \
 incidenceeditor \
 kcalutils-devel \
 kf6-kcalendarcore-devel \
 kmime-devel \
 "
RDEPENDS:incidenceeditor-doc = " \
 "
