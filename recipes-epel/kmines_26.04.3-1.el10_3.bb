# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmines"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kmines \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmines-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fa4be573d46ecd8cdb19f0f71935e1f42001978ee4da47f99a56d67518473d6"

URI_x86_64_v2_kmines = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmines-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmines;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmines}"
SRC_URI[x86_64_v2_kmines.sha256sum] = "e9277bc7b0dc9a5b61bef2ca79edd91201406fd990d34b57ba62c38e2fdcd0c7"

URI_aarch64_kmines = "${EPEL_MIRROR}/aarch64/Packages/k/kmines-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmines;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmines}"
SRC_URI[aarch64_kmines.sha256sum] = "c085dd54599b4b5ab496ded50b6d95d601851201189236d27d2055df728c1095"

RDEPENDS:kmines = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
