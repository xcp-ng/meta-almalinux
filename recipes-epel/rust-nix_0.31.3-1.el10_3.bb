# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nix"
PV = "0.31.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-nix+acct-devel \
 rust-nix+aio-devel \
 rust-nix+default-devel \
 rust-nix+dir-devel \
 rust-nix+env-devel \
 rust-nix+event-devel \
 rust-nix+fanotify-devel \
 rust-nix+feature-devel \
 rust-nix+fs-devel \
 rust-nix+hostname-devel \
 rust-nix+inotify-devel \
 rust-nix+ioctl-devel \
 rust-nix+kmod-devel \
 rust-nix+memoffset-devel \
 rust-nix+mman-devel \
 rust-nix+mount-devel \
 rust-nix+mqueue-devel \
 rust-nix+net-devel \
 rust-nix+personality-devel \
 rust-nix+pin-utils-devel \
 rust-nix+poll-devel \
 rust-nix+process-devel \
 rust-nix+pthread-devel \
 rust-nix+ptrace-devel \
 rust-nix+quota-devel \
 rust-nix+reboot-devel \
 rust-nix+resource-devel \
 rust-nix+sched-devel \
 rust-nix+signal-devel \
 rust-nix+socket-devel \
 rust-nix+syslog-devel \
 rust-nix+term-devel \
 rust-nix+time-devel \
 rust-nix+ucontext-devel \
 rust-nix+uio-devel \
 rust-nix+user-devel \
 rust-nix+zerocopy-devel \
 rust-nix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nix-0.31.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33314b522370f2ed88b3c017b0483e9e403168e272892deffd9c580583652284"

URI_x86_64_v2_rust-nix+acct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+acct-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+acct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+acct-devel}"
SRC_URI[x86_64_v2_rust-nix+acct-devel.sha256sum] = "a46d6f531f0e51ac3672f13426404b5972a26b7c03b37e6b2feba13d6fcf2309"

URI_x86_64_v2_rust-nix+aio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+aio-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+aio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+aio-devel}"
SRC_URI[x86_64_v2_rust-nix+aio-devel.sha256sum] = "6ea89ec02cac6251efc409b9ff0d4cb39946bd2b1fab0bfd599a43559246e37b"

URI_x86_64_v2_rust-nix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+default-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+default-devel}"
SRC_URI[x86_64_v2_rust-nix+default-devel.sha256sum] = "e47e7a4d15484196d0073809456e98d5d77d08ba41dbc2b97beb0c42e9f3d536"

URI_x86_64_v2_rust-nix+dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+dir-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+dir-devel}"
SRC_URI[x86_64_v2_rust-nix+dir-devel.sha256sum] = "8a98affeecd8cff121ae3773961aff86f27f05afaa6bca76dfef4e9b806844f6"

URI_x86_64_v2_rust-nix+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+env-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+env-devel}"
SRC_URI[x86_64_v2_rust-nix+env-devel.sha256sum] = "a27e374dae9f1ac66dd811879cdb1fbe254aeeee418b31d3a048e21797ed0db8"

URI_x86_64_v2_rust-nix+event-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+event-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+event-devel}"
SRC_URI[x86_64_v2_rust-nix+event-devel.sha256sum] = "df84e8c62a0f97a15cede14653191d392c37e8fd711d3e0c8a674670039b26ec"

URI_x86_64_v2_rust-nix+fanotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+fanotify-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+fanotify-devel}"
SRC_URI[x86_64_v2_rust-nix+fanotify-devel.sha256sum] = "110e7a0f7595d31bd8d39745dca42be4cb6c8d96e08f3a9f11c3e64b375eae2c"

URI_x86_64_v2_rust-nix+feature-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+feature-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+feature-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+feature-devel}"
SRC_URI[x86_64_v2_rust-nix+feature-devel.sha256sum] = "b3772762368cba7e86ab2f54ff5042548f45ceb13c68f6c3d066719e9449b8aa"

URI_x86_64_v2_rust-nix+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+fs-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+fs-devel}"
SRC_URI[x86_64_v2_rust-nix+fs-devel.sha256sum] = "188e1f5289687292ab64c14e96401a6adba90d92d030ecbb3937c4d38a0efa70"

URI_x86_64_v2_rust-nix+hostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+hostname-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+hostname-devel}"
SRC_URI[x86_64_v2_rust-nix+hostname-devel.sha256sum] = "a17c886f9f975320a947133027d066b051d37c04a209432deca3b0bbc978ce5d"

URI_x86_64_v2_rust-nix+inotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+inotify-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+inotify-devel}"
SRC_URI[x86_64_v2_rust-nix+inotify-devel.sha256sum] = "da3bef0be22daf3faa13576b8a1841a8f4f7d0d4eef58504abc620daa5c05ff0"

URI_x86_64_v2_rust-nix+ioctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+ioctl-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+ioctl-devel}"
SRC_URI[x86_64_v2_rust-nix+ioctl-devel.sha256sum] = "97975cb8afb7bea4e126d0c899cb07014efeada742f7300aebf896313f441dcc"

URI_x86_64_v2_rust-nix+kmod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+kmod-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+kmod-devel}"
SRC_URI[x86_64_v2_rust-nix+kmod-devel.sha256sum] = "f90e74508c8ccc5751f1fc09b583e0891efe824e6c922b80eb6a8bcd7489a410"

URI_x86_64_v2_rust-nix+memoffset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+memoffset-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+memoffset-devel}"
SRC_URI[x86_64_v2_rust-nix+memoffset-devel.sha256sum] = "abecdb2beceef466d53cc5f90e00a1ae7988dc167f466371ae428b9e768c7435"

URI_x86_64_v2_rust-nix+mman-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+mman-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+mman-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+mman-devel}"
SRC_URI[x86_64_v2_rust-nix+mman-devel.sha256sum] = "7d42ea17fc4f1cb95bbe62b1c461bfa924e40311426fb9bfeb65bb71c385f894"

URI_x86_64_v2_rust-nix+mount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+mount-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+mount-devel}"
SRC_URI[x86_64_v2_rust-nix+mount-devel.sha256sum] = "7f965e3ab0867dddc2ac494580092e6f7b289e68bedb798810c5d28865b36297"

URI_x86_64_v2_rust-nix+mqueue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+mqueue-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+mqueue-devel}"
SRC_URI[x86_64_v2_rust-nix+mqueue-devel.sha256sum] = "59622a5b5cbdbabb36d9d1e17e3626c326331c449a253d94db688a4232dd8d19"

URI_x86_64_v2_rust-nix+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+net-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+net-devel}"
SRC_URI[x86_64_v2_rust-nix+net-devel.sha256sum] = "e5c07982778b8aec1476d69c96714a4f8bbe2614729414f8b9472bc01c32d309"

URI_x86_64_v2_rust-nix+personality-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+personality-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+personality-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+personality-devel}"
SRC_URI[x86_64_v2_rust-nix+personality-devel.sha256sum] = "af0140c0fac80d53aac9c449632787063205459304f90a21f25be785f8ac94d0"

URI_x86_64_v2_rust-nix+pin-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+pin-utils-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+pin-utils-devel}"
SRC_URI[x86_64_v2_rust-nix+pin-utils-devel.sha256sum] = "1ddded6128c8926940478eafeca24a2f20f9736ca95a3beed2b8527bb5dbbd14"

URI_x86_64_v2_rust-nix+poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+poll-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+poll-devel}"
SRC_URI[x86_64_v2_rust-nix+poll-devel.sha256sum] = "eb7a169044169fa9feb0671a1fd69901623ce4eddda61deea6c16df619db10f5"

URI_x86_64_v2_rust-nix+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+process-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+process-devel}"
SRC_URI[x86_64_v2_rust-nix+process-devel.sha256sum] = "341072b234bc7458b1cf25776117f9c83f544063263681a270fc66ccb79c3a96"

URI_x86_64_v2_rust-nix+pthread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+pthread-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+pthread-devel}"
SRC_URI[x86_64_v2_rust-nix+pthread-devel.sha256sum] = "727e7fb122127f65397ea2a8c86e648e12329d17f0a5b4d01b15659e7f850961"

URI_x86_64_v2_rust-nix+ptrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+ptrace-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+ptrace-devel}"
SRC_URI[x86_64_v2_rust-nix+ptrace-devel.sha256sum] = "91b7a9604c0aa39ea0b1d03d6327f1d94174f60507d887aa4cbda662196f174b"

URI_x86_64_v2_rust-nix+quota-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+quota-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+quota-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+quota-devel}"
SRC_URI[x86_64_v2_rust-nix+quota-devel.sha256sum] = "3ee7e487e74c5be537770da94ee070adae2714811532c7baed7625d2857b50f8"

URI_x86_64_v2_rust-nix+reboot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+reboot-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+reboot-devel}"
SRC_URI[x86_64_v2_rust-nix+reboot-devel.sha256sum] = "291b7e5693302d5a9596b18794f3a416cb97f6df02b8554c5536d25c6faa0406"

URI_x86_64_v2_rust-nix+resource-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+resource-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+resource-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+resource-devel}"
SRC_URI[x86_64_v2_rust-nix+resource-devel.sha256sum] = "bf26a32def16315328655ea67ef051621b1711f83c462ce9717653d054d3fa4e"

URI_x86_64_v2_rust-nix+sched-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+sched-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+sched-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+sched-devel}"
SRC_URI[x86_64_v2_rust-nix+sched-devel.sha256sum] = "e991be3bd24cc2396482dc0b953423e64d19734aa8c02e9ebcf0c365a31624a5"

URI_x86_64_v2_rust-nix+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+signal-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+signal-devel}"
SRC_URI[x86_64_v2_rust-nix+signal-devel.sha256sum] = "c02b4df7af91efafc05903cee80013d9e92c8599f00d75876d281eff6eef24ff"

URI_x86_64_v2_rust-nix+socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+socket-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+socket-devel}"
SRC_URI[x86_64_v2_rust-nix+socket-devel.sha256sum] = "500ac5238ed40b584b88bd6f843db1d53d91c8b481fed0ff02aaed6fa2305828"

URI_x86_64_v2_rust-nix+syslog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+syslog-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+syslog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+syslog-devel}"
SRC_URI[x86_64_v2_rust-nix+syslog-devel.sha256sum] = "f9102af2e32b7db61bce14b27b6c93ec732ee25e651c9e03119db8fbbd4b8c52"

URI_x86_64_v2_rust-nix+term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+term-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+term-devel}"
SRC_URI[x86_64_v2_rust-nix+term-devel.sha256sum] = "b0fbb6c174e820858982e6f2f261ec3f009a81fbf16f43e9ac03abce8b88e512"

URI_x86_64_v2_rust-nix+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+time-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+time-devel}"
SRC_URI[x86_64_v2_rust-nix+time-devel.sha256sum] = "eeaf032382afcf29fdfdb5c3bf73648d9f7b42577a20091343a8399575448f7d"

URI_x86_64_v2_rust-nix+ucontext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+ucontext-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+ucontext-devel}"
SRC_URI[x86_64_v2_rust-nix+ucontext-devel.sha256sum] = "86caaf23fd1969bac72afd04cc7f4dd225ef2a1a2db87e87f8454aee6ab1252f"

URI_x86_64_v2_rust-nix+uio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+uio-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+uio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+uio-devel}"
SRC_URI[x86_64_v2_rust-nix+uio-devel.sha256sum] = "c6f4a8e11b534dd5c67ac87c643a7bf7163b0960b89346ff00690eb70f2e03c5"

URI_x86_64_v2_rust-nix+user-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+user-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+user-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+user-devel}"
SRC_URI[x86_64_v2_rust-nix+user-devel.sha256sum] = "c8741c6dc23aa8bdc0e208f99c4a5779aa4c5056c7c7066eea62274b039be2f1"

URI_x86_64_v2_rust-nix+zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+zerocopy-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+zerocopy-devel}"
SRC_URI[x86_64_v2_rust-nix+zerocopy-devel.sha256sum] = "c44cb4a32c188417d3d172f622174a48d01ba6d6ee5872256c2b1c0730d0c190"

URI_x86_64_v2_rust-nix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix-devel-0.31.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix-devel}"
SRC_URI[x86_64_v2_rust-nix-devel.sha256sum] = "cb42cd7245f319a506231bfd1cc366cecfe467dcb636ff38bd2f8eee05799bed"

URI_aarch64_rust-nix+acct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+acct-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+acct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+acct-devel}"
SRC_URI[aarch64_rust-nix+acct-devel.sha256sum] = "38f2ff2859d4049d2395aba0c17de5c3c62f04ac186d038bd9aaff356003200d"

URI_aarch64_rust-nix+aio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+aio-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+aio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+aio-devel}"
SRC_URI[aarch64_rust-nix+aio-devel.sha256sum] = "5a447b2fd5f9b8e68227e13cc3b8a80ca114e1c7e8828e0cf033b048babbc265"

URI_aarch64_rust-nix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+default-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+default-devel}"
SRC_URI[aarch64_rust-nix+default-devel.sha256sum] = "1c87e399e2d719bab0d2d09a41d8f82a50a179dfde3790d10f4ea2158c434c62"

URI_aarch64_rust-nix+dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+dir-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+dir-devel}"
SRC_URI[aarch64_rust-nix+dir-devel.sha256sum] = "7bb1e55dc5ce43782ff19d75b3af7627ae687a47e8c6f54d44b815c80d6b2d37"

URI_aarch64_rust-nix+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+env-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+env-devel}"
SRC_URI[aarch64_rust-nix+env-devel.sha256sum] = "f91f6ca768b09947392293d9af01c1ad9836584d16d26c2739385072ef6dc513"

URI_aarch64_rust-nix+event-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+event-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+event-devel}"
SRC_URI[aarch64_rust-nix+event-devel.sha256sum] = "d5ab86b060b17522388bd71269b8db49072b98491f7a46f9b0519b3775e848df"

URI_aarch64_rust-nix+fanotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+fanotify-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+fanotify-devel}"
SRC_URI[aarch64_rust-nix+fanotify-devel.sha256sum] = "079020d6859e2a61f2cff31ae297485a7a959af5df880ee94b4e88f5cd3ff858"

URI_aarch64_rust-nix+feature-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+feature-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+feature-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+feature-devel}"
SRC_URI[aarch64_rust-nix+feature-devel.sha256sum] = "5d58dcf7679618f971d75507f4144c2fb5e3c4da30e845f3aa494b94bbe7ee60"

URI_aarch64_rust-nix+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+fs-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+fs-devel}"
SRC_URI[aarch64_rust-nix+fs-devel.sha256sum] = "a7e57e7028088f96b1c1bdc65b763983e21b63d7e612cb34a77a05876d1a25de"

URI_aarch64_rust-nix+hostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+hostname-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+hostname-devel}"
SRC_URI[aarch64_rust-nix+hostname-devel.sha256sum] = "8922aaa97cc3fa746cf9c869dafd6fe9062aa77c41c8249bb85fbc9bdd99f6bb"

URI_aarch64_rust-nix+inotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+inotify-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+inotify-devel}"
SRC_URI[aarch64_rust-nix+inotify-devel.sha256sum] = "9578513d8e01f81e7a3fd85c16216d44cac403db3dfaa73b2337eb421646d6c0"

URI_aarch64_rust-nix+ioctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+ioctl-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+ioctl-devel}"
SRC_URI[aarch64_rust-nix+ioctl-devel.sha256sum] = "245de79598a718099fcebc07010e1337169aaf56694e0286aacaea13ae0899dd"

URI_aarch64_rust-nix+kmod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+kmod-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+kmod-devel}"
SRC_URI[aarch64_rust-nix+kmod-devel.sha256sum] = "acc495028ffab7b568af9aa5746fe0012256acdedc8fa77d6727f02eeff401da"

URI_aarch64_rust-nix+memoffset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+memoffset-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+memoffset-devel}"
SRC_URI[aarch64_rust-nix+memoffset-devel.sha256sum] = "561f1e42601312eb672e706453fd338b1b1fd6df19e2bff234eec3299deddd7a"

URI_aarch64_rust-nix+mman-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+mman-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+mman-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+mman-devel}"
SRC_URI[aarch64_rust-nix+mman-devel.sha256sum] = "39b5aa583bda1680c65d29d5008576294aa8f88a899bb14e02ed70e9015c7350"

URI_aarch64_rust-nix+mount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+mount-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+mount-devel}"
SRC_URI[aarch64_rust-nix+mount-devel.sha256sum] = "a9f97b48ac8096b21979ca22a324e1b6d6f8ce39cec3f4cd6e5b34377be4b6e0"

URI_aarch64_rust-nix+mqueue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+mqueue-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+mqueue-devel}"
SRC_URI[aarch64_rust-nix+mqueue-devel.sha256sum] = "f515e4cce182624daf262ce8091c6e9fd4f91a1c50e6c0a42f8fa130e253853a"

URI_aarch64_rust-nix+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+net-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+net-devel}"
SRC_URI[aarch64_rust-nix+net-devel.sha256sum] = "908ec723c162eea54b59489976a2a13412bf83ac44184fff3ae3299ca4e317b4"

URI_aarch64_rust-nix+personality-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+personality-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+personality-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+personality-devel}"
SRC_URI[aarch64_rust-nix+personality-devel.sha256sum] = "0a59662b16296413b41cbd085f813e61e465bbafcf076a37438707d9ef260de4"

URI_aarch64_rust-nix+pin-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+pin-utils-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+pin-utils-devel}"
SRC_URI[aarch64_rust-nix+pin-utils-devel.sha256sum] = "d86f5075e1cf559348f5caabbbbfb63e4bb86b67d79085c8fc227468c346a532"

URI_aarch64_rust-nix+poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+poll-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+poll-devel}"
SRC_URI[aarch64_rust-nix+poll-devel.sha256sum] = "0f1b9e28d827f8c22903fa2f3d212b9dcb1d401ad3781e456b744800e16d3565"

URI_aarch64_rust-nix+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+process-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+process-devel}"
SRC_URI[aarch64_rust-nix+process-devel.sha256sum] = "6c02a1350015d9bfadc15e5ff70f323a9b191cb5f3715d8e39e2fadc13a99ffd"

URI_aarch64_rust-nix+pthread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+pthread-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+pthread-devel}"
SRC_URI[aarch64_rust-nix+pthread-devel.sha256sum] = "5760b05312a016a917607fea03569ed863339a760da1ccabff4432bfc954890d"

URI_aarch64_rust-nix+ptrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+ptrace-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+ptrace-devel}"
SRC_URI[aarch64_rust-nix+ptrace-devel.sha256sum] = "2f9833c20260bf9fa681e73067d49f92e0d2d43bcb6c3d5552c4ff67573d786e"

URI_aarch64_rust-nix+quota-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+quota-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+quota-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+quota-devel}"
SRC_URI[aarch64_rust-nix+quota-devel.sha256sum] = "0056affe174a6ee12d8532c674308e9f74b11e3f307ee0e57584e7618358a4dc"

URI_aarch64_rust-nix+reboot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+reboot-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+reboot-devel}"
SRC_URI[aarch64_rust-nix+reboot-devel.sha256sum] = "ed98205cb92770554e89c25658173ce73a5a54035790fada9f9aaa0535141c5b"

URI_aarch64_rust-nix+resource-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+resource-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+resource-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+resource-devel}"
SRC_URI[aarch64_rust-nix+resource-devel.sha256sum] = "2ab039c02bba03ece8421d47e645f318e34fe54d08b7dd86ba3b5374d272b4c4"

URI_aarch64_rust-nix+sched-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+sched-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+sched-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+sched-devel}"
SRC_URI[aarch64_rust-nix+sched-devel.sha256sum] = "660ac6504c072c14b44b841cc77196d62521cf7d9e579805aa60af7f60dc827a"

URI_aarch64_rust-nix+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+signal-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+signal-devel}"
SRC_URI[aarch64_rust-nix+signal-devel.sha256sum] = "f5bbe87880fec70a9fd79812e25513ae2821dfa801428f8581022b1b2e22b0a0"

URI_aarch64_rust-nix+socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+socket-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+socket-devel}"
SRC_URI[aarch64_rust-nix+socket-devel.sha256sum] = "bdcf45713edfaf28f82e7def1fc671158667a74dda75f97cc2f7070d635fc04b"

URI_aarch64_rust-nix+syslog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+syslog-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+syslog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+syslog-devel}"
SRC_URI[aarch64_rust-nix+syslog-devel.sha256sum] = "1ba29e182f63ff1b51df59c704f04e48600fa8614499f4fe664602915bd37e52"

URI_aarch64_rust-nix+term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+term-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+term-devel}"
SRC_URI[aarch64_rust-nix+term-devel.sha256sum] = "9a5b70d9a0ea754fb8b7c2b459374324242ce903df7a4691b853bb4fe7592a1c"

URI_aarch64_rust-nix+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+time-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+time-devel}"
SRC_URI[aarch64_rust-nix+time-devel.sha256sum] = "19a118a3b26d8e83d65d6bcf0745b2ea032c236eb31b107ff68848949e686617"

URI_aarch64_rust-nix+ucontext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+ucontext-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+ucontext-devel}"
SRC_URI[aarch64_rust-nix+ucontext-devel.sha256sum] = "d350e1c623d6e386f2536adebcce9125eaa09b77fa8547e5e5c8236a00daa0bb"

URI_aarch64_rust-nix+uio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+uio-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+uio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+uio-devel}"
SRC_URI[aarch64_rust-nix+uio-devel.sha256sum] = "ee3912f4042bcd6501737205f87f9cdf812910510fb0c123aeb17175123bc546"

URI_aarch64_rust-nix+user-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+user-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+user-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+user-devel}"
SRC_URI[aarch64_rust-nix+user-devel.sha256sum] = "8c49e52cf5bd4233806caa95f445f15c01ec3a290faad6cc783f533920f16a39"

URI_aarch64_rust-nix+zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+zerocopy-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+zerocopy-devel}"
SRC_URI[aarch64_rust-nix+zerocopy-devel.sha256sum] = "99dc8c76b08eaedbe54b800c45834c0bca9c9713f43100b0af7c047ec6d7cbc6"

URI_aarch64_rust-nix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix-devel-0.31.3-1.el10_3.noarch.rpm;name=aarch64_rust-nix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix-devel}"
SRC_URI[aarch64_rust-nix-devel.sha256sum] = "706032882c5a917445f295f2fd45899452da2edb552168162716e4ba00d5184e"

RDEPENDS:rust-nix+acct-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+aio-devel = " \
 cargo \
 rust-nix+pin-utils-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+default-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+dir-devel = " \
 cargo \
 rust-nix+fs-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+env-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+event-devel = " \
 cargo \
 rust-nix+poll-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+fanotify-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+feature-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+fs-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+hostname-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+inotify-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+ioctl-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+kmod-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+memoffset-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+mman-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+mount-devel = " \
 cargo \
 rust-nix+uio-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+mqueue-devel = " \
 cargo \
 rust-nix+fs-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+net-devel = " \
 cargo \
 rust-nix+socket-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+personality-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+pin-utils-devel = " \
 cargo \
 rust-nix-devel \
 rust-pin-utils+default-devel \
 "
RDEPENDS:rust-nix+poll-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+process-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+pthread-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+ptrace-devel = " \
 cargo \
 rust-nix+process-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+quota-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+reboot-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+resource-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+sched-devel = " \
 cargo \
 rust-nix+process-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+signal-devel = " \
 cargo \
 rust-nix+process-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+socket-devel = " \
 cargo \
 rust-nix+memoffset-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+syslog-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+term-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+time-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+ucontext-devel = " \
 cargo \
 rust-nix+signal-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+uio-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+user-devel = " \
 cargo \
 rust-nix+feature-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+zerocopy-devel = " \
 cargo \
 rust-nix+fs-devel \
 rust-nix+uio-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-cfg_aliases+default-devel \
 rust-libc+default-devel \
 rust-libc+extra_traits-devel \
 "
