# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kblackbox"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kblackbox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kblackbox-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc3f998454b5a4fcce560a0e64985fe96faf140e77b4b7fc53e74e90a3d8ab04"

URI_x86_64_v2_kblackbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kblackbox-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kblackbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kblackbox}"
SRC_URI[x86_64_v2_kblackbox.sha256sum] = "1aa166d38606307e3541f938185b44d64b158d2b4c55483d2e355ba6c1604ea4"

URI_aarch64_kblackbox = "${EPEL_MIRROR}/aarch64/Packages/k/kblackbox-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kblackbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_kblackbox}"
SRC_URI[aarch64_kblackbox.sha256sum] = "24819c83d13ac69a3bc91bafff8e013d4b3010bb7028f4f355e94d464416f2ff"

RDEPENDS:kblackbox = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
