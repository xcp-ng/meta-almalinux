# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yoke-derive"
PV = "0.8.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-yoke-derive+default-devel \
 rust-yoke-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-yoke-derive-0.8.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4188c9668fc61900405b9e6cd4d297bc32ad33252a402a47deeda378f491d17"

URI_x86_64_v2_rust-yoke-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke-derive+default-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke-derive+default-devel}"
SRC_URI[x86_64_v2_rust-yoke-derive+default-devel.sha256sum] = "b65b9412a77e9f1311d045e36e5d2293dd305492382741ad28f5a57f66a2a553"

URI_x86_64_v2_rust-yoke-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke-derive-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke-derive-devel}"
SRC_URI[x86_64_v2_rust-yoke-derive-devel.sha256sum] = "cb967ead6973aecc58e9dfbd10b34f70b15299159291211bd8ec5e17923db682"

URI_aarch64_rust-yoke-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke-derive+default-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-yoke-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke-derive+default-devel}"
SRC_URI[aarch64_rust-yoke-derive+default-devel.sha256sum] = "266960adbcd5213995bbaa1984c744be20e2d7fa4d04e03ff9747913a476b6a4"

URI_aarch64_rust-yoke-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke-derive-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-yoke-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke-derive-devel}"
SRC_URI[aarch64_rust-yoke-derive-devel.sha256sum] = "922c918291a5b6c29a4b8d937dd466bb63571480fd54173f7f6e1e6930698dcd"

RDEPENDS:rust-yoke-derive+default-devel = " \
 cargo \
 rust-yoke-derive-devel \
 "
RDEPENDS:rust-yoke-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+fold-devel \
 rust-synstructure+default-devel \
 "
