# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tempita"
PV = "0.5.2"
PR = "14.el10_0"
PACKAGES = " \
 python3-tempita \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tempita-0.5.2-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c105e0270fb5da377dd976aecd80834d23172b7a05ee953e5bef1c8e5151e904"

URI_x86_64_v2_python3-tempita = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tempita-0.5.2-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tempita;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tempita}"
SRC_URI[x86_64_v2_python3-tempita.sha256sum] = "3b0b6efd5291c0d4887938f8e1ea089499a50fe122e90d397eb6205c2dc79413"

URI_aarch64_python3-tempita = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tempita-0.5.2-14.el10_0.noarch.rpm;name=aarch64_python3-tempita;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tempita}"
SRC_URI[aarch64_python3-tempita.sha256sum] = "244021dd3ca939fffc30ed837b074e88edd23136d2799dee5a3987af5ba6ec1f"

RDEPENDS:python3-tempita = " \
 python3 \
 "
