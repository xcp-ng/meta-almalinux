# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpm-ostree"
PV = "2026.1"
PR = "5.el10_2"
PACKAGES = " \
 rpm-ostree \
 rpm-ostree-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rpm-ostree-2026.1-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ead5d3a8610d75f00a77256d6fe35eea6994961d50291bf00aad22e9911d85af"

URI_x86_64_v2_rpm-ostree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-ostree-2026.1-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_rpm-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-ostree}"
SRC_URI[x86_64_v2_rpm-ostree.sha256sum] = "b4de8a55d55794f13f8648b432c087cd18f6c8a67a25b45d86c3ac7f741eff13"

URI_x86_64_v2_rpm-ostree-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-ostree-libs-2026.1-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_rpm-ostree-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-ostree-libs}"
SRC_URI[x86_64_v2_rpm-ostree-libs.sha256sum] = "bd3fec1b7ac1377746538574c6ff39ca4acc3bb41e9a1432c87fa6a6f3c97301"

URI_aarch64_rpm-ostree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-ostree-2026.1-5.el10_2.aarch64.rpm;name=aarch64_rpm-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-ostree}"
SRC_URI[aarch64_rpm-ostree.sha256sum] = "90033f0f44218afc6d71704c5ef0e960f4f2f52d9d8f9b95e131fe99de00d038"

URI_aarch64_rpm-ostree-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-ostree-libs-2026.1-5.el10_2.aarch64.rpm;name=aarch64_rpm-ostree-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-ostree-libs}"
SRC_URI[aarch64_rpm-ostree-libs.sha256sum] = "59bb4eebce7ad529caf75d32cc9c0cc6d6b876c3bec65d6ea2698dadd559a790"

RDEPENDS:rpm-ostree = " \
 bash \
 bootc \
 bubblewrap \
 fuse3 \
 glib2 \
 glibc \
 json-c \
 json-glib \
 libarchive \
 libcap \
 libgcc \
 libmodulemd \
 librepo \
 libsolv \
 libstdc++ \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 polkit-libs \
 rpm-libs \
 rpm-ostree-libs \
 skopeo \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:rpm-ostree-libs = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 ostree-libs \
 popt \
 rpm-libs \
 "
