# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "open-vmdk"
PV = "0.3.12"
PR = "1.el10_1"
PACKAGES = " \
 open-vmdk \
 ovfenv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/open-vmdk-0.3.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5b567db02525000f93e3bccd9221a2bdca370d115b04a8a22510429961bb973"

URI_x86_64_v2_open-vmdk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/open-vmdk-0.3.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_open-vmdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_open-vmdk}"
SRC_URI[x86_64_v2_open-vmdk.sha256sum] = "0404a8c75eefd4ea6c3204e490a461acb28473700b348c669824a087ed24ebdb"

URI_x86_64_v2_ovfenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ovfenv-0.3.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ovfenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ovfenv}"
SRC_URI[x86_64_v2_ovfenv.sha256sum] = "cf2ffd80b9eb8c8785a64a022779798438584675809c1a5ab4815cd11d137efc"

URI_aarch64_open-vmdk = "${EPEL_MIRROR}/aarch64/Packages/o/open-vmdk-0.3.12-1.el10_1.aarch64.rpm;name=aarch64_open-vmdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_open-vmdk}"
SRC_URI[aarch64_open-vmdk.sha256sum] = "55e200ff85d36b54df8c4a2978f3b4bb14df79079efc09c8c859b6d7ad3690a1"

URI_aarch64_ovfenv = "${EPEL_MIRROR}/aarch64/Packages/o/ovfenv-0.3.12-1.el10_1.noarch.rpm;name=aarch64_ovfenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ovfenv}"
SRC_URI[aarch64_ovfenv.sha256sum] = "c026779be6099d8667f730b6a7a667b42b6c0cda99bfabd2c9d727f12f1ad04c"

RDEPENDS:open-vmdk = " \
 bash \
 glibc \
 grep \
 python3 \
 python3-lxml \
 python3-pyyaml \
 sed \
 tar \
 util-linux \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:ovfenv = " \
 open-vm-tools \
 python3 \
 python3-libxml2 \
 "
