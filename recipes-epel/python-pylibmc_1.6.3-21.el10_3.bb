# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pylibmc"
PV = "1.6.3"
PR = "21.el10_3"
PACKAGES = " \
 python3-pylibmc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-pylibmc-1.6.3-21.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7bdece10a4961a5f1612a71e395e9709b78374cd72079110c0ca4ed11b3c68b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pylibmc-1.6.3-21.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pylibmc;unpack=0"
SRC_URI[x86_64_v2_python3-pylibmc.sha256sum] = "9437a38c55c7998424a3fc1ba0e3c35d4c914e43ce0eef77328540e219fc9ee8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pylibmc-1.6.3-21.el10_3.aarch64.rpm;name=aarch64_python3-pylibmc;unpack=0"
SRC_URI[aarch64_python3-pylibmc.sha256sum] = "e1f54a723b1b525149bdf0c44b9fdb50ec4df1f8b1e24cbaacb8c6c084a5ccbf"

RDEPENDS:python3-pylibmc = " \
 glibc \
 libmemcached-awesome \
 python3 \
 zlib-ng-compat \
 "
