# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wayland"
PV = "1.23.0"
PR = "2.el10"
PACKAGES = " \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwayland-server \
 wayland-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wayland-1.23.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5edcab77614b05ee079ade21adfb3354568e2731e881e526a38b7abed578a94b"

URI_x86_64_v2_libwayland-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwayland-client-1.23.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libwayland-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwayland-client}"
SRC_URI[x86_64_v2_libwayland-client.sha256sum] = "361c2b91f1c348ac74f1e88c4a9fb8ce6a19b48dd0a7eb2ea05480d4dc3a89f0"

URI_x86_64_v2_libwayland-cursor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwayland-cursor-1.23.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libwayland-cursor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwayland-cursor}"
SRC_URI[x86_64_v2_libwayland-cursor.sha256sum] = "70eb524439a74ad8f3eae9bd5b2170e6f6af44f4bcfc1e3da12aa9c1a3bce610"

URI_x86_64_v2_libwayland-egl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwayland-egl-1.23.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libwayland-egl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwayland-egl}"
SRC_URI[x86_64_v2_libwayland-egl.sha256sum] = "5d75a7b861f2683b947cff4fba3f2002e484c2c4b90b59313b536c9d7a0e3761"

URI_x86_64_v2_libwayland-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwayland-server-1.23.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libwayland-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwayland-server}"
SRC_URI[x86_64_v2_libwayland-server.sha256sum] = "4ea622292fe94b27a69a8e5f6e5031c4acfad0b7cb0e0c55b8d7364aad06bb0c"

URI_x86_64_v2_wayland-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wayland-devel-1.23.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_wayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wayland-devel}"
SRC_URI[x86_64_v2_wayland-devel.sha256sum] = "bdf8602e640337fe8b79e1b2025eb67addc87927ca26870338e45394c7b15556"

URI_aarch64_libwayland-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwayland-client-1.23.0-2.el10.aarch64.rpm;name=aarch64_libwayland-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwayland-client}"
SRC_URI[aarch64_libwayland-client.sha256sum] = "9d27f10c5d7fed2f489a71074277b001b2082d01bd46488d5b3a6b0fbab1c9fa"

URI_aarch64_libwayland-cursor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwayland-cursor-1.23.0-2.el10.aarch64.rpm;name=aarch64_libwayland-cursor;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwayland-cursor}"
SRC_URI[aarch64_libwayland-cursor.sha256sum] = "8ecb8da658c4cfdde510f400535822be336deae6e27a863a8a7a1285a971cf1f"

URI_aarch64_libwayland-egl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwayland-egl-1.23.0-2.el10.aarch64.rpm;name=aarch64_libwayland-egl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwayland-egl}"
SRC_URI[aarch64_libwayland-egl.sha256sum] = "24d0cde63cedf7c13b2a13e4f94c7c558e5f797c4f1a3ebb2a1e28bebda01efd"

URI_aarch64_libwayland-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwayland-server-1.23.0-2.el10.aarch64.rpm;name=aarch64_libwayland-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwayland-server}"
SRC_URI[aarch64_libwayland-server.sha256sum] = "180b04725ce8f01c0c25976d2368d137061f9117083588745c6eee868efe01e9"

URI_aarch64_wayland-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wayland-devel-1.23.0-2.el10.aarch64.rpm;name=aarch64_wayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wayland-devel}"
SRC_URI[aarch64_wayland-devel.sha256sum] = "72dbac840cb5351e9c01bcc14166314e2eb3830936c02a6e7609f7db2b57a622"

RDEPENDS:libwayland-client = " \
 glibc \
 libffi \
 "
RDEPENDS:libwayland-cursor = " \
 glibc \
 libwayland-client \
 "
RDEPENDS:libwayland-egl = " \
 glibc \
 "
RDEPENDS:libwayland-server = " \
 glibc \
 libffi \
 "
RDEPENDS:wayland-devel = " \
 expat \
 glibc \
 libffi-devel \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwayland-server \
 libxml2 \
 pkgconf-pkg-config \
 wayland-devel \
 "
