# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-psycopg3"
PV = "3.2.10"
PR = "2.el10_2"
PACKAGES = " \
 python3-psycopg3 \
 python3-psycopg3_c \
 python3-psycopg3_pool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-psycopg3-3.2.10-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21a63a860d348bdd27142c03729ae5e75438b46595199a85319e21eb216b39c8"

URI_x86_64_v2_python3-psycopg3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-psycopg3-3.2.10-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-psycopg3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-psycopg3}"
SRC_URI[x86_64_v2_python3-psycopg3.sha256sum] = "a83569b2e691e6004cc8331a31a291db03deeafce8df76557074295cee160fee"

URI_x86_64_v2_python3-psycopg3_c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-psycopg3_c-3.2.10-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-psycopg3_c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-psycopg3_c}"
SRC_URI[x86_64_v2_python3-psycopg3_c.sha256sum] = "1336e3d1d4e012b75226486f783465ac12521cc080ae3656067c55c31145e8fd"

URI_x86_64_v2_python3-psycopg3_pool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-psycopg3_pool-3.2.10-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-psycopg3_pool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-psycopg3_pool}"
SRC_URI[x86_64_v2_python3-psycopg3_pool.sha256sum] = "81e941ced6ec0167e51a967904803a59171ba7944a07fbb021dc2911ba82c3f7"

URI_aarch64_python3-psycopg3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-psycopg3-3.2.10-2.el10_2.noarch.rpm;name=aarch64_python3-psycopg3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-psycopg3}"
SRC_URI[aarch64_python3-psycopg3.sha256sum] = "3476223022faeaf5f04849729712f1d2e6f57bfaab154637f86b27f57619354b"

URI_aarch64_python3-psycopg3_c = "${EPEL_MIRROR}/aarch64/Packages/p/python3-psycopg3_c-3.2.10-2.el10_2.aarch64.rpm;name=aarch64_python3-psycopg3_c;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-psycopg3_c}"
SRC_URI[aarch64_python3-psycopg3_c.sha256sum] = "ebe6275350a99ce98ac7b15a15ff86d3950d541263648718b42e2f47a8367651"

URI_aarch64_python3-psycopg3_pool = "${EPEL_MIRROR}/aarch64/Packages/p/python3-psycopg3_pool-3.2.10-2.el10_2.noarch.rpm;name=aarch64_python3-psycopg3_pool;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-psycopg3_pool}"
SRC_URI[aarch64_python3-psycopg3_pool.sha256sum] = "2bbd78da812e42b41f051e406d8ea3d3b1803466c957b238e75ba03482013678"

RDEPENDS:python3-psycopg3 = " \
 libpq \
 python3 \
 python3-typing-extensions \
 "
RDEPENDS:python3-psycopg3_c = " \
 glibc \
 libpq \
 postgresql-private-libs \
 python3 \
 "
RDEPENDS:python3-psycopg3_pool = " \
 libpq \
 python3 \
 python3-psycopg3 \
 python3-typing-extensions \
 "
