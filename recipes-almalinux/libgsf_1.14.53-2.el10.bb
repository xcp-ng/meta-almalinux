# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgsf"
PV = "1.14.53"
PR = "2.el10"
PACKAGES = " \
 libgsf \
 libgsf-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libgsf-1.14.53-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2c704d214b4cb4f1c64f68ec02e6211131bedab18eacdb3f3f240a7ba42a977"

URI_x86_64_v2_libgsf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgsf-1.14.53-2.el10.x86_64_v2.rpm;name=x86_64_v2_libgsf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgsf}"
SRC_URI[x86_64_v2_libgsf.sha256sum] = "ff7c47b0f225c34114e942187da176bc94f4b23475a61885fa31587f9e96cdcd"

URI_x86_64_v2_libgsf-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgsf-devel-1.14.53-2.el10.x86_64_v2.rpm;name=x86_64_v2_libgsf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgsf-devel}"
SRC_URI[x86_64_v2_libgsf-devel.sha256sum] = "b7f4d43375a4a7ca7c7618750cbaa3ace758c30694641c7d6e79d72328b8a5d1"

URI_aarch64_libgsf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgsf-1.14.53-2.el10.aarch64.rpm;name=aarch64_libgsf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgsf}"
SRC_URI[aarch64_libgsf.sha256sum] = "24e282fb1475fb35b7013a56d1fa74cee6c56b0292775942fbd1ca55bbcaf867"

URI_aarch64_libgsf-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgsf-devel-1.14.53-2.el10.aarch64.rpm;name=aarch64_libgsf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgsf-devel}"
SRC_URI[aarch64_libgsf-devel.sha256sum] = "0aa80768009ecc50f05d8fc3bd2b39927480936830a418108ad1e05298076c88"

RDEPENDS:libgsf = " \
 bzip2-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libxml2 \
 zlib-ng-compat \
 "
RDEPENDS:libgsf-devel = " \
 glib2 \
 glib2-devel \
 glibc \
 libgsf \
 libxml2-devel \
 pkgconf-pkg-config \
 "
