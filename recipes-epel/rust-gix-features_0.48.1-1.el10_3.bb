# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-features"
PV = "0.48.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-features+cache-efficiency-debug-devel \
 rust-gix-features+crc32-devel \
 rust-gix-features+default-devel \
 rust-gix-features+document-features-devel \
 rust-gix-features+fs-read-dir-devel \
 rust-gix-features+io-pipe-devel \
 rust-gix-features+once_cell-devel \
 rust-gix-features+parallel-devel \
 rust-gix-features+prodash-devel \
 rust-gix-features+progress-devel \
 rust-gix-features+progress-unit-bytes-devel \
 rust-gix-features+progress-unit-human-numbers-devel \
 rust-gix-features+tracing-detail-devel \
 rust-gix-features+tracing-devel \
 rust-gix-features+walkdir-devel \
 rust-gix-features+zlib-devel \
 rust-gix-features-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-features-0.48.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38aa6338351a6dec12de56d1cc85255482c8141d1c2de11c5d31297b1a5301da"

URI_x86_64_v2_rust-gix-features+cache-efficiency-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+cache-efficiency-debug-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+cache-efficiency-debug-devel}"
SRC_URI[x86_64_v2_rust-gix-features+cache-efficiency-debug-devel.sha256sum] = "207a06c1a1df9a3cfe95f3edaf2909870cd0094123e0fc897fa4b8fdbcc049f9"

URI_x86_64_v2_rust-gix-features+crc32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+crc32-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+crc32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+crc32-devel}"
SRC_URI[x86_64_v2_rust-gix-features+crc32-devel.sha256sum] = "d0a57d7d40c63f9fd2c0e7e51f0eb6356fffe7fe2f4b96b05937502d1c4cf415"

URI_x86_64_v2_rust-gix-features+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+default-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+default-devel}"
SRC_URI[x86_64_v2_rust-gix-features+default-devel.sha256sum] = "8389e696baf9ebe1e0e038f26c065a74d9d628ba8c24f81a2bc5d27980920035"

URI_x86_64_v2_rust-gix-features+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+document-features-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-features+document-features-devel.sha256sum] = "4c7bc36518937ff704bfb8b1511bf7bebb9c28cd968e53118f7c2a7cf6b749d3"

URI_x86_64_v2_rust-gix-features+fs-read-dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+fs-read-dir-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+fs-read-dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+fs-read-dir-devel}"
SRC_URI[x86_64_v2_rust-gix-features+fs-read-dir-devel.sha256sum] = "ef870b4892944fc33666ee84ebb4ec867387bb514edf0f96c0c922c40403cfa2"

URI_x86_64_v2_rust-gix-features+io-pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+io-pipe-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+io-pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+io-pipe-devel}"
SRC_URI[x86_64_v2_rust-gix-features+io-pipe-devel.sha256sum] = "a3e226d9ac7cb1ac4b718e7fdcddeba3a3d4823c87c653a6841e82c5716b393e"

URI_x86_64_v2_rust-gix-features+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+once_cell-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+once_cell-devel}"
SRC_URI[x86_64_v2_rust-gix-features+once_cell-devel.sha256sum] = "ded1674fcfda80c9a6459762c2d0ad0eac51d3c9a960a62ac5204cd59c3e68a9"

URI_x86_64_v2_rust-gix-features+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+parallel-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix-features+parallel-devel.sha256sum] = "4d44fa99408ce0ef9c917f5d3eef8a2455af1dccafc292bdc6b0126c39237fdb"

URI_x86_64_v2_rust-gix-features+prodash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+prodash-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+prodash-devel}"
SRC_URI[x86_64_v2_rust-gix-features+prodash-devel.sha256sum] = "c6dbf0712c91c2b82f8523fc9589b3fec723523e21f362b866b893785c987024"

URI_x86_64_v2_rust-gix-features+progress-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+progress-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+progress-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+progress-devel}"
SRC_URI[x86_64_v2_rust-gix-features+progress-devel.sha256sum] = "75e33ed669816a5ea588cbd7cd0e2d39cb91f011202700772cc732ce73a83f17"

URI_x86_64_v2_rust-gix-features+progress-unit-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+progress-unit-bytes-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+progress-unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+progress-unit-bytes-devel}"
SRC_URI[x86_64_v2_rust-gix-features+progress-unit-bytes-devel.sha256sum] = "bcbf0857e80b789f4669e91af55e09fd7684d739389bab3aa3fa0b35567db172"

URI_x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+progress-unit-human-numbers-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel}"
SRC_URI[x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel.sha256sum] = "01d336065a32bc6fd05c1f5e51c150dccd8b0f76b4f159e35cad29a6c3aa9800"

URI_x86_64_v2_rust-gix-features+tracing-detail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+tracing-detail-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+tracing-detail-devel}"
SRC_URI[x86_64_v2_rust-gix-features+tracing-detail-devel.sha256sum] = "3de4c1f4b8649460027aa1b70511c9ca640734c38214662e0d6de70c8fc2c3e1"

URI_x86_64_v2_rust-gix-features+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+tracing-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+tracing-devel}"
SRC_URI[x86_64_v2_rust-gix-features+tracing-devel.sha256sum] = "5979362733adb279af293d82226ad631f0ec03e38f7c680c877fec011af9cbd2"

URI_x86_64_v2_rust-gix-features+walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+walkdir-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+walkdir-devel}"
SRC_URI[x86_64_v2_rust-gix-features+walkdir-devel.sha256sum] = "58bc58d4b959029bb41a78287caa2120cb7473544ad2b9f81061d3c3ecba7ab3"

URI_x86_64_v2_rust-gix-features+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+zlib-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+zlib-devel}"
SRC_URI[x86_64_v2_rust-gix-features+zlib-devel.sha256sum] = "04228676c2272af882f990ce9ca9e5e5e2b4129e98de5f09e3420fdf71fd3b79"

URI_x86_64_v2_rust-gix-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features-devel-0.48.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features-devel}"
SRC_URI[x86_64_v2_rust-gix-features-devel.sha256sum] = "4fab987a64714220768077edd100320aeae9fe04b91cb9f11e6d22296dbe1844"

URI_aarch64_rust-gix-features+cache-efficiency-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+cache-efficiency-debug-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+cache-efficiency-debug-devel}"
SRC_URI[aarch64_rust-gix-features+cache-efficiency-debug-devel.sha256sum] = "8e1267f24dc39b39d6e0cc43971549a4343904b28107bdb964d53b3e9446c755"

URI_aarch64_rust-gix-features+crc32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+crc32-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+crc32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+crc32-devel}"
SRC_URI[aarch64_rust-gix-features+crc32-devel.sha256sum] = "7bdd2df0e359ab54efa11ab5ef8f9c8afb345b4d1e51a3b3e7d9b67ac693b10a"

URI_aarch64_rust-gix-features+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+default-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+default-devel}"
SRC_URI[aarch64_rust-gix-features+default-devel.sha256sum] = "ffa81339ec224f23bbc3bc0b595747f15a8f00a711cdcbb1a2178016628f3430"

URI_aarch64_rust-gix-features+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+document-features-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+document-features-devel}"
SRC_URI[aarch64_rust-gix-features+document-features-devel.sha256sum] = "54f83d0b0cb8c61cb3bfc8d0f025f8f8853d94ae55d1b4b50099cfb2d41b50e9"

URI_aarch64_rust-gix-features+fs-read-dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+fs-read-dir-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+fs-read-dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+fs-read-dir-devel}"
SRC_URI[aarch64_rust-gix-features+fs-read-dir-devel.sha256sum] = "21f2848a9fee234ab01a1c11b44d6a17ec1d037f5b9536ea41886a9d30fd8041"

URI_aarch64_rust-gix-features+io-pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+io-pipe-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+io-pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+io-pipe-devel}"
SRC_URI[aarch64_rust-gix-features+io-pipe-devel.sha256sum] = "a67682d0d23074a0dfcf08457246c6acdca3f50547638eb6ba0b0fa2b91e2d54"

URI_aarch64_rust-gix-features+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+once_cell-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+once_cell-devel}"
SRC_URI[aarch64_rust-gix-features+once_cell-devel.sha256sum] = "29db3c974e1118707f48f9db648f36a6b9d82a8b44f769a44c31e08a38774cc7"

URI_aarch64_rust-gix-features+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+parallel-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+parallel-devel}"
SRC_URI[aarch64_rust-gix-features+parallel-devel.sha256sum] = "6cd21573b099de6c6f792bab3a4fb34478fab4fd45c450f16f02ac43d791723d"

URI_aarch64_rust-gix-features+prodash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+prodash-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+prodash-devel}"
SRC_URI[aarch64_rust-gix-features+prodash-devel.sha256sum] = "2ab81543b3e77d11ced64a01cbd7b50adab4ac1513ca0961f06f44ae0597acd0"

URI_aarch64_rust-gix-features+progress-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+progress-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+progress-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+progress-devel}"
SRC_URI[aarch64_rust-gix-features+progress-devel.sha256sum] = "d320a02b025485427fbb2f0a4b06b97332c96a83dd6f40bf2df62bbe7d988fe7"

URI_aarch64_rust-gix-features+progress-unit-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+progress-unit-bytes-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+progress-unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+progress-unit-bytes-devel}"
SRC_URI[aarch64_rust-gix-features+progress-unit-bytes-devel.sha256sum] = "b1fa54e15070c368ef907d63a8a083fd506ffff74b369c151515b7cea7885fa1"

URI_aarch64_rust-gix-features+progress-unit-human-numbers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+progress-unit-human-numbers-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+progress-unit-human-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+progress-unit-human-numbers-devel}"
SRC_URI[aarch64_rust-gix-features+progress-unit-human-numbers-devel.sha256sum] = "81eeca0898e13bc1a3428332c804a55e3e513089f164ed53d96651b0110dfa0f"

URI_aarch64_rust-gix-features+tracing-detail-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+tracing-detail-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+tracing-detail-devel}"
SRC_URI[aarch64_rust-gix-features+tracing-detail-devel.sha256sum] = "8eb7369868db39c08afd5ba4643323581ceead6041e7ea487c64fc2c72db4033"

URI_aarch64_rust-gix-features+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+tracing-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+tracing-devel}"
SRC_URI[aarch64_rust-gix-features+tracing-devel.sha256sum] = "73822e12bbcd7dd380be891049f7d5b9b9a0143d64d578328c31094b029559f7"

URI_aarch64_rust-gix-features+walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+walkdir-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+walkdir-devel}"
SRC_URI[aarch64_rust-gix-features+walkdir-devel.sha256sum] = "da74552cda8d2346d846c284f65ee18a6d0ba90960d283ada52331321a3f2559"

URI_aarch64_rust-gix-features+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+zlib-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+zlib-devel}"
SRC_URI[aarch64_rust-gix-features+zlib-devel.sha256sum] = "b1bf6cb12fc96c0004f5018e3006b03846426bdd8c93495b74b06c82e82ca33a"

URI_aarch64_rust-gix-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features-devel-0.48.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features-devel}"
SRC_URI[aarch64_rust-gix-features-devel.sha256sum] = "ae909d1e12df5e45d3bba899f3272e2b33d3cf366d67374d26266171d316f073"

RDEPENDS:rust-gix-features+cache-efficiency-debug-devel = " \
 cargo \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+crc32-devel = " \
 cargo \
 rust-crc32fast+default-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+default-devel = " \
 cargo \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+fs-read-dir-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-utils+default-devel \
 "
RDEPENDS:rust-gix-features+io-pipe-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+once_cell-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-once_cell+default-devel \
 "
RDEPENDS:rust-gix-features+parallel-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-gix-features-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-gix-features+prodash-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-prodash+default-devel \
 "
RDEPENDS:rust-gix-features+progress-devel = " \
 cargo \
 rust-gix-features+prodash-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+progress-unit-bytes-devel = " \
 cargo \
 rust-bytesize+default-devel \
 rust-gix-features-devel \
 rust-prodash+default-devel \
 rust-prodash+unit-bytes-devel \
 "
RDEPENDS:rust-gix-features+progress-unit-human-numbers-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-prodash+default-devel \
 rust-prodash+unit-human-devel \
 "
RDEPENDS:rust-gix-features+tracing-detail-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-trace+tracing-detail-devel \
 "
RDEPENDS:rust-gix-features+tracing-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-trace+tracing-devel \
 "
RDEPENDS:rust-gix-features+walkdir-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-path+default-devel \
 rust-gix-utils+default-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-gix-features+zlib-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-thiserror+default-devel \
 rust-zlib-rs+default-devel \
 "
RDEPENDS:rust-gix-features-devel = " \
 cargo \
 rust \
 rust-gix-trace+default-devel \
 rust-libc+default-devel \
 "
