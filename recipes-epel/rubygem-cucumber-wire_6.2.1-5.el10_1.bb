# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber-wire"
PV = "6.2.1"
PR = "5.el10_1"
PACKAGES = " \
 rubygem-cucumber-wire \
 rubygem-cucumber-wire-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-wire-6.2.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fe6832cc3fc1291774fd48024bcc51c8f4ef2278ab4f776d29060b556690339"

URI_x86_64_v2_rubygem-cucumber-wire = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-wire-6.2.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-wire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-wire}"
SRC_URI[x86_64_v2_rubygem-cucumber-wire.sha256sum] = "7685f22b2a8b59ef20bb30a92881263c461dd07d8415107b0097e96abb470749"

URI_x86_64_v2_rubygem-cucumber-wire-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-wire-doc-6.2.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-wire-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-wire-doc}"
SRC_URI[x86_64_v2_rubygem-cucumber-wire-doc.sha256sum] = "5b52d42af23b413406b6a42d8c24b3a67ec04f7f1f8c3289e083ce674670523c"

URI_aarch64_rubygem-cucumber-wire = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-wire-6.2.1-5.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-wire;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-wire}"
SRC_URI[aarch64_rubygem-cucumber-wire.sha256sum] = "9996cc1532fe2083754783f775a6fb7efe281c108304ae8e73a235cf1940f0ac"

URI_aarch64_rubygem-cucumber-wire-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-wire-doc-6.2.1-5.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-wire-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-wire-doc}"
SRC_URI[aarch64_rubygem-cucumber-wire-doc.sha256sum] = "003cfb2b74903f9e11d0ec6b5b385425515c78bd72888164ea37c163bb54cd71"

RDEPENDS:rubygem-cucumber-wire = " \
 rubygem-cucumber-core \
 rubygem-cucumber-cucumber-expressions \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-wire-doc = " \
 rubygem-cucumber-wire \
 "
