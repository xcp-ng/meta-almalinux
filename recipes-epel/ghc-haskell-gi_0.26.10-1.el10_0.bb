# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-haskell-gi"
PV = "0.26.10"
PR = "1.el10_0"
PACKAGES = " \
 ghc-haskell-gi \
 ghc-haskell-gi-devel \
 ghc-haskell-gi-doc \
 ghc-haskell-gi-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-haskell-gi-0.26.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "739480fdd76a7d19258db445e47c20678ba2d097ef3c0f5d9210153a5fae1553"

URI_x86_64_v2_ghc-haskell-gi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskell-gi-0.26.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haskell-gi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskell-gi}"
SRC_URI[x86_64_v2_ghc-haskell-gi.sha256sum] = "da2e0fcccbdbedf4e10ea5cd5a0ce567efe04c545908955f7bfdfdf137d49bba"

URI_x86_64_v2_ghc-haskell-gi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskell-gi-devel-0.26.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haskell-gi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskell-gi-devel}"
SRC_URI[x86_64_v2_ghc-haskell-gi-devel.sha256sum] = "92ce2fab3ef0eed24a1143fbb0df144ddba5a528f38f05441ea63eed3c394de3"

URI_x86_64_v2_ghc-haskell-gi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskell-gi-doc-0.26.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-haskell-gi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskell-gi-doc}"
SRC_URI[x86_64_v2_ghc-haskell-gi-doc.sha256sum] = "d3fc57219ce09f0b867dc640eee4dc66853452c949c35ec9dd8659c635483961"

URI_x86_64_v2_ghc-haskell-gi-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haskell-gi-prof-0.26.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haskell-gi-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haskell-gi-prof}"
SRC_URI[x86_64_v2_ghc-haskell-gi-prof.sha256sum] = "cd43204b97b094bf27c5756d37005fd0d4d3622f3d2480d9fa7006d0b6cdb8c9"

URI_aarch64_ghc-haskell-gi = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskell-gi-0.26.10-1.el10_0.aarch64.rpm;name=aarch64_ghc-haskell-gi;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskell-gi}"
SRC_URI[aarch64_ghc-haskell-gi.sha256sum] = "cca0897c2bfe5d3cdedc61a33998f38e51990222a3144b38cc9ae7b864dfb424"

URI_aarch64_ghc-haskell-gi-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskell-gi-devel-0.26.10-1.el10_0.aarch64.rpm;name=aarch64_ghc-haskell-gi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskell-gi-devel}"
SRC_URI[aarch64_ghc-haskell-gi-devel.sha256sum] = "70b3d4e57016a0270708b5f91adb77a7791f1fe443c0a3f9d53ffa73f975d148"

URI_aarch64_ghc-haskell-gi-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskell-gi-doc-0.26.10-1.el10_0.noarch.rpm;name=aarch64_ghc-haskell-gi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskell-gi-doc}"
SRC_URI[aarch64_ghc-haskell-gi-doc.sha256sum] = "cac527ccbab3e8e380c73e6987fbe194f34848b01dc14fcf3ebf049e77730cfd"

URI_aarch64_ghc-haskell-gi-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haskell-gi-prof-0.26.10-1.el10_0.aarch64.rpm;name=aarch64_ghc-haskell-gi-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haskell-gi-prof}"
SRC_URI[aarch64_ghc-haskell-gi-prof.sha256sum] = "c89cdb92161c631899339744cc1c16409dbe5235f15ef90b8657d30e7bb7c7b8"

RDEPENDS:ghc-haskell-gi = " \
 ghc-Cabal \
 ghc-Cabal-syntax \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-colour \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-haskell-gi-base \
 ghc-haskell-lexer \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-pretty-show \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-xdg-basedir \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glib2 \
 glibc \
 gmp \
 gobject-introspection \
 zlib-ng-compat \
 "
RDEPENDS:ghc-haskell-gi-devel = " \
 ghc-Cabal-devel \
 ghc-ansi-terminal-devel \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-haskell-gi \
 ghc-haskell-gi-base-devel \
 ghc-mtl-devel \
 ghc-pretty-show-devel \
 ghc-process-devel \
 ghc-regex-tdfa-devel \
 ghc-safe-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-xdg-basedir-devel \
 ghc-xml-conduit-devel \
 glib2-devel \
 gobject-introspection-devel \
 "
RDEPENDS:ghc-haskell-gi-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-haskell-gi-prof = " \
 ghc-Cabal-prof \
 ghc-ansi-terminal-prof \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-haskell-gi-base-prof \
 ghc-haskell-gi-devel \
 ghc-mtl-prof \
 ghc-pretty-show-prof \
 ghc-process-prof \
 ghc-regex-tdfa-prof \
 ghc-safe-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-xdg-basedir-prof \
 ghc-xml-conduit-prof \
 "
