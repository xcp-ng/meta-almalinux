# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "beakerlib"
PV = "1.33.3"
PR = "1.el10_1"
PACKAGES = " \
 beakerlib \
 beakerlib-vim-syntax \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/beakerlib-1.33.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1f8f8d90d15f1184ef07e10e3daac518584a5b8827749f375c6bc9957439ac7"

URI_x86_64_v2_beakerlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/beakerlib-1.33.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_beakerlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_beakerlib}"
SRC_URI[x86_64_v2_beakerlib.sha256sum] = "11c2ce329816bd8baa01801ee352845e5bf426b733d158fb91bab1745be928e6"

URI_x86_64_v2_beakerlib-vim-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/beakerlib-vim-syntax-1.33.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_beakerlib-vim-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_beakerlib-vim-syntax}"
SRC_URI[x86_64_v2_beakerlib-vim-syntax.sha256sum] = "d1f8b0c10af5db53d7129caed34cd33e305cda5489ade9aae275c8779a334a40"

URI_aarch64_beakerlib = "${EPEL_MIRROR}/aarch64/Packages/b/beakerlib-1.33.3-1.el10_1.noarch.rpm;name=aarch64_beakerlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_beakerlib}"
SRC_URI[aarch64_beakerlib.sha256sum] = "f997e6c2916b6e87e1e0db4cad4588fdf3ba1470eb39687a9265df9728d808c2"

URI_aarch64_beakerlib-vim-syntax = "${EPEL_MIRROR}/aarch64/Packages/b/beakerlib-vim-syntax-1.33.3-1.el10_1.noarch.rpm;name=aarch64_beakerlib-vim-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_beakerlib-vim-syntax}"
SRC_URI[aarch64_beakerlib-vim-syntax.sha256sum] = "991a7c28fac136257bfd79eb3115327ef17fe6e04505c39e8b9a38f8932a4611"

RDEPENDS:beakerlib = " \
 bash \
 bc \
 dnf-plugins-core \
 grep \
 gzip \
 iproute \
 nfs-utils \
 python3-dnf \
 sed \
 tar \
 time \
 util-linux \
 virtual/coreutils \
 virtual/wget_or_curl \
 which \
 "
RDEPENDS:beakerlib-vim-syntax = " \
 vim-common \
 "
