# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-ident"
PV = "1.0.26"
PR = "1.el10_2"
PACKAGES = " \
 rust-unicode-ident+default-devel \
 rust-unicode-ident-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-ident-1.0.26-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "034a1795b54a11e77f0e4253e4a87f7a69f50be27e33c0a390202dac7eb1ac86"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-ident+default-devel-1.0.26-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-ident+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unicode-ident+default-devel.sha256sum] = "ea8003408de08688f7132f3d9cadd2886aaeed331d508b1666ca2ec8d6cd10b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-ident-devel-1.0.26-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-ident-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unicode-ident-devel.sha256sum] = "ed89bb6ad1fdf39240689f31673314078fcb572a2cd522aa603364e8beb83aaa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-ident+default-devel-1.0.26-1.el10_2.noarch.rpm;name=aarch64_rust-unicode-ident+default-devel;unpack=0"
SRC_URI[aarch64_rust-unicode-ident+default-devel.sha256sum] = "b2d0b100b3ffe77948fc2e19bb8fe85df0fa50083799f9d53739b4a041da53a3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-ident-devel-1.0.26-1.el10_2.noarch.rpm;name=aarch64_rust-unicode-ident-devel;unpack=0"
SRC_URI[aarch64_rust-unicode-ident-devel.sha256sum] = "9b5f948e3d6243a83fc83df672c1a59b59aef954da6a823ec725060231012ace"

RDEPENDS:rust-unicode-ident+default-devel = " \
 cargo \
 rust-unicode-ident-devel \
 "
RDEPENDS:rust-unicode-ident-devel = " \
 cargo \
 rust \
 "
