# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MooseX-Types-Path-Class"
PV = "0.09"
PR = "21.el10_2"
PACKAGES = " \
 perl-MooseX-Types-Path-Class \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MooseX-Types-Path-Class-0.09-21.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5af7b572903cf859580ecd7d2398798377ffe8460079ed8a095c3edf200788e2"

URI_x86_64_v2_perl-MooseX-Types-Path-Class = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MooseX-Types-Path-Class-0.09-21.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MooseX-Types-Path-Class;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MooseX-Types-Path-Class}"
SRC_URI[x86_64_v2_perl-MooseX-Types-Path-Class.sha256sum] = "860fc02dd9aa03515b0c14069060af3fee20b93d9ab8885439e3d8c593205bc7"

URI_aarch64_perl-MooseX-Types-Path-Class = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MooseX-Types-Path-Class-0.09-21.el10_2.noarch.rpm;name=aarch64_perl-MooseX-Types-Path-Class;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MooseX-Types-Path-Class}"
SRC_URI[aarch64_perl-MooseX-Types-Path-Class.sha256sum] = "89e3fe66782553d2080737995da9933436a0ad8e76bd7fa183baea92c97c48a4"

RDEPENDS:perl-MooseX-Types-Path-Class = " \
 perl-Moose \
 perl-MooseX-Types \
 perl-Path-Class \
 perl-if \
 perl-libs \
 "
