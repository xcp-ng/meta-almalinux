# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcompletion"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcompletion \
 kf6-kcompletion-devel \
 kf6-kcompletion-doc \
 kf6-kcompletion-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kcompletion-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3ff04c453585957d532d7ac357dfa52e51f4f94ba61fe5a14cd812c13c21e02f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcompletion;unpack=0"
SRC_URI[x86_64_v2_kf6-kcompletion.sha256sum] = "096ce8b70056eae99621233977f979c19dd79b08dc23b32fbea0e4fbccef193c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcompletion-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kcompletion-devel.sha256sum] = "0e46e777e2c60bee1dd3d054c02a0e0eec11d90cd040dd11adc1f6795c40383c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcompletion-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kcompletion-doc.sha256sum] = "73cf93018b9ffdb4e6a5dd6cadf4d7fd853cba6db112acf8aab132779f252155"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcompletion-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kcompletion-html.sha256sum] = "2b6af2378702aa74731bf1aa32e21b128d4b234df434f0625bdd56a970302f9d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcompletion;unpack=0"
SRC_URI[aarch64_kf6-kcompletion.sha256sum] = "5d81efd73cf9ebd037b7f96184d736b8825e6def8511fc629dfa0b228466105f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcompletion-devel;unpack=0"
SRC_URI[aarch64_kf6-kcompletion-devel.sha256sum] = "771163230b15072e4da247bbca147836c974e9346a723c955aefb2aaa815257c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcompletion-doc;unpack=0"
SRC_URI[aarch64_kf6-kcompletion-doc.sha256sum] = "0f92742eb5fe8c2469577e3a0e483ee05dbbe3789426f7a49aae4b95c3a16012"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcompletion-html;unpack=0"
SRC_URI[aarch64_kf6-kcompletion-html.sha256sum] = "d11797b628dc039eff4d3e999d9f2b2c79e1d30f9c651c6c70247b16eb54e385"

RDEPENDS:kf6-kcompletion = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcompletion-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcompletion \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcompletion-doc = " \
 "
RDEPENDS:kf6-kcompletion-html = " \
 "
