# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-IEEE754"
PV = "0.02"
PR = "15.el10_0"
PACKAGES = " \
 perl-Data-IEEE754 \
 perl-Data-IEEE754-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-IEEE754-0.02-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "901a88cb3a8df3553afd8cdaa33ac83221b65b1dcddc25cbf37414d024f6b94f"

URI_x86_64_v2_perl-Data-IEEE754 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-IEEE754-0.02-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-IEEE754;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-IEEE754}"
SRC_URI[x86_64_v2_perl-Data-IEEE754.sha256sum] = "8e746818637ae5dfe7103992cb414669d0c4bb821b6e7ff01c33c259a0a04427"

URI_x86_64_v2_perl-Data-IEEE754-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-IEEE754-tests-0.02-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-IEEE754-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-IEEE754-tests}"
SRC_URI[x86_64_v2_perl-Data-IEEE754-tests.sha256sum] = "0030b7978e3314f06665138be111d3f3322489dca8dd4f7c66ac83a252c62593"

URI_aarch64_perl-Data-IEEE754 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-IEEE754-0.02-15.el10_0.noarch.rpm;name=aarch64_perl-Data-IEEE754;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-IEEE754}"
SRC_URI[aarch64_perl-Data-IEEE754.sha256sum] = "17e70d18b208e274ff32b2fb16a85e3980a6d6930422abbe467ff4ea7abc72b6"

URI_aarch64_perl-Data-IEEE754-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-IEEE754-tests-0.02-15.el10_0.noarch.rpm;name=aarch64_perl-Data-IEEE754-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-IEEE754-tests}"
SRC_URI[aarch64_perl-Data-IEEE754-tests.sha256sum] = "c9c716e18cd5827234e251de64d3746c82b523edae41e33e58882a10294bce5f"

RDEPENDS:perl-Data-IEEE754 = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Data-IEEE754-tests = " \
 bash \
 perl-Data-IEEE754 \
 perl-ExtUtils-MakeMaker \
 perl-PathTools \
 perl-Test-Bits \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
