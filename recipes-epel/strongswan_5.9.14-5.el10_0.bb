# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "strongswan"
PV = "5.9.14"
PR = "5.el10_0"
PACKAGES = " \
 perl-vici \
 python3-vici \
 strongswan \
 strongswan-charon-nm \
 strongswan-libipsec \
 strongswan-sqlite \
 strongswan-tnc-imcvs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/strongswan-5.9.14-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46821dceaaba53f6a4332161ed2633082cd89765ab23dd1b331e9a9727983496"

URI_x86_64_v2_perl-vici = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-vici-5.9.14-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-vici;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-vici}"
SRC_URI[x86_64_v2_perl-vici.sha256sum] = "3b037421a715153991a737916b84cd84247568d119cd67f624f101fbd665e39f"

URI_x86_64_v2_python3-vici = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-vici-5.9.14-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-vici;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-vici}"
SRC_URI[x86_64_v2_python3-vici.sha256sum] = "a40aa82001ec57432d66c70653bb3d6b4f0338e3839934cc87adc6bca172ed1f"

URI_x86_64_v2_strongswan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/strongswan-5.9.14-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_strongswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strongswan}"
SRC_URI[x86_64_v2_strongswan.sha256sum] = "18d93f26de7e5083e2b30a80b512c31e8a3cbd5bddffbfb4a2dc6340e35463d6"

URI_x86_64_v2_strongswan-charon-nm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/strongswan-charon-nm-5.9.14-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_strongswan-charon-nm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strongswan-charon-nm}"
SRC_URI[x86_64_v2_strongswan-charon-nm.sha256sum] = "68efe48923061c3dad233215c15227c03599d54504936ecf09f0c2cbb0820248"

URI_x86_64_v2_strongswan-libipsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/strongswan-libipsec-5.9.14-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_strongswan-libipsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strongswan-libipsec}"
SRC_URI[x86_64_v2_strongswan-libipsec.sha256sum] = "abc658b3054637eff152b44c3ca799071ea978817fa54fe1777b6414f918ba07"

URI_x86_64_v2_strongswan-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/strongswan-sqlite-5.9.14-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_strongswan-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strongswan-sqlite}"
SRC_URI[x86_64_v2_strongswan-sqlite.sha256sum] = "a6d3f89ae43cc6cf83423ab32a3e39e4baf103dd617d94c9d742fd66f5b24732"

URI_x86_64_v2_strongswan-tnc-imcvs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/strongswan-tnc-imcvs-5.9.14-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_strongswan-tnc-imcvs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strongswan-tnc-imcvs}"
SRC_URI[x86_64_v2_strongswan-tnc-imcvs.sha256sum] = "234c068217e52abfa9b2f6f2e52ff9a9e2c55e10db695474b5b81e624d3cab42"

URI_aarch64_perl-vici = "${EPEL_MIRROR}/aarch64/Packages/p/perl-vici-5.9.14-5.el10_0.noarch.rpm;name=aarch64_perl-vici;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-vici}"
SRC_URI[aarch64_perl-vici.sha256sum] = "bf3c493b7f26d58a50b3d3e88e33fdedfee5bd3bc0b7dfeaa9dfea5fb9c5eae7"

URI_aarch64_python3-vici = "${EPEL_MIRROR}/aarch64/Packages/p/python3-vici-5.9.14-5.el10_0.noarch.rpm;name=aarch64_python3-vici;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-vici}"
SRC_URI[aarch64_python3-vici.sha256sum] = "0653737c2f171ded76a21dab0402802d602f53ff8efb39d0122e91b1ee02150f"

URI_aarch64_strongswan = "${EPEL_MIRROR}/aarch64/Packages/s/strongswan-5.9.14-5.el10_0.aarch64.rpm;name=aarch64_strongswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_strongswan}"
SRC_URI[aarch64_strongswan.sha256sum] = "1bad66e794cf99ec000121371271b285687d5883de75f9b1040bc4bc2486f526"

URI_aarch64_strongswan-charon-nm = "${EPEL_MIRROR}/aarch64/Packages/s/strongswan-charon-nm-5.9.14-5.el10_0.aarch64.rpm;name=aarch64_strongswan-charon-nm;unpack=0"
SRC_URI:append = " ${URI_aarch64_strongswan-charon-nm}"
SRC_URI[aarch64_strongswan-charon-nm.sha256sum] = "cd4b11a44acd2f73c3bc3cb27694a1566d5bf74a03d022bf0d4efef4ba648990"

URI_aarch64_strongswan-libipsec = "${EPEL_MIRROR}/aarch64/Packages/s/strongswan-libipsec-5.9.14-5.el10_0.aarch64.rpm;name=aarch64_strongswan-libipsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_strongswan-libipsec}"
SRC_URI[aarch64_strongswan-libipsec.sha256sum] = "442132f4a6735420bfcbcfc5d0081762e416472470e1d5fd2b32fd4cdc4aa07c"

URI_aarch64_strongswan-sqlite = "${EPEL_MIRROR}/aarch64/Packages/s/strongswan-sqlite-5.9.14-5.el10_0.aarch64.rpm;name=aarch64_strongswan-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_strongswan-sqlite}"
SRC_URI[aarch64_strongswan-sqlite.sha256sum] = "392437f71b6e0be4698112e38897d3a414de875333e6bdc8c0c259bfa705ffb9"

URI_aarch64_strongswan-tnc-imcvs = "${EPEL_MIRROR}/aarch64/Packages/s/strongswan-tnc-imcvs-5.9.14-5.el10_0.aarch64.rpm;name=aarch64_strongswan-tnc-imcvs;unpack=0"
SRC_URI:append = " ${URI_aarch64_strongswan-tnc-imcvs}"
SRC_URI[aarch64_strongswan-tnc-imcvs.sha256sum] = "34914c70a87b400b6955142bae7df1a683a9532dd110f7fcdbdf9b84b72d2b98"

RDEPENDS:perl-vici = " \
 perl-constant \
 perl-libs \
 perl-vici \
 "
RDEPENDS:python3-vici = " \
 python3 \
 "
RDEPENDS:strongswan = " \
 bash \
 glibc \
 gmp \
 libcap \
 libgcc \
 libgcrypt \
 libgpg-error \
 openssl-libs \
 pam-libs \
 systemd \
 systemd-libs \
 tpm2-tss \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:strongswan-charon-nm = " \
 NetworkManager-libnm \
 dbus \
 glib2 \
 glibc \
 strongswan \
 "
RDEPENDS:strongswan-libipsec = " \
 glibc \
 strongswan \
 "
RDEPENDS:strongswan-sqlite = " \
 glibc \
 sqlite-libs \
 strongswan \
 "
RDEPENDS:strongswan-tnc-imcvs = " \
 glibc \
 json-c \
 libxml2 \
 strongswan \
 strongswan-sqlite \
 "
