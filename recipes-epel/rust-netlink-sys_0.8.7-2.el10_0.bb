# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-netlink-sys"
PV = "0.8.7"
PR = "2.el10_0"
PACKAGES = " \
 rust-netlink-sys+async-io-devel \
 rust-netlink-sys+default-devel \
 rust-netlink-sys+futures-devel \
 rust-netlink-sys+mio-devel \
 rust-netlink-sys+mio_socket-devel \
 rust-netlink-sys+smol_socket-devel \
 rust-netlink-sys+tokio-devel \
 rust-netlink-sys+tokio_socket-devel \
 rust-netlink-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-netlink-sys-0.8.7-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fa9af9bb0769b98c34efc0209a14f9e62fab0b4b439fa89497d6b3825c518c1"

URI_x86_64_v2_rust-netlink-sys+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+async-io-devel-0.8.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+async-io-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+async-io-devel.sha256sum] = "f0758c6af9b3b7dc5384a26cbb1be0fe83b0a3d20597fb582d1ea9ede8b58765"

URI_x86_64_v2_rust-netlink-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+default-devel-0.8.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+default-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+default-devel.sha256sum] = "15df7192a83574eb852db551019dfe958f99b3eb788b02fc3c608672fa6017a8"

URI_x86_64_v2_rust-netlink-sys+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+futures-devel-0.8.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+futures-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+futures-devel.sha256sum] = "329ce54054c7a7061e4b84d19867b2c1bd891d9ca087e64d9972d649bca7a9ba"

URI_x86_64_v2_rust-netlink-sys+mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+mio-devel-0.8.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+mio-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+mio-devel.sha256sum] = "f3392c4eeaff3dcb3a4825490c5c020b304b7390fafc32ef0301d798f1b8584a"

URI_x86_64_v2_rust-netlink-sys+mio_socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+mio_socket-devel-0.8.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+mio_socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+mio_socket-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+mio_socket-devel.sha256sum] = "d0397cd39aaaa1fa9016185f773418119189dc1e9535b2a6f50badfa4d240a1c"

URI_x86_64_v2_rust-netlink-sys+smol_socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+smol_socket-devel-0.8.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+smol_socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+smol_socket-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+smol_socket-devel.sha256sum] = "35fdd5de19512c063cf18d54d199d50e546eb37a25f2598575beb208e8c92182"

URI_x86_64_v2_rust-netlink-sys+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+tokio-devel-0.8.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+tokio-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+tokio-devel.sha256sum] = "2738197ab10742a357230db10fa3bb7327b214d362719b008cbff93207a459f8"

URI_x86_64_v2_rust-netlink-sys+tokio_socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys+tokio_socket-devel-0.8.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys+tokio_socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys+tokio_socket-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys+tokio_socket-devel.sha256sum] = "6afefc045650f9ab40d2973fe9377fb3fcb13f2872b33bb810bb399c8072df90"

URI_x86_64_v2_rust-netlink-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-sys-devel-0.8.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-sys-devel}"
SRC_URI[x86_64_v2_rust-netlink-sys-devel.sha256sum] = "999a19a92f51c2ee1d2b205bf904a3795b712900bd3f2ac08b96539856081b5b"

URI_aarch64_rust-netlink-sys+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+async-io-devel-0.8.7-2.el10_0.noarch.rpm;name=aarch64_rust-netlink-sys+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+async-io-devel}"
SRC_URI[aarch64_rust-netlink-sys+async-io-devel.sha256sum] = "018c9cbd1a027fe830e1c55ed0ed2981f4d711f02e57005de1378d361b442506"

URI_aarch64_rust-netlink-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+default-devel-0.8.7-2.el10_0.noarch.rpm;name=aarch64_rust-netlink-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+default-devel}"
SRC_URI[aarch64_rust-netlink-sys+default-devel.sha256sum] = "42d15fdce2b314f82f34bcd449e7c9d5a38927bb094cf3a3e2c5f50845ff1dc9"

URI_aarch64_rust-netlink-sys+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+futures-devel-0.8.7-2.el10_0.noarch.rpm;name=aarch64_rust-netlink-sys+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+futures-devel}"
SRC_URI[aarch64_rust-netlink-sys+futures-devel.sha256sum] = "cd03291cef3790af61643a28b62c5cdd558383c78f1a9e195e61e9d58c1e4fe9"

URI_aarch64_rust-netlink-sys+mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+mio-devel-0.8.7-2.el10_0.noarch.rpm;name=aarch64_rust-netlink-sys+mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+mio-devel}"
SRC_URI[aarch64_rust-netlink-sys+mio-devel.sha256sum] = "f3de46e9e9284dbdabff1546f9d09500fe3a9db96462efd374099b437e27b3cd"

URI_aarch64_rust-netlink-sys+mio_socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+mio_socket-devel-0.8.7-2.el10_0.noarch.rpm;name=aarch64_rust-netlink-sys+mio_socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+mio_socket-devel}"
SRC_URI[aarch64_rust-netlink-sys+mio_socket-devel.sha256sum] = "51a6ec0d625a44d4d94f7aa71a170223876320d6e2a85e68db6972f9f93899b9"

URI_aarch64_rust-netlink-sys+smol_socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+smol_socket-devel-0.8.7-2.el10_0.noarch.rpm;name=aarch64_rust-netlink-sys+smol_socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+smol_socket-devel}"
SRC_URI[aarch64_rust-netlink-sys+smol_socket-devel.sha256sum] = "fdb2d3d7b47c2998600fd348477c94d6c50f9ea0e12916d03ca8fc289c2f820a"

URI_aarch64_rust-netlink-sys+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+tokio-devel-0.8.7-2.el10_0.noarch.rpm;name=aarch64_rust-netlink-sys+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+tokio-devel}"
SRC_URI[aarch64_rust-netlink-sys+tokio-devel.sha256sum] = "1cd9dfb6c04d2dafcb42e9df8f9199178f2aa9d66b1167d6693f7798f016c76a"

URI_aarch64_rust-netlink-sys+tokio_socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys+tokio_socket-devel-0.8.7-2.el10_0.noarch.rpm;name=aarch64_rust-netlink-sys+tokio_socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys+tokio_socket-devel}"
SRC_URI[aarch64_rust-netlink-sys+tokio_socket-devel.sha256sum] = "1868af9071da995a02f8f62e8c31b7839901a89dfd5a40babc87b4b878b9fe5f"

URI_aarch64_rust-netlink-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-sys-devel-0.8.7-2.el10_0.noarch.rpm;name=aarch64_rust-netlink-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-sys-devel}"
SRC_URI[aarch64_rust-netlink-sys-devel.sha256sum] = "96bfd070899100123cd2cb9e813aeca606ff5d931b506f292c9e2f6e6d1abc4c"

RDEPENDS:rust-netlink-sys+async-io-devel = " \
 cargo \
 rust-async-io+default-devel \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys+default-devel = " \
 cargo \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys+futures-devel = " \
 cargo \
 rust-futures+default-devel \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys+mio-devel = " \
 cargo \
 rust-mio+default-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys+mio_socket-devel = " \
 cargo \
 rust-netlink-sys+mio-devel \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys+smol_socket-devel = " \
 cargo \
 rust-netlink-sys+async-io-devel \
 rust-netlink-sys+futures-devel \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys+tokio-devel = " \
 cargo \
 rust-netlink-sys-devel \
 rust-tokio+net-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-netlink-sys+tokio_socket-devel = " \
 cargo \
 rust-netlink-sys+futures-devel \
 rust-netlink-sys+tokio-devel \
 rust-netlink-sys-devel \
 "
RDEPENDS:rust-netlink-sys-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 "
