# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zlib-ng"
PV = "2.2.3"
PR = "1.el10"
PACKAGES = " \
 zlib-ng \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 zlib-ng-compat-static \
 zlib-ng-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/zlib-ng-2.2.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6fdbe5183ce8aa4ecf4a3e8ab3d2eceb2ae770c7f9c1df2832025bcc476e0e6"

URI_x86_64_v2_zlib-ng = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/zlib-ng-2.2.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_zlib-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zlib-ng}"
SRC_URI[x86_64_v2_zlib-ng.sha256sum] = "b45affe0338acfd049e64a520fe8f6671c0afa51427bfb2e72c16bf0ae328864"

URI_x86_64_v2_zlib-ng-compat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/zlib-ng-compat-2.2.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_zlib-ng-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zlib-ng-compat}"
SRC_URI[x86_64_v2_zlib-ng-compat.sha256sum] = "17bccac72ad9f6b68091227fa46d0f18b243be913c21ea5fee3fc6ac567489fc"

URI_x86_64_v2_zlib-ng-compat-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/zlib-ng-compat-devel-2.2.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_zlib-ng-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zlib-ng-compat-devel}"
SRC_URI[x86_64_v2_zlib-ng-compat-devel.sha256sum] = "4596a282fff2b1255f686afd85a1c74bdddd86daaa3b1cfb6133dee0c0e29ae0"

URI_x86_64_v2_zlib-ng-compat-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/zlib-ng-compat-static-2.2.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_zlib-ng-compat-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zlib-ng-compat-static}"
SRC_URI[x86_64_v2_zlib-ng-compat-static.sha256sum] = "56a52beb251bcb9543317a71d0365424c3c426676885563f3b9214ff3aeb29b7"

URI_x86_64_v2_zlib-ng-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/zlib-ng-devel-2.2.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zlib-ng-devel}"
SRC_URI[x86_64_v2_zlib-ng-devel.sha256sum] = "baefc4c645309398e58dcdf4d4dd261ccc64930c9d2a8051f9a1170192dd8d54"

URI_aarch64_zlib-ng = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/zlib-ng-2.2.3-1.el10.aarch64.rpm;name=aarch64_zlib-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_zlib-ng}"
SRC_URI[aarch64_zlib-ng.sha256sum] = "0f21a1791b41f429a34958d3e2fdac7b9d628e198b399ba72cb9139a547e60ad"

URI_aarch64_zlib-ng-compat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/zlib-ng-compat-2.2.3-1.el10.aarch64.rpm;name=aarch64_zlib-ng-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_zlib-ng-compat}"
SRC_URI[aarch64_zlib-ng-compat.sha256sum] = "97a1f9b6911699a7649a687370c21480af43364c8ae5942e9a8952dd4f5143cc"

URI_aarch64_zlib-ng-compat-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/zlib-ng-compat-devel-2.2.3-1.el10.aarch64.rpm;name=aarch64_zlib-ng-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zlib-ng-compat-devel}"
SRC_URI[aarch64_zlib-ng-compat-devel.sha256sum] = "42461e4dedb9322f63c6134b992710e41ba7b6405bd99d704102826a4f78be61"

URI_aarch64_zlib-ng-compat-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/zlib-ng-compat-static-2.2.3-1.el10.aarch64.rpm;name=aarch64_zlib-ng-compat-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_zlib-ng-compat-static}"
SRC_URI[aarch64_zlib-ng-compat-static.sha256sum] = "b7b452a710ae36d8d2b2387f70c363763d048d75ea10c20959e73ec5417e8c0e"

URI_aarch64_zlib-ng-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/zlib-ng-devel-2.2.3-1.el10.aarch64.rpm;name=aarch64_zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zlib-ng-devel}"
SRC_URI[aarch64_zlib-ng-devel.sha256sum] = "226a81fb4d3fd29cd2da278a84fb9cf2a8d7aab1292f93cd1dd35fbc1ee2559d"

RDEPENDS:zlib-ng = " \
 glibc \
 "
RDEPENDS:zlib-ng-compat = " \
 glibc \
 "
RDEPENDS:zlib-ng-compat-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 zlib-ng-compat \
 "
RDEPENDS:zlib-ng-compat-static = " \
 zlib-ng-compat-devel \
 "
RDEPENDS:zlib-ng-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 zlib-ng \
 "
