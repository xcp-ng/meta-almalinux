# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "conda"
PV = "26.1.1"
PR = "3.el10_2~bootstrap"
PACKAGES = " \
 conda \
 conda-tests \
 python3-conda \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/conda-26.1.1-3.el10_2~bootstrap.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "deb4c1502613e0772596ab3c85224392b28ad774a5610d239d2117c143f746d0"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3-conda: python3.12dist(archspec) >= 0.2.3

URI_aarch64_conda = "${EPEL_MIRROR}/aarch64/Packages/c/conda-26.1.1-3.el10_2~bootstrap.noarch.rpm;name=aarch64_conda;unpack=0"
SRC_URI:append = " ${URI_aarch64_conda}"
SRC_URI[aarch64_conda.sha256sum] = "79bac101ca7d49a9b31d4283353bc5b79c7642da39b2b213edfca3747a0f0fd2"

URI_aarch64_conda-tests = "${EPEL_MIRROR}/aarch64/Packages/c/conda-tests-26.1.1-3.el10_2~bootstrap.noarch.rpm;name=aarch64_conda-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_conda-tests}"
SRC_URI[aarch64_conda-tests.sha256sum] = "8fa7779a27ebb9d6853f6653f1129cde5f2ae0e26242d45b31026c86bb2412c2"

URI_aarch64_python3-conda = "${EPEL_MIRROR}/aarch64/Packages/p/python3-conda-26.1.1-3.el10_2~bootstrap.noarch.rpm;name=aarch64_python3-conda;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-conda}"
SRC_URI[aarch64_python3-conda.sha256sum] = "c511a16f9e108db34b306d370edc24f30f0dc8536dc474057d1322ae34cbcdc9"

RDEPENDS:conda = " \
 python3 \
 python3-conda \
 "
RDEPENDS:conda-tests = " \
 "
RDEPENDS:python3-conda = " \
 python3 \
 python3-boltons \
 python3-charset-normalizer \
 python3-conda-package-handling \
 python3-distro \
 python3-frozendict \
 python3-jsonpatch \
 python3-menuinst \
 python3-packaging \
 python3-platformdirs \
 python3-pluggy \
 python3-pycosat \
 python3-requests \
 python3-ruamel-yaml \
 python3-setuptools \
 python3-tqdm \
 python3-zstandard \
 "
