# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql-jdbc"
PV = "42.7.1"
PR = "8.el10"
PACKAGES = " \
 postgresql-jdbc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql-jdbc-42.7.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0a2c7d129893877c499295c8d4fc90f4ec75d4b6ff70411c703aa9604172970c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-jdbc-42.7.1-8.el10.noarch.rpm;name=x86_64_v2_postgresql-jdbc;unpack=0"
SRC_URI[x86_64_v2_postgresql-jdbc.sha256sum] = "7f79a09e81c48af1f79b007b5cef27ae2135eef373f2fa469700f718f1f9b320"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-jdbc-42.7.1-8.el10.noarch.rpm;name=aarch64_postgresql-jdbc;unpack=0"
SRC_URI[aarch64_postgresql-jdbc.sha256sum] = "7f79a09e81c48af1f79b007b5cef27ae2135eef373f2fa469700f718f1f9b320"

RDEPENDS:postgresql-jdbc = " \
 javapackages-filesystem \
 ongres-scram-client \
 "
