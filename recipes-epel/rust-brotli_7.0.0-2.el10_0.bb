# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-brotli"
PV = "7.0.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-brotli+alloc-stdlib-devel \
 rust-brotli+billing-devel \
 rust-brotli+default-devel \
 rust-brotli+disable-timer-devel \
 rust-brotli+disallow_large_window_size-devel \
 rust-brotli+external-literal-probability-devel \
 rust-brotli+ffi-api-devel \
 rust-brotli+float64-devel \
 rust-brotli+floating_point_context_mixing-devel \
 rust-brotli+no-stdlib-ffi-binding-devel \
 rust-brotli+pass-through-ffi-panics-devel \
 rust-brotli+seccomp-devel \
 rust-brotli+sha2-devel \
 rust-brotli+simd-devel \
 rust-brotli+std-devel \
 rust-brotli+validation-devel \
 rust-brotli+vector_scratch_space-devel \
 rust-brotli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-brotli-7.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a619db9e3b8939e77a79cf86344e7b0d7fe6d2cbf5b325a31b9017e2a96355b2"

URI_x86_64_v2_rust-brotli+alloc-stdlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+alloc-stdlib-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+alloc-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+alloc-stdlib-devel}"
SRC_URI[x86_64_v2_rust-brotli+alloc-stdlib-devel.sha256sum] = "c939207e1d3ef0feb61a3d88edda8828a1af787de1ac8e2b4149b4cb3927f283"

URI_x86_64_v2_rust-brotli+billing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+billing-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+billing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+billing-devel}"
SRC_URI[x86_64_v2_rust-brotli+billing-devel.sha256sum] = "917eee9f96304c2881274af506d55759cbd4e895e8480d72569d4e15686b31e4"

URI_x86_64_v2_rust-brotli+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+default-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+default-devel}"
SRC_URI[x86_64_v2_rust-brotli+default-devel.sha256sum] = "36cb9672e72cd7a6998feec9787da898204fc7680648f22ca5be5a72135e1486"

URI_x86_64_v2_rust-brotli+disable-timer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+disable-timer-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+disable-timer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+disable-timer-devel}"
SRC_URI[x86_64_v2_rust-brotli+disable-timer-devel.sha256sum] = "0a2e9de762e79ffb137ed0af934b7214807467911df14c4cd9d6369228acc742"

URI_x86_64_v2_rust-brotli+disallow_large_window_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+disallow_large_window_size-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+disallow_large_window_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+disallow_large_window_size-devel}"
SRC_URI[x86_64_v2_rust-brotli+disallow_large_window_size-devel.sha256sum] = "0096298e3f79f5f11dae7e5f7df1ba1f27aabacf6a3dcea58bf472efc6387040"

URI_x86_64_v2_rust-brotli+external-literal-probability-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+external-literal-probability-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+external-literal-probability-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+external-literal-probability-devel}"
SRC_URI[x86_64_v2_rust-brotli+external-literal-probability-devel.sha256sum] = "68a58dc981fe98a1c606c4758a54ac0449723d5d24e93fdeb1d144b298da7c45"

URI_x86_64_v2_rust-brotli+ffi-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+ffi-api-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+ffi-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+ffi-api-devel}"
SRC_URI[x86_64_v2_rust-brotli+ffi-api-devel.sha256sum] = "780916052bbe963ee912fa2ce8745626fcb163c29f5e2145ac5c40bf4b93987a"

URI_x86_64_v2_rust-brotli+float64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+float64-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+float64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+float64-devel}"
SRC_URI[x86_64_v2_rust-brotli+float64-devel.sha256sum] = "508058e394f62cca658a86f922f94a19b0352fa333d6c9be4b4c6edc54e4ad0f"

URI_x86_64_v2_rust-brotli+floating_point_context_mixing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+floating_point_context_mixing-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+floating_point_context_mixing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+floating_point_context_mixing-devel}"
SRC_URI[x86_64_v2_rust-brotli+floating_point_context_mixing-devel.sha256sum] = "049736cd34805201fb2ffedeb1777748dd2a7b636195fd6cb05d4cc050318908"

URI_x86_64_v2_rust-brotli+no-stdlib-ffi-binding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+no-stdlib-ffi-binding-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+no-stdlib-ffi-binding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+no-stdlib-ffi-binding-devel}"
SRC_URI[x86_64_v2_rust-brotli+no-stdlib-ffi-binding-devel.sha256sum] = "cd335f7012b8448ef6b77c6125b943fb2a69434991564771c2e6e3057a0cc2ba"

URI_x86_64_v2_rust-brotli+pass-through-ffi-panics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+pass-through-ffi-panics-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+pass-through-ffi-panics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+pass-through-ffi-panics-devel}"
SRC_URI[x86_64_v2_rust-brotli+pass-through-ffi-panics-devel.sha256sum] = "4b4ff1a0d4673bff33a502ecd7e39dc1caa20e9d725f22fb86543f3be68ab4ff"

URI_x86_64_v2_rust-brotli+seccomp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+seccomp-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+seccomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+seccomp-devel}"
SRC_URI[x86_64_v2_rust-brotli+seccomp-devel.sha256sum] = "308c9f8cab03d8daf97bc8af57629e95af42a73d886602a466f39b67f0630c71"

URI_x86_64_v2_rust-brotli+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+sha2-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+sha2-devel}"
SRC_URI[x86_64_v2_rust-brotli+sha2-devel.sha256sum] = "b6c58d423b07dfc9db09c727ea119218e019b5b945b20b18d0d223d53f962280"

URI_x86_64_v2_rust-brotli+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+simd-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+simd-devel}"
SRC_URI[x86_64_v2_rust-brotli+simd-devel.sha256sum] = "0001175558eb915d335c8f9fcf888c80eb88ea9cf10ffc03cdd6f66a2c826f8f"

URI_x86_64_v2_rust-brotli+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+std-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+std-devel}"
SRC_URI[x86_64_v2_rust-brotli+std-devel.sha256sum] = "f58ed702d1ff8d331e8d2cb5134ee068cc7cfe3372ae1a8e35c81d9c6c255dff"

URI_x86_64_v2_rust-brotli+validation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+validation-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+validation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+validation-devel}"
SRC_URI[x86_64_v2_rust-brotli+validation-devel.sha256sum] = "5afecdaeedf9fc2b62a9e6b7408d2fffba53c3073c5e131adb3dbbdce4f622f7"

URI_x86_64_v2_rust-brotli+vector_scratch_space-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+vector_scratch_space-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+vector_scratch_space-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+vector_scratch_space-devel}"
SRC_URI[x86_64_v2_rust-brotli+vector_scratch_space-devel.sha256sum] = "a1824299a04665a789f0ef7eaa8dcdffd9999c746e25a44ab24b625c3b9f8fe2"

URI_x86_64_v2_rust-brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-devel-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-devel}"
SRC_URI[x86_64_v2_rust-brotli-devel.sha256sum] = "aa3ca4e4736ff5957ad89caf037ceff96ba8bd2cee6dd41e02e3cd6200f9a070"

URI_aarch64_rust-brotli+alloc-stdlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+alloc-stdlib-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+alloc-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+alloc-stdlib-devel}"
SRC_URI[aarch64_rust-brotli+alloc-stdlib-devel.sha256sum] = "0d5a4543297c3a2bba27adeb4f4bd9d3be02930b80d93241812dd98f71cefacc"

URI_aarch64_rust-brotli+billing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+billing-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+billing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+billing-devel}"
SRC_URI[aarch64_rust-brotli+billing-devel.sha256sum] = "e33e061c0877882ce0bea69aa7bdafb154955965fcd7ec6f07392877b0be7804"

URI_aarch64_rust-brotli+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+default-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+default-devel}"
SRC_URI[aarch64_rust-brotli+default-devel.sha256sum] = "b329d2ade782a85ea86e4d9d204857a910c442c948bb79fbd1ca8245371aaaf5"

URI_aarch64_rust-brotli+disable-timer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+disable-timer-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+disable-timer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+disable-timer-devel}"
SRC_URI[aarch64_rust-brotli+disable-timer-devel.sha256sum] = "d620e80bac588adafb93c87c58fa4eb25471c45548831a7f858dc55db0c34789"

URI_aarch64_rust-brotli+disallow_large_window_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+disallow_large_window_size-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+disallow_large_window_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+disallow_large_window_size-devel}"
SRC_URI[aarch64_rust-brotli+disallow_large_window_size-devel.sha256sum] = "66aac93ac402914c375381e3079f1c335d626811d131303fb87b4bec42e3b00f"

URI_aarch64_rust-brotli+external-literal-probability-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+external-literal-probability-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+external-literal-probability-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+external-literal-probability-devel}"
SRC_URI[aarch64_rust-brotli+external-literal-probability-devel.sha256sum] = "76d3c64bff9723970eb06e7ce23370ea81b628b7529475f09813dc66d942bef4"

URI_aarch64_rust-brotli+ffi-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+ffi-api-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+ffi-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+ffi-api-devel}"
SRC_URI[aarch64_rust-brotli+ffi-api-devel.sha256sum] = "c3321c45e15b18bdcf15faa080304be577e51e087ef71dd8f66b05aae8891086"

URI_aarch64_rust-brotli+float64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+float64-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+float64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+float64-devel}"
SRC_URI[aarch64_rust-brotli+float64-devel.sha256sum] = "ffcc4d0359cc02c15a010563792b97e9ffc7f7626d1a67afbeb15c24a608f4ad"

URI_aarch64_rust-brotli+floating_point_context_mixing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+floating_point_context_mixing-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+floating_point_context_mixing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+floating_point_context_mixing-devel}"
SRC_URI[aarch64_rust-brotli+floating_point_context_mixing-devel.sha256sum] = "f3c21d1823f1ded95988d381e307c757279b6b1386cf028291427f06a869c759"

URI_aarch64_rust-brotli+no-stdlib-ffi-binding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+no-stdlib-ffi-binding-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+no-stdlib-ffi-binding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+no-stdlib-ffi-binding-devel}"
SRC_URI[aarch64_rust-brotli+no-stdlib-ffi-binding-devel.sha256sum] = "d387764905d0c2dd30607203f6b6d268c5c522b7fd7a9ea5431b9d898a95605c"

URI_aarch64_rust-brotli+pass-through-ffi-panics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+pass-through-ffi-panics-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+pass-through-ffi-panics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+pass-through-ffi-panics-devel}"
SRC_URI[aarch64_rust-brotli+pass-through-ffi-panics-devel.sha256sum] = "b533e14f66119864289e145dd2f02b704958042446aebb8500c026df5c2842ec"

URI_aarch64_rust-brotli+seccomp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+seccomp-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+seccomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+seccomp-devel}"
SRC_URI[aarch64_rust-brotli+seccomp-devel.sha256sum] = "ed31e76ce096cc07222f7c3e4cb10b6e4dd3884ed52f4c79b66bcfd5b0472f69"

URI_aarch64_rust-brotli+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+sha2-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+sha2-devel}"
SRC_URI[aarch64_rust-brotli+sha2-devel.sha256sum] = "0310a057f30c45cc27ba135efee9a4db7c1e848e1d8cf3553f18d82b8225f746"

URI_aarch64_rust-brotli+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+simd-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+simd-devel}"
SRC_URI[aarch64_rust-brotli+simd-devel.sha256sum] = "e5c67a9d3bc6738bdbc1e63edfe9aabf6f24a50529f66991e8653c332c6adca7"

URI_aarch64_rust-brotli+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+std-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+std-devel}"
SRC_URI[aarch64_rust-brotli+std-devel.sha256sum] = "5464d103bd288e517718316735bbb078654edcf4867b2c3118d60f23e7d7a663"

URI_aarch64_rust-brotli+validation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+validation-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+validation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+validation-devel}"
SRC_URI[aarch64_rust-brotli+validation-devel.sha256sum] = "2e1f1111b50521eed2ccd0f7b58dfdec6d05ee284b6d843b4c449d5ea7dad0e5"

URI_aarch64_rust-brotli+vector_scratch_space-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+vector_scratch_space-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli+vector_scratch_space-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+vector_scratch_space-devel}"
SRC_URI[aarch64_rust-brotli+vector_scratch_space-devel.sha256sum] = "79ebb58dc5a63ea3396a481e0a4d4ccd8dccbf98482346bc219fe184d701a69e"

URI_aarch64_rust-brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-devel-7.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-devel}"
SRC_URI[aarch64_rust-brotli-devel.sha256sum] = "55c0c3038bad79a8bc830cfbcb944c1562391cbd9965ea78ccfd135309bc9e42"

RDEPENDS:rust-brotli+alloc-stdlib-devel = " \
 cargo \
 rust-alloc-stdlib+default-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+billing-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+default-devel = " \
 cargo \
 rust-brotli+std-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+disable-timer-devel = " \
 cargo \
 rust-brotli-decompressor+disable-timer-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+disallow_large_window_size-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+external-literal-probability-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+ffi-api-devel = " \
 cargo \
 rust-brotli-decompressor+ffi-api-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+float64-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+floating_point_context_mixing-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+no-stdlib-ffi-binding-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+pass-through-ffi-panics-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+seccomp-devel = " \
 cargo \
 rust-brotli-decompressor+seccomp-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+sha2-devel = " \
 cargo \
 rust-brotli-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-brotli+simd-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+std-devel = " \
 cargo \
 rust-brotli+alloc-stdlib-devel \
 rust-brotli-decompressor+std-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+validation-devel = " \
 cargo \
 rust-brotli+sha2-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+vector_scratch_space-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli-devel = " \
 cargo \
 rust \
 rust-alloc-no-stdlib+default-devel \
 rust-brotli-decompressor-devel \
 "
