# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ignore"
PV = "0.4.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-ignore+default-devel \
 rust-ignore+simd-accel-devel \
 rust-ignore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ignore-0.4.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b8da7315fbab8dd8840f5a8c49d55310ad92af54f3966a7c52e4adbf702309a"

URI_x86_64_v2_rust-ignore+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ignore+default-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ignore+default-devel}"
SRC_URI[x86_64_v2_rust-ignore+default-devel.sha256sum] = "51bce39ef991d28a90746a44f38b72cb4d4ccb1b21c591ddd1f1e3681d2d3680"

URI_x86_64_v2_rust-ignore+simd-accel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ignore+simd-accel-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ignore+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ignore+simd-accel-devel}"
SRC_URI[x86_64_v2_rust-ignore+simd-accel-devel.sha256sum] = "f640a5e178d95e6830c4246299952f2086e7fbb31ef97f30a3b03c0d114f689a"

URI_x86_64_v2_rust-ignore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ignore-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ignore-devel}"
SRC_URI[x86_64_v2_rust-ignore-devel.sha256sum] = "71aefbcac1a6216028014a31da1eac793935ce466b62066ba17184736730f913"

URI_aarch64_rust-ignore+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ignore+default-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ignore+default-devel}"
SRC_URI[aarch64_rust-ignore+default-devel.sha256sum] = "cddac2980152e09f3305370e98538c2084aebaea0b39d5a3dbf93c6a07f5a3b9"

URI_aarch64_rust-ignore+simd-accel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ignore+simd-accel-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-ignore+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ignore+simd-accel-devel}"
SRC_URI[aarch64_rust-ignore+simd-accel-devel.sha256sum] = "67c78cec65dd8e5942d2e22532fec04f132601d77c063723eec66896184f9c3b"

URI_aarch64_rust-ignore-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ignore-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ignore-devel}"
SRC_URI[aarch64_rust-ignore-devel.sha256sum] = "8293a4279ee02f4212d67098825de0b9e77c659aed84e611a83640c247ab84ac"

RDEPENDS:rust-ignore+default-devel = " \
 cargo \
 rust-ignore-devel \
 "
RDEPENDS:rust-ignore+simd-accel-devel = " \
 cargo \
 rust-ignore-devel \
 "
RDEPENDS:rust-ignore-devel = " \
 cargo \
 rust \
 rust-crossbeam-deque+default-devel \
 rust-globset+default-devel \
 rust-log+default-devel \
 rust-memchr+default-devel \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 rust-same-file+default-devel \
 rust-walkdir+default-devel \
 "
