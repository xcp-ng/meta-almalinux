# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dymo-cups-drivers-lw5xx"
PV = "2.0.0.0"
PR = "1.el10_1"
PACKAGES = " \
 dymo-cups-drivers-lw5xx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dymo-cups-drivers-lw5xx-2.0.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "584e5bb758ec68a0eae54e160c47c0a039f0e4515ac5fef4692e3858698be63b"

URI_x86_64_v2_dymo-cups-drivers-lw5xx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dymo-cups-drivers-lw5xx-2.0.0.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dymo-cups-drivers-lw5xx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dymo-cups-drivers-lw5xx}"
SRC_URI[x86_64_v2_dymo-cups-drivers-lw5xx.sha256sum] = "0e25d10f2961971ef2b3e88a8a003897d9c29c07475c963185afc6055f8df202"

URI_aarch64_dymo-cups-drivers-lw5xx = "${EPEL_MIRROR}/aarch64/Packages/d/dymo-cups-drivers-lw5xx-2.0.0.0-1.el10_1.aarch64.rpm;name=aarch64_dymo-cups-drivers-lw5xx;unpack=0"
SRC_URI:append = " ${URI_aarch64_dymo-cups-drivers-lw5xx}"
SRC_URI[aarch64_dymo-cups-drivers-lw5xx.sha256sum] = "b205ab3bf1546ca85723b54a8bccbca34d95f9329ffb6f7e40f9b795d548ad1b"

RDEPENDS:dymo-cups-drivers-lw5xx = " \
 cups \
 cups-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
