# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openstep-plist"
PV = "0.5.2"
PR = "1.el10_1"
PACKAGES = " \
 python3-openstep-plist \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openstep-plist-0.5.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24f3af2378692358add681357743035c8b0567aa8d034f37be33e3247b924dff"

URI_x86_64_v2_python3-openstep-plist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openstep-plist-0.5.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-openstep-plist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openstep-plist}"
SRC_URI[x86_64_v2_python3-openstep-plist.sha256sum] = "4f7f880adbf02a6a0a4b75740d810793fd88a76f25d02d9adc27193e4e426605"

URI_aarch64_python3-openstep-plist = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openstep-plist-0.5.2-1.el10_1.aarch64.rpm;name=aarch64_python3-openstep-plist;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openstep-plist}"
SRC_URI[aarch64_python3-openstep-plist.sha256sum] = "9177c888d59a6123263621ed54fd080429d04abf83c2839baa7f4b6cb8fc8c5f"

RDEPENDS:python3-openstep-plist = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
