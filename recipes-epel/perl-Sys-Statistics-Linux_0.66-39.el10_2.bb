# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-Statistics-Linux"
PV = "0.66"
PR = "39.el10_2"
PACKAGES = " \
 perl-Sys-Statistics-Linux \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-Statistics-Linux-0.66-39.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c1c3942f6333fc676343e8ab6df40b3e959142aa37fe850de404ed3af607167f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-Statistics-Linux-0.66-39.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sys-Statistics-Linux;unpack=0"
SRC_URI[x86_64_v2_perl-Sys-Statistics-Linux.sha256sum] = "333d39def32b7ce5797642672e313ef657decfb847d1c9c4b648b414e8e328ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-Statistics-Linux-0.66-39.el10_2.noarch.rpm;name=aarch64_perl-Sys-Statistics-Linux;unpack=0"
SRC_URI[aarch64_perl-Sys-Statistics-Linux.sha256sum] = "7b558212919ee5c65f322129749485651ab5ecc4e552921b649b97c5d208620d"

RDEPENDS:perl-Sys-Statistics-Linux = " \
 perl-Carp \
 perl-POSIX \
 perl-Sys-Statistics-Linux \
 perl-Time-HiRes \
 perl-constant \
 perl-libs \
 "
