# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rsa"
PV = "0.9.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-rsa+default-devel \
 rust-rsa+getrandom-devel \
 rust-rsa+hazmat-devel \
 rust-rsa+pem-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+serde-devel \
 rust-rsa+sha1-devel \
 rust-rsa+sha2-devel \
 rust-rsa+std-devel \
 rust-rsa+u64_digit-devel \
 rust-rsa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rsa-0.9.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5dbdda01194e6149bb87ff7ae34693f2ad7da85174141ecacb3edad0c1970910"

URI_x86_64_v2_rust-rsa+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+default-devel-0.9.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+default-devel}"
SRC_URI[x86_64_v2_rust-rsa+default-devel.sha256sum] = "595f9944523e049364d0b11407e5452ed3d580985e00f4a66ac1d57f41118820"

URI_x86_64_v2_rust-rsa+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+getrandom-devel-0.9.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+getrandom-devel}"
SRC_URI[x86_64_v2_rust-rsa+getrandom-devel.sha256sum] = "fb6f2496d2eb89bca763215fc87417b341954a0a4ec1e8f38ce8e29c226baaf6"

URI_x86_64_v2_rust-rsa+hazmat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+hazmat-devel-0.9.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+hazmat-devel}"
SRC_URI[x86_64_v2_rust-rsa+hazmat-devel.sha256sum] = "627ca2ef4dcab274a930ff493d309463aab8c97581537bf983b2c6e7eafb1655"

URI_x86_64_v2_rust-rsa+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+pem-devel-0.9.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+pem-devel}"
SRC_URI[x86_64_v2_rust-rsa+pem-devel.sha256sum] = "baf8d829597934c62e6e9a13f8b47703a1f3ee738bace2f47765099ec54a07e2"

URI_x86_64_v2_rust-rsa+pkcs5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+pkcs5-devel-0.9.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+pkcs5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+pkcs5-devel}"
SRC_URI[x86_64_v2_rust-rsa+pkcs5-devel.sha256sum] = "36410dbc1bd0764f11c2ee817f892bfd6eb64f5952479ac9ba88c38c5168619d"

URI_x86_64_v2_rust-rsa+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+serde-devel-0.9.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+serde-devel}"
SRC_URI[x86_64_v2_rust-rsa+serde-devel.sha256sum] = "075d30389cfe74b28918f3f63ec3ef69a2000218b26d3b228261145362ce2460"

URI_x86_64_v2_rust-rsa+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+sha1-devel-0.9.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+sha1-devel}"
SRC_URI[x86_64_v2_rust-rsa+sha1-devel.sha256sum] = "a23fa14efe12137effdcca5f10effe50efc2702765f7511c1bdd3e47e57ebfef"

URI_x86_64_v2_rust-rsa+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+sha2-devel-0.9.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+sha2-devel}"
SRC_URI[x86_64_v2_rust-rsa+sha2-devel.sha256sum] = "8a2ddc51c6a7eca90476dc5dcdddbcd64ecfc3f71e941eefebcc44f1d7e3d287"

URI_x86_64_v2_rust-rsa+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+std-devel-0.9.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+std-devel}"
SRC_URI[x86_64_v2_rust-rsa+std-devel.sha256sum] = "2781ee1d8ad277968082274dcf12ff40ca413de9a64dbccbff21da30e6ac9a4a"

URI_x86_64_v2_rust-rsa+u64_digit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa+u64_digit-devel-0.9.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa+u64_digit-devel}"
SRC_URI[x86_64_v2_rust-rsa+u64_digit-devel.sha256sum] = "1c53639a583a5429a46bb442dee9b01ce754a1fecc0bd3effabf3fd4a986c3f9"

URI_x86_64_v2_rust-rsa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsa-devel-0.9.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsa-devel}"
SRC_URI[x86_64_v2_rust-rsa-devel.sha256sum] = "01708d78a0e5ac848063f5cff42ced742fc5ed3e0b12ccf7b67ffeb699ad86b3"

URI_aarch64_rust-rsa+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+default-devel-0.9.8-1.el10_0.noarch.rpm;name=aarch64_rust-rsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+default-devel}"
SRC_URI[aarch64_rust-rsa+default-devel.sha256sum] = "337c978a10ad8b5f3bc9b65ce379d38f98ca5d19f1f88d88116e9d50b31a611c"

URI_aarch64_rust-rsa+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+getrandom-devel-0.9.8-1.el10_0.noarch.rpm;name=aarch64_rust-rsa+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+getrandom-devel}"
SRC_URI[aarch64_rust-rsa+getrandom-devel.sha256sum] = "af3d8097907c6c7f48f862e93bdce062262cd07ab1c448b6a49827cc34e1d591"

URI_aarch64_rust-rsa+hazmat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+hazmat-devel-0.9.8-1.el10_0.noarch.rpm;name=aarch64_rust-rsa+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+hazmat-devel}"
SRC_URI[aarch64_rust-rsa+hazmat-devel.sha256sum] = "93a5353274712c88d563f97fa7c4c57ae64b5df37f8b1a1f1e7da9a2abc4ae7c"

URI_aarch64_rust-rsa+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+pem-devel-0.9.8-1.el10_0.noarch.rpm;name=aarch64_rust-rsa+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+pem-devel}"
SRC_URI[aarch64_rust-rsa+pem-devel.sha256sum] = "e578ba72240c7d60f7c42141044dc0038eb076ac3e74ee1d06b6e743042501a2"

URI_aarch64_rust-rsa+pkcs5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+pkcs5-devel-0.9.8-1.el10_0.noarch.rpm;name=aarch64_rust-rsa+pkcs5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+pkcs5-devel}"
SRC_URI[aarch64_rust-rsa+pkcs5-devel.sha256sum] = "f9e42476fa5964813a221bc45fcb466ee03efd9759f016f4276ba969040d5b37"

URI_aarch64_rust-rsa+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+serde-devel-0.9.8-1.el10_0.noarch.rpm;name=aarch64_rust-rsa+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+serde-devel}"
SRC_URI[aarch64_rust-rsa+serde-devel.sha256sum] = "480b491c039975d35c34d25037ab201fc237d6299ae8cf499f2a392d630b14c8"

URI_aarch64_rust-rsa+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+sha1-devel-0.9.8-1.el10_0.noarch.rpm;name=aarch64_rust-rsa+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+sha1-devel}"
SRC_URI[aarch64_rust-rsa+sha1-devel.sha256sum] = "0b5712f358b475fb23dfd8399f20673a6e19b6defdc502531afb9ae2f22c719f"

URI_aarch64_rust-rsa+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+sha2-devel-0.9.8-1.el10_0.noarch.rpm;name=aarch64_rust-rsa+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+sha2-devel}"
SRC_URI[aarch64_rust-rsa+sha2-devel.sha256sum] = "f9758afb32deaeddecbf1ec0ac8823f07a7e3914e011f55881bb59571119aa68"

URI_aarch64_rust-rsa+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+std-devel-0.9.8-1.el10_0.noarch.rpm;name=aarch64_rust-rsa+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+std-devel}"
SRC_URI[aarch64_rust-rsa+std-devel.sha256sum] = "03edab77f771dac9c11a01e75083f46527ae95991239b11a5520eeb12faf48a3"

URI_aarch64_rust-rsa+u64_digit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa+u64_digit-devel-0.9.8-1.el10_0.noarch.rpm;name=aarch64_rust-rsa+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa+u64_digit-devel}"
SRC_URI[aarch64_rust-rsa+u64_digit-devel.sha256sum] = "2e3d21ac3a267355c10f50cda08deb61d4a240b85167d8e56b1d975790406a16"

URI_aarch64_rust-rsa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsa-devel-0.9.8-1.el10_0.noarch.rpm;name=aarch64_rust-rsa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsa-devel}"
SRC_URI[aarch64_rust-rsa-devel.sha256sum] = "a98232a95b9ddf78fea52665ca3a9024b172b2ade59b43af9dd55eb7e5772ffc"

RDEPENDS:rust-rsa+default-devel = " \
 cargo \
 rust-rsa+pem-devel \
 rust-rsa+std-devel \
 rust-rsa+u64_digit-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+getrandom-devel = " \
 cargo \
 rust-rand_core0.6+getrandom-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+hazmat-devel = " \
 cargo \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+pem-devel = " \
 cargo \
 rust-pkcs1+pem-devel \
 rust-pkcs8+pem-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+pkcs5-devel = " \
 cargo \
 rust-pkcs8+encryption-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa+serde-devel = " \
 cargo \
 rust-num-bigint-dig+serde-devel \
 rust-rsa-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rsa+sha1-devel = " \
 cargo \
 rust-rsa-devel \
 rust-sha1+oid-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-rsa+sha2-devel = " \
 cargo \
 rust-rsa-devel \
 rust-sha2+oid-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-rsa+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-pkcs1+std-devel \
 rust-pkcs8+std-devel \
 rust-rand_core0.6+std-devel \
 rust-rsa-devel \
 rust-signature+std-devel \
 "
RDEPENDS:rust-rsa+u64_digit-devel = " \
 cargo \
 rust-num-bigint-dig+u64_digit-devel \
 rust-rsa-devel \
 "
RDEPENDS:rust-rsa-devel = " \
 cargo \
 rust \
 rust-const-oid-devel \
 rust-digest+alloc-devel \
 rust-digest+oid-devel \
 rust-digest-devel \
 rust-num-bigint-dig+i128-devel \
 rust-num-bigint-dig+prime-devel \
 rust-num-bigint-dig+zeroize-devel \
 rust-num-bigint-dig-devel \
 rust-num-integer-devel \
 rust-num-traits+libm-devel \
 rust-num-traits-devel \
 rust-pkcs1+alloc-devel \
 rust-pkcs1+pkcs8-devel \
 rust-pkcs1-devel \
 rust-pkcs8+alloc-devel \
 rust-pkcs8-devel \
 rust-rand_core0.6-devel \
 rust-signature+alloc-devel \
 rust-signature+digest-devel \
 rust-signature+rand_core-devel \
 rust-signature-devel \
 rust-spki+alloc-devel \
 rust-spki-devel \
 rust-subtle-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize+default-devel \
 "
