# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-core"
PV = "0.3.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-core+alloc-devel \
 rust-futures-core+cfg-target-has-atomic-devel \
 rust-futures-core+default-devel \
 rust-futures-core+portable-atomic-devel \
 rust-futures-core+std-devel \
 rust-futures-core+unstable-devel \
 rust-futures-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-core-0.3.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a24af68c5955233c28ff3850d483340ab39527d1070f92057856fb443b93d27"

URI_x86_64_v2_rust-futures-core+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+alloc-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-core+alloc-devel.sha256sum] = "d23665ab675436b8cc803ac2ec330631f2a4c08558f8628ee39d03c342af06dd"

URI_x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+cfg-target-has-atomic-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel.sha256sum] = "f7c1dbadcddd31d806529dd0bf9fb8fcdd1b85bf190e77d4738a32e9490dec43"

URI_x86_64_v2_rust-futures-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+default-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+default-devel}"
SRC_URI[x86_64_v2_rust-futures-core+default-devel.sha256sum] = "47a4206adbfda0e4f4b60e234a8786969450f9b5f298cc835f760b833eeaf17c"

URI_x86_64_v2_rust-futures-core+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+portable-atomic-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-core+portable-atomic-devel.sha256sum] = "d9ede82e4aa4312dbfc342257e4590758ec7ad5fb79ebdf246f13d676d6036d4"

URI_x86_64_v2_rust-futures-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+std-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+std-devel}"
SRC_URI[x86_64_v2_rust-futures-core+std-devel.sha256sum] = "be847ede073417272e85587a11aa24faeb4afe1982d26fab4ffae510f3afd86b"

URI_x86_64_v2_rust-futures-core+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+unstable-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-core+unstable-devel.sha256sum] = "1f719d23f5d20f7d5aa60280ec1387a27fcb6095c5ff92b0614d3c138e50bbb5"

URI_x86_64_v2_rust-futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core-devel}"
SRC_URI[x86_64_v2_rust-futures-core-devel.sha256sum] = "3634e565ed0c6e34725e69fd3c0eb6e02177942e53a8453343749d9897acff66"

URI_aarch64_rust-futures-core+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+alloc-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+alloc-devel}"
SRC_URI[aarch64_rust-futures-core+alloc-devel.sha256sum] = "ff8aca9dab048705030b052feb8c4f91a58d6691b25302766fe5eb555c61f15a"

URI_aarch64_rust-futures-core+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+cfg-target-has-atomic-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures-core+cfg-target-has-atomic-devel.sha256sum] = "c9559ab2f7ccf706b00b2ceabc8f0181ae29bda4b9d83968d8b167fc40b1aa6b"

URI_aarch64_rust-futures-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+default-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+default-devel}"
SRC_URI[aarch64_rust-futures-core+default-devel.sha256sum] = "403803d5ec6c14c6f9ab241461027bdcc36a7af23ec37fc23eb18430c0db9f1b"

URI_aarch64_rust-futures-core+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+portable-atomic-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+portable-atomic-devel}"
SRC_URI[aarch64_rust-futures-core+portable-atomic-devel.sha256sum] = "e5fffabbaeb27972c89f870829e17a5bc93f967aa8519189a61abb17e4568db6"

URI_aarch64_rust-futures-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+std-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+std-devel}"
SRC_URI[aarch64_rust-futures-core+std-devel.sha256sum] = "cee0d3c6ce6d08d4a9a548f133c056033e70eb9a0c12d9dea19addc91cd02c88"

URI_aarch64_rust-futures-core+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+unstable-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+unstable-devel}"
SRC_URI[aarch64_rust-futures-core+unstable-devel.sha256sum] = "4fa259effff27bdabe16a2e087520b011d7fddea9ce9ee14fc2b41628bad1475"

URI_aarch64_rust-futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core-devel}"
SRC_URI[aarch64_rust-futures-core-devel.sha256sum] = "16eba99499b906cac973dddbb37f528f543cf467044dd6c77de431ec5fe679e5"

RDEPENDS:rust-futures-core+alloc-devel = " \
 cargo \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+default-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+portable-atomic-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-futures-core+std-devel = " \
 cargo \
 rust-futures-core+alloc-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+unstable-devel = " \
 cargo \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core-devel = " \
 cargo \
 rust \
 "
