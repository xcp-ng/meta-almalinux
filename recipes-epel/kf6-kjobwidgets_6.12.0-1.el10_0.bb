# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kjobwidgets"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kjobwidgets \
 kf6-kjobwidgets-devel \
 kf6-kjobwidgets-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kjobwidgets-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "712ab472cc35efb04c77c7bc0ae05e74594165db51a00214b7cb7d9468daa839"

URI_x86_64_v2_kf6-kjobwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets}"
SRC_URI[x86_64_v2_kf6-kjobwidgets.sha256sum] = "78cfaea80cb29702cdf64a7dd04dade6e3700a8285ff6aa6f442658654783a00"

URI_x86_64_v2_kf6-kjobwidgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kjobwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets-devel}"
SRC_URI[x86_64_v2_kf6-kjobwidgets-devel.sha256sum] = "03c81ea9656c3d8c3d0099edc8c173450290c47b8954c70c4fc5c778cc637c11"

URI_x86_64_v2_kf6-kjobwidgets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kjobwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets-doc}"
SRC_URI[x86_64_v2_kf6-kjobwidgets-doc.sha256sum] = "838e1105d019dfd449eefc9b959515e3a60f785cea823b1fb24e3f6787ffa0e8"

URI_aarch64_kf6-kjobwidgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets}"
SRC_URI[aarch64_kf6-kjobwidgets.sha256sum] = "6d79553515c1d28e6739f49f515ef8e68d70629b3d337b097253b5395a6f66ec"

URI_aarch64_kf6-kjobwidgets-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kjobwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets-devel}"
SRC_URI[aarch64_kf6-kjobwidgets-devel.sha256sum] = "ac75f4726aa073667a9983edea6c2706f83eeb4a1efef22ddd09cdac66c2144d"

URI_aarch64_kf6-kjobwidgets-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kjobwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets-doc}"
SRC_URI[aarch64_kf6-kjobwidgets-doc.sha256sum] = "62d43e01973ca650e7f585139c6bc69e5465182427bc79d89c8a6948c39070b2"

RDEPENDS:kf6-kjobwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kjobwidgets-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kjobwidgets \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kjobwidgets-doc = " \
 "
