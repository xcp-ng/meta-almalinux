# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-generic-deriving"
PV = "1.14.5"
PR = "1.el10_0"
PACKAGES = " \
 ghc-generic-deriving \
 ghc-generic-deriving-devel \
 ghc-generic-deriving-doc \
 ghc-generic-deriving-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-generic-deriving-1.14.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e559179fb0b41a4231dea1b1522701698af3fba75daa94d78a1174fd19393815"

URI_x86_64_v2_ghc-generic-deriving = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-generic-deriving-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-generic-deriving;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-generic-deriving}"
SRC_URI[x86_64_v2_ghc-generic-deriving.sha256sum] = "90d0914949170c58aa4eef5b22a924c80f2824540319b0f81a4373d40c7b385c"

URI_x86_64_v2_ghc-generic-deriving-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-generic-deriving-devel-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-generic-deriving-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-generic-deriving-devel}"
SRC_URI[x86_64_v2_ghc-generic-deriving-devel.sha256sum] = "32451a3b02949d8db33ca9bb44e1b8312884be9f1f1547771fdd23e6a46158e4"

URI_x86_64_v2_ghc-generic-deriving-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-generic-deriving-doc-1.14.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-generic-deriving-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-generic-deriving-doc}"
SRC_URI[x86_64_v2_ghc-generic-deriving-doc.sha256sum] = "fd1c10e29c26713720f392cb876c6ff20c97294d6ba7bacb06517710418248c3"

URI_x86_64_v2_ghc-generic-deriving-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-generic-deriving-prof-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-generic-deriving-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-generic-deriving-prof}"
SRC_URI[x86_64_v2_ghc-generic-deriving-prof.sha256sum] = "feb0a13112fde955170ad8bd2f6e448d4088d8a21f011f907c2ffe19dea05205"

URI_aarch64_ghc-generic-deriving = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-generic-deriving-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-generic-deriving;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-generic-deriving}"
SRC_URI[aarch64_ghc-generic-deriving.sha256sum] = "b7e1b881a0a5bd66ee46aad75bdfab4282393743ea6ef58cbb2ffcadd0d9c664"

URI_aarch64_ghc-generic-deriving-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-generic-deriving-devel-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-generic-deriving-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-generic-deriving-devel}"
SRC_URI[aarch64_ghc-generic-deriving-devel.sha256sum] = "7a0d96452b965f665ef78214fc817f80d09984e667fe1739a8f99e2cbf2aae8f"

URI_aarch64_ghc-generic-deriving-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-generic-deriving-doc-1.14.5-1.el10_0.noarch.rpm;name=aarch64_ghc-generic-deriving-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-generic-deriving-doc}"
SRC_URI[aarch64_ghc-generic-deriving-doc.sha256sum] = "2f78e8d38f941e65996a272f40ae96f708d8632a0b1981145639786609f54d4e"

URI_aarch64_ghc-generic-deriving-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-generic-deriving-prof-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-generic-deriving-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-generic-deriving-prof}"
SRC_URI[aarch64_ghc-generic-deriving-prof.sha256sum] = "ff65bfef75bf71f63fee979618e61498a91f304628d36c828adaa0dec1ab6752"

RDEPENDS:ghc-generic-deriving = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-th-abstraction \
 glibc \
 gmp \
 "
RDEPENDS:ghc-generic-deriving-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-generic-deriving \
 ghc-template-haskell-devel \
 ghc-th-abstraction-devel \
 "
RDEPENDS:ghc-generic-deriving-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-generic-deriving-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-generic-deriving-devel \
 ghc-template-haskell-prof \
 ghc-th-abstraction-prof \
 "
