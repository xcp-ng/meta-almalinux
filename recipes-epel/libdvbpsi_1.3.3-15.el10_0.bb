# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdvbpsi"
PV = "1.3.3"
PR = "15.el10_0"
PACKAGES = " \
 libdvbpsi \
 libdvbpsi-devel \
 libdvbpsi-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdvbpsi-1.3.3-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ce66070f6c69fef91f42218ebd17ea8b9bae1f4d4276e9335c9f5df48eb27ef"

URI_x86_64_v2_libdvbpsi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdvbpsi-1.3.3-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdvbpsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdvbpsi}"
SRC_URI[x86_64_v2_libdvbpsi.sha256sum] = "8686ce1b609c78c53c75072eae1d5f3065166336e3e372ed42373256937c9728"

URI_x86_64_v2_libdvbpsi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdvbpsi-devel-1.3.3-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdvbpsi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdvbpsi-devel}"
SRC_URI[x86_64_v2_libdvbpsi-devel.sha256sum] = "a6f68597791ab731d3930a1a115a08a612673dd111e0c8fd262f01ff3cf3a86d"

URI_x86_64_v2_libdvbpsi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdvbpsi-doc-1.3.3-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdvbpsi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdvbpsi-doc}"
SRC_URI[x86_64_v2_libdvbpsi-doc.sha256sum] = "c2cecf5ec0160d4d83578c0c4454344c5a388c369176c6a8ce9ae9b8ad888762"

URI_aarch64_libdvbpsi = "${EPEL_MIRROR}/aarch64/Packages/l/libdvbpsi-1.3.3-15.el10_0.aarch64.rpm;name=aarch64_libdvbpsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdvbpsi}"
SRC_URI[aarch64_libdvbpsi.sha256sum] = "252fd58f6cecdc2a9f6e1c4f8b43891a4af3b60ad5c3f845ac3ce457990fc3c6"

URI_aarch64_libdvbpsi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdvbpsi-devel-1.3.3-15.el10_0.aarch64.rpm;name=aarch64_libdvbpsi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdvbpsi-devel}"
SRC_URI[aarch64_libdvbpsi-devel.sha256sum] = "10405c725d6373637bd4b090a5870671752cf82189f24f3b5f7710a307cc33c8"

URI_aarch64_libdvbpsi-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libdvbpsi-doc-1.3.3-15.el10_0.aarch64.rpm;name=aarch64_libdvbpsi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdvbpsi-doc}"
SRC_URI[aarch64_libdvbpsi-doc.sha256sum] = "33b80cd3f5372643b56bd823746b2f02a8d74653a5bd140e304f914bd22cf4c1"

RDEPENDS:libdvbpsi = " \
 glibc \
 "
RDEPENDS:libdvbpsi-devel = " \
 libdvbpsi \
 pkgconf-pkg-config \
 "
RDEPENDS:libdvbpsi-doc = " \
 "
