# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "popt"
PV = "1.19"
PR = "8.el10"
PACKAGES = " \
 popt \
 popt-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/popt-1.19-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "758bf7a5844f0fc68a48a983b38e9710d242edce4ede3e6078018d13f2a1e35c"

URI_x86_64_v2_popt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/popt-1.19-8.el10.x86_64_v2.rpm;name=x86_64_v2_popt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_popt}"
SRC_URI[x86_64_v2_popt.sha256sum] = "778ac5db7f98f3168d2410e4d4c9cdd0541ec51166dbc66f0147843b9fde6643"

URI_x86_64_v2_popt-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/popt-devel-1.19-8.el10.x86_64_v2.rpm;name=x86_64_v2_popt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_popt-devel}"
SRC_URI[x86_64_v2_popt-devel.sha256sum] = "812bc231904453c84e4e988ca5b6ad1939f0a643ca9a7b1c3714edfb6bec1868"

URI_aarch64_popt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/popt-1.19-8.el10.aarch64.rpm;name=aarch64_popt;unpack=0"
SRC_URI:append = " ${URI_aarch64_popt}"
SRC_URI[aarch64_popt.sha256sum] = "675764511e80bf3e9515b824072389d7a658ce2b7f513dde6f516122496cfd25"

URI_aarch64_popt-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/popt-devel-1.19-8.el10.aarch64.rpm;name=aarch64_popt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_popt-devel}"
SRC_URI[aarch64_popt-devel.sha256sum] = "8f0b16204c547205071e3b3bcf3f55d97521444db5a9c56760212156d90b7907"

RDEPENDS:popt = " \
 glibc \
 "
RDEPENDS:popt-devel = " \
 pkgconf-pkg-config \
 popt \
 "
