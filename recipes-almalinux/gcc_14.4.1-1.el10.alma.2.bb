# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc"
PV = "14.4.1"
PR = "1.el10.alma.2"
PACKAGES:x86_64_v2 = " \
 cpp \
 gcc \
 gcc-c++ \
 gcc-gfortran \
 gcc-offload-amdgcn \
 gcc-offload-nvptx \
 gcc-plugin-annobin \
 gcc-plugin-devel \
 libasan \
 libatomic \
 libgcc \
 libgccjit \
 libgccjit-devel \
 libgfortran \
 libgfortran-static \
 libgomp \
 libgomp-offload-amdgcn \
 libgomp-offload-nvptx \
 libhwasan \
 libitm \
 libitm-devel \
 liblsan \
 libquadmath \
 libquadmath-devel \
 libquadmath-static \
 libstdc++ \
 libstdc++-devel \
 libstdc++-docs \
 libstdc++-static \
 libtsan \
 libubsan \
"
PACKAGES:aarch64 = " \
 cpp \
 gcc \
 gcc-c++ \
 gcc-gfortran \
 gcc-plugin-annobin \
 gcc-plugin-devel \
 libasan \
 libatomic \
 libgcc \
 libgccjit \
 libgccjit-devel \
 libgfortran \
 libgfortran-static \
 libgomp \
 libhwasan \
 libitm \
 libitm-devel \
 liblsan \
 libstdc++ \
 libstdc++-devel \
 libstdc++-docs \
 libstdc++-static \
 libtsan \
 libubsan \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gcc-14.4.1-1.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3cdd105f035dd0500c2c6acc437b55517bd76594145c6f019f7e67a15f7c132"

URI_x86_64_v2_cpp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cpp-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpp}"
SRC_URI[x86_64_v2_cpp.sha256sum] = "6d6833b4623cf0d7971ce9a5cbfc81fdd2377e24b8adb6a2e7d37bd9e3429a31"

URI_x86_64_v2_gcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc}"
SRC_URI[x86_64_v2_gcc.sha256sum] = "bab4879e3057046aa7c046d2673ea2e6191e7f229526d6f51d8fb932891fd0a1"

URI_x86_64_v2_gcc-c++ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-c++-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++}"
SRC_URI[x86_64_v2_gcc-c++.sha256sum] = "0e3f32754dff76a3ec41df0a76b8ab0c0c1329f8811b028f85f50044218fe0a7"

URI_x86_64_v2_gcc-gfortran = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-gfortran-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-gfortran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-gfortran}"
SRC_URI[x86_64_v2_gcc-gfortran.sha256sum] = "9fa654d0a40a1be6a016eeba9bb3313a847c9cd65e7e4bab91fd48149625e5bf"

URI_x86_64_v2_gcc-offload-amdgcn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-offload-amdgcn-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-offload-amdgcn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-offload-amdgcn}"
SRC_URI[x86_64_v2_gcc-offload-amdgcn.sha256sum] = "fa43d64af99072fab563a8daebeb7b3da25b7d320408f6f4b6b967cf7f026093"

URI_x86_64_v2_gcc-offload-nvptx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-offload-nvptx-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-offload-nvptx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-offload-nvptx}"
SRC_URI[x86_64_v2_gcc-offload-nvptx.sha256sum] = "30afea4303eb881236da83e79028f07c871fb134f6562f34de11b39cdae39f85"

URI_x86_64_v2_gcc-plugin-annobin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-plugin-annobin-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-plugin-annobin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-plugin-annobin}"
SRC_URI[x86_64_v2_gcc-plugin-annobin.sha256sum] = "3a5c5a1d7e5abdcda528021abc9f6518f3241318e2b7c8fdf385d486b1c20bd0"

URI_x86_64_v2_gcc-plugin-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-plugin-devel-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-plugin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-plugin-devel}"
SRC_URI[x86_64_v2_gcc-plugin-devel.sha256sum] = "1dd651a26455c0eed5ab13b1848ec475604dec9acbbf92f86ade1b119a4aac07"

URI_x86_64_v2_libasan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libasan-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libasan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libasan}"
SRC_URI[x86_64_v2_libasan.sha256sum] = "46591873959ac9bf30052740d3b96d3966b935bbb698aff115d2a6732d4bc2f4"

URI_x86_64_v2_libatomic = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libatomic-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libatomic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libatomic}"
SRC_URI[x86_64_v2_libatomic.sha256sum] = "95bdb83004b768ab9ee92930c0d069eec8054aa3cbcc8a8b620fd573158c0dff"

URI_x86_64_v2_libgcc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgcc-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgcc}"
SRC_URI[x86_64_v2_libgcc.sha256sum] = "fd3b22561430bfe35c0f7e465a9cf5167825db38c8fdf06566749a85e3f4e6f4"

URI_x86_64_v2_libgccjit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgccjit-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgccjit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgccjit}"
SRC_URI[x86_64_v2_libgccjit.sha256sum] = "5cefad1dd886aceeb36ea8ee9a1e28d506389e041bb40d3f3e5c6baa1b7536b8"
RPROVIDES:libgccjit:x86_64_v2 = "virtual/libgccjit.so.0___64bit_"

URI_x86_64_v2_libgccjit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgccjit-devel-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgccjit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgccjit-devel}"
SRC_URI[x86_64_v2_libgccjit-devel.sha256sum] = "d98f4f522cdf813b6e838823b70f40f1beb707f078eebb31390b04715029cb8c"

URI_x86_64_v2_libgfortran = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgfortran-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgfortran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgfortran}"
SRC_URI[x86_64_v2_libgfortran.sha256sum] = "c03391a2921d664cf62c2f75012c316b69bcd306094a1d3789200ef16deef8d8"

URI_x86_64_v2_libgfortran-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgfortran-static-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgfortran-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgfortran-static}"
SRC_URI[x86_64_v2_libgfortran-static.sha256sum] = "5cba3131cfd2f824460360f3ff4694977a83ff2ddd23a3f59d1897a1cc741216"

URI_x86_64_v2_libgomp = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgomp-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgomp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgomp}"
SRC_URI[x86_64_v2_libgomp.sha256sum] = "fd2994c6c9c071d1b3c34493b1b063fb4ffcc15562c16e13d96b5531dee94f0f"

URI_x86_64_v2_libgomp-offload-amdgcn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgomp-offload-amdgcn-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgomp-offload-amdgcn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgomp-offload-amdgcn}"
SRC_URI[x86_64_v2_libgomp-offload-amdgcn.sha256sum] = "075aad9768b739650c705b836cdf556ade19888ce98bfad188b55ca2b545129a"

URI_x86_64_v2_libgomp-offload-nvptx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgomp-offload-nvptx-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgomp-offload-nvptx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgomp-offload-nvptx}"
SRC_URI[x86_64_v2_libgomp-offload-nvptx.sha256sum] = "68b898e5e4471ecaaaabe3b51bd28b297459f6351e480b97550cca2d9c6f01f0"

URI_x86_64_v2_libhwasan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libhwasan-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libhwasan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libhwasan}"
SRC_URI[x86_64_v2_libhwasan.sha256sum] = "2d9be670d0551a62fc6be7bab7243363182e288e986c1de578f0c4d808bcb548"

URI_x86_64_v2_libitm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libitm-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libitm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libitm}"
SRC_URI[x86_64_v2_libitm.sha256sum] = "c5997f60cd94f9a500d4e44062a6c20fc937c64dada39e43d7a738a58ac9d567"

URI_x86_64_v2_libitm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libitm-devel-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libitm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libitm-devel}"
SRC_URI[x86_64_v2_libitm-devel.sha256sum] = "7ab538464661ab8080bd23586866e81f1134e2c96716bd5ca0a257ad9fff584b"

URI_x86_64_v2_liblsan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liblsan-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_liblsan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblsan}"
SRC_URI[x86_64_v2_liblsan.sha256sum] = "092355e2b561244f4376bd6f0141049bd6640d934bd1eb185d630a8ae5f2e041"

URI_x86_64_v2_libquadmath = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libquadmath-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libquadmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquadmath}"
SRC_URI[x86_64_v2_libquadmath.sha256sum] = "cd77c4c8c4806833d031cb5b8bf9f97afb1038826147c6bb1824ce4b26094700"

URI_x86_64_v2_libquadmath-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libquadmath-devel-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libquadmath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquadmath-devel}"
SRC_URI[x86_64_v2_libquadmath-devel.sha256sum] = "1edce116607ef8c34faa380e77699e047b640b1eb677aa8d842b55a08be1a9fb"

URI_x86_64_v2_libquadmath-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libquadmath-static-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libquadmath-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquadmath-static}"
SRC_URI[x86_64_v2_libquadmath-static.sha256sum] = "de6a68e726a3cf05c62d2f8689f3253e8c1d7b99abe51487725c4b76ae2261a0"

URI_x86_64_v2_libstdc++ = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libstdc++-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libstdc++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++}"
SRC_URI[x86_64_v2_libstdc++.sha256sum] = "cc38a639b4cdff1a504075ea98bca246a99e93378aea099346890c8e55deb761"

URI_x86_64_v2_libstdc++-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstdc++-devel-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++-devel}"
SRC_URI[x86_64_v2_libstdc++-devel.sha256sum] = "98a05c812190003c5f378ceed5cfcb6cb983514c8425cfc5027f10f07fff3e74"

URI_x86_64_v2_libstdc++-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstdc++-docs-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libstdc++-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++-docs}"
SRC_URI[x86_64_v2_libstdc++-docs.sha256sum] = "6dc09960d5be7c900199ad45ed82bb87eafdadf5448b2770571be6d803dce851"

URI_x86_64_v2_libstdc++-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libstdc++-static-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libstdc++-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++-static}"
SRC_URI[x86_64_v2_libstdc++-static.sha256sum] = "7a01a54f96be59aa540b4b3cc938f33b5d903a5d095fd09bb35b2cc7df7d2bad"

URI_x86_64_v2_libtsan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtsan-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libtsan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtsan}"
SRC_URI[x86_64_v2_libtsan.sha256sum] = "47fdc9d4f65cb19c4d88fc7abb754470430386b65b9620d3cc5a6964ade8c729"

URI_x86_64_v2_libubsan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libubsan-14.4.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libubsan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libubsan}"
SRC_URI[x86_64_v2_libubsan.sha256sum] = "67726926974e786e95903ed19785c91a175f76fd7eeafa36cb5156a706ab92f1"

URI_aarch64_cpp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cpp-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpp}"
SRC_URI[aarch64_cpp.sha256sum] = "dcc1a387b9a49fe695626c091147c4bdf90d4a98bf033b71497b0f59e8d5d719"

URI_aarch64_gcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc}"
SRC_URI[aarch64_gcc.sha256sum] = "3667ba0449932292e8c35b51b8913ae4c7ebd4c6a5837d64e02b14650376aecc"

URI_aarch64_gcc-c++ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-c++-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_gcc-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++}"
SRC_URI[aarch64_gcc-c++.sha256sum] = "f702322100a1c089d84e8d434134b91b4a0bab6f447b24bce73d5848b6f22120"

URI_aarch64_gcc-gfortran = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-gfortran-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_gcc-gfortran;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-gfortran}"
SRC_URI[aarch64_gcc-gfortran.sha256sum] = "4dd87fba40defb7c2840f8958275282a69398b5f3b65a2386ba3a40da512477e"

URI_aarch64_gcc-plugin-annobin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-plugin-annobin-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_gcc-plugin-annobin;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-plugin-annobin}"
SRC_URI[aarch64_gcc-plugin-annobin.sha256sum] = "fcb9a04e26755504aeb95af61587c70aed325278e42af0621066adbf79ce9ae8"

URI_aarch64_gcc-plugin-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-plugin-devel-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_gcc-plugin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-plugin-devel}"
SRC_URI[aarch64_gcc-plugin-devel.sha256sum] = "2a34a58ff9e72338440eef9347121be891578cb47d58c8f08149340215efadf9"

URI_aarch64_libasan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libasan-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libasan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libasan}"
SRC_URI[aarch64_libasan.sha256sum] = "0c7ea9e7e1c12f0814cfa3378e021a0c51aaa116e7d84d68c7fb934bf08d3156"

URI_aarch64_libatomic = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libatomic-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libatomic;unpack=0"
SRC_URI:append = " ${URI_aarch64_libatomic}"
SRC_URI[aarch64_libatomic.sha256sum] = "e13bb7816093e91ebad18380b203321347bbdad1917ea12457d504088b22d48f"

URI_aarch64_libgcc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgcc-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libgcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgcc}"
SRC_URI[aarch64_libgcc.sha256sum] = "4ebec449ee979b48aab83f1b4b646793e3c557d56f7e48ae4099edfedcd0b7a2"

URI_aarch64_libgccjit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgccjit-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libgccjit;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgccjit}"
SRC_URI[aarch64_libgccjit.sha256sum] = "d1fbfa4f6ed27cb2318c8425cf23de308d4c86c40a7d28bb55dc1aa5bd590b0a"
RPROVIDES:libgccjit:aarch64 = "virtual/libgccjit.so.0___64bit_"

URI_aarch64_libgccjit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgccjit-devel-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libgccjit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgccjit-devel}"
SRC_URI[aarch64_libgccjit-devel.sha256sum] = "f090dda7082ee984005d0f83b3b34b1975c6bbbb15f92f3bb5f05d69b1c74405"

URI_aarch64_libgfortran = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgfortran-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libgfortran;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgfortran}"
SRC_URI[aarch64_libgfortran.sha256sum] = "8695b2b9517d63feb993d8170909038986e75990434826fe950c81971465c3eb"

URI_aarch64_libgfortran-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgfortran-static-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libgfortran-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgfortran-static}"
SRC_URI[aarch64_libgfortran-static.sha256sum] = "576a003c4842ec3ef3063167153da6fbec3b3eba7acb80b31392357973b3387b"

URI_aarch64_libgomp = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgomp-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libgomp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgomp}"
SRC_URI[aarch64_libgomp.sha256sum] = "fe7ba32d302d5aab53aaaed5139787b3b5d3f9768a2282f70bbcb7255be58b0f"

URI_aarch64_libhwasan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libhwasan-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libhwasan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libhwasan}"
SRC_URI[aarch64_libhwasan.sha256sum] = "f6c94767139cab07826a53ea8d69137d641fbb45d719c854cf33c0ec7d5781ab"

URI_aarch64_libitm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libitm-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libitm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libitm}"
SRC_URI[aarch64_libitm.sha256sum] = "e125a3ff47b487fae04ad9ea9572e4a7c922da129ccbc18379a0450592a708b2"

URI_aarch64_libitm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libitm-devel-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libitm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libitm-devel}"
SRC_URI[aarch64_libitm-devel.sha256sum] = "a5f316cdea47a31fda6696eae4ac8dd8b951909e8c233ff59ab1d3016092b207"

URI_aarch64_liblsan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liblsan-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_liblsan;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblsan}"
SRC_URI[aarch64_liblsan.sha256sum] = "ad56250e263878399fd4cb184dc99a208f073fa92a1d7983aac994edb950bc10"

URI_aarch64_libstdc++ = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libstdc++-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libstdc++;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++}"
SRC_URI[aarch64_libstdc++.sha256sum] = "d2c3d2d71c6bea37df9db2307aa69d3a864a3d61767abaf60c80f24b1375e941"

URI_aarch64_libstdc++-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstdc++-devel-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++-devel}"
SRC_URI[aarch64_libstdc++-devel.sha256sum] = "9070e9359cbfc4f9581c5666931f21387248df8cd859a11182f7944768b08ffc"

URI_aarch64_libstdc++-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstdc++-docs-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libstdc++-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++-docs}"
SRC_URI[aarch64_libstdc++-docs.sha256sum] = "3b84cb7ef0def3eb390ad186ed78320f91f6446ac103342c2799d35a101a0482"

URI_aarch64_libstdc++-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libstdc++-static-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libstdc++-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++-static}"
SRC_URI[aarch64_libstdc++-static.sha256sum] = "24b10b9478928801be80e4e82bc4332602759d4013c362c81262dc4fdd568e09"

URI_aarch64_libtsan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtsan-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libtsan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtsan}"
SRC_URI[aarch64_libtsan.sha256sum] = "aad908739562e02d45f83dbe53a30a418204a2fa6d693dc035b62c79f248c102"

URI_aarch64_libubsan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libubsan-14.4.1-1.el10.alma.2.aarch64.rpm;name=aarch64_libubsan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libubsan}"
SRC_URI[aarch64_libubsan.sha256sum] = "1f76f94d687adf615062bb837c7282e91883a24cb36ff538d23fb3bd845ddcc6"

RDEPENDS:cpp = " \
 filesystem \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc:x86_64_v2 = " \
 bash \
 binutils \
 cpp \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc:aarch64 = " \
 bash \
 binutils \
 cpp \
 glibc \
 glibc-devel \
 gmp \
 libasan \
 libatomic \
 libgcc \
 libgomp \
 libmpc \
 libubsan \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-c++ = " \
 gcc \
 glibc \
 gmp \
 libmpc \
 libstdc++ \
 libstdc++-devel \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-gfortran:x86_64_v2 = " \
 gcc \
 glibc \
 gmp \
 libgfortran \
 libmpc \
 libquadmath \
 libquadmath-devel \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-gfortran:aarch64 = " \
 gcc \
 glibc \
 gmp \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-offload-amdgcn = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-amdgcn \
 libmpc \
 libstdc++ \
 libzstd \
 lld \
 llvm \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-offload-nvptx = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-nvptx \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-plugin-annobin = " \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gcc-plugin-devel = " \
 gcc \
 glibc \
 gmp-devel \
 libmpc-devel \
 mpfr-devel \
 "
RDEPENDS:libasan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libatomic = " \
 glibc \
 "
RDEPENDS:libgcc = " \
 "
RDEPENDS:libgccjit = " \
 gcc \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:libgccjit-devel = " \
 libgccjit \
 virtual/libgccjit.so.0___64bit_ \
 "
RDEPENDS:libgfortran = " \
 glibc \
 libgcc \
 "
RDEPENDS:libgfortran-static:x86_64_v2 = " \
 gcc \
 libgfortran \
 libquadmath-static \
"
RDEPENDS:libgfortran-static:aarch64 = " \
 gcc \
 libgfortran \
"
RDEPENDS:libgomp = " \
 glibc \
 "
RDEPENDS:libgomp-offload-amdgcn = " \
 glibc \
 libgomp \
 "
RDEPENDS:libgomp-offload-nvptx = " \
 glibc \
 libgomp \
 "
RDEPENDS:libhwasan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libitm = " \
 glibc \
 "
RDEPENDS:libitm-devel = " \
 gcc \
 libitm \
 "
RDEPENDS:liblsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libquadmath = " \
 glibc \
 libgcc \
 "
RDEPENDS:libquadmath-devel = " \
 gcc \
 libquadmath \
 "
RDEPENDS:libquadmath-static = " \
 libquadmath-devel \
 "
RDEPENDS:libstdc++ = " \
 glibc \
 libgcc \
 "
RDEPENDS:libstdc++-devel = " \
 libstdc++ \
 "
RDEPENDS:libstdc++-docs = " \
 "
RDEPENDS:libstdc++-static = " \
 libstdc++-devel \
 "
RDEPENDS:libtsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libubsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libgccjit.so.0___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libgccjit.so.0___64bit_"
