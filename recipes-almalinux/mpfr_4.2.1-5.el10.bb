# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mpfr"
PV = "4.2.1"
PR = "5.el10"
PACKAGES = " \
 mpfr \
 mpfr-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mpfr-4.2.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "513a7c3f0fc0dfd0fd54bd9a13aba2207bab4f6a7aec20c6de513efaf96eb437"

URI_x86_64_v2_mpfr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mpfr-4.2.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_mpfr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpfr}"
SRC_URI[x86_64_v2_mpfr.sha256sum] = "4aba1c9d70985c0bf3dfb238bb83231ffd96cf17c593c2e33def3b61e206df1b"

URI_x86_64_v2_mpfr-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mpfr-devel-4.2.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_mpfr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpfr-devel}"
SRC_URI[x86_64_v2_mpfr-devel.sha256sum] = "ac23f0268bf528f80504a60fd35bef4d656bc9b516614882079df0e21f204339"

URI_aarch64_mpfr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mpfr-4.2.1-5.el10.aarch64.rpm;name=aarch64_mpfr;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpfr}"
SRC_URI[aarch64_mpfr.sha256sum] = "f0eaa0bd497f9f462796dc59698e6b7e8fc783fd1eae973d37fbee5d1b442b69"

URI_aarch64_mpfr-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mpfr-devel-4.2.1-5.el10.aarch64.rpm;name=aarch64_mpfr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpfr-devel}"
SRC_URI[aarch64_mpfr-devel.sha256sum] = "226a994e43e787243657d8db60411f41e698f300dedb1d3cee0a31e01554132e"

RDEPENDS:mpfr = " \
 glibc \
 gmp \
 "
RDEPENDS:mpfr-devel = " \
 gmp-devel \
 mpfr \
 pkgconf-pkg-config \
 "
