# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jobserver"
PV = "0.1.34"
PR = "1.el10_0"
PACKAGES = " \
 rust-jobserver+default-devel \
 rust-jobserver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jobserver-0.1.34-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02b2d45de3c4fe5ddec49a78aea3b2f71017ad51f6cdbc9344667866291b32f1"

URI_x86_64_v2_rust-jobserver+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jobserver+default-devel-0.1.34-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jobserver+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jobserver+default-devel}"
SRC_URI[x86_64_v2_rust-jobserver+default-devel.sha256sum] = "90f245b8e7efcac1a119ded6c60098c14d442a24174df5869c6b9d48901ac991"

URI_x86_64_v2_rust-jobserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jobserver-devel-0.1.34-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jobserver-devel}"
SRC_URI[x86_64_v2_rust-jobserver-devel.sha256sum] = "208be6dfc7c65d4279adbf20ef56a690a655c1a36dfc4de8447d8d46d9941193"

URI_aarch64_rust-jobserver+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jobserver+default-devel-0.1.34-1.el10_0.noarch.rpm;name=aarch64_rust-jobserver+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jobserver+default-devel}"
SRC_URI[aarch64_rust-jobserver+default-devel.sha256sum] = "5d14ace9675b476b692fb9688cd899afd38549511d05832436b0617827173feb"

URI_aarch64_rust-jobserver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jobserver-devel-0.1.34-1.el10_0.noarch.rpm;name=aarch64_rust-jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jobserver-devel}"
SRC_URI[aarch64_rust-jobserver-devel.sha256sum] = "a5362a6476332311dba1a26b22b70b71502b45ab80a95d589626541018e4f164"

RDEPENDS:rust-jobserver+default-devel = " \
 cargo \
 rust-jobserver-devel \
 "
RDEPENDS:rust-jobserver-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
