# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sfnt2woff-zopfli"
PV = "1.3.1"
PR = "15.el10_0"
PACKAGES = " \
 sfnt2woff-zopfli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sfnt2woff-zopfli-1.3.1-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b93972fc9a9bf1647ad71552bfe27afa279abe4925b622937003f24a10aa75f3"

URI_x86_64_v2_sfnt2woff-zopfli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sfnt2woff-zopfli-1.3.1-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sfnt2woff-zopfli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sfnt2woff-zopfli}"
SRC_URI[x86_64_v2_sfnt2woff-zopfli.sha256sum] = "4be1e4b520d873216230631ef71350921676350b1453e461c391a973e8755c89"

URI_aarch64_sfnt2woff-zopfli = "${EPEL_MIRROR}/aarch64/Packages/s/sfnt2woff-zopfli-1.3.1-15.el10_0.aarch64.rpm;name=aarch64_sfnt2woff-zopfli;unpack=0"
SRC_URI:append = " ${URI_aarch64_sfnt2woff-zopfli}"
SRC_URI[aarch64_sfnt2woff-zopfli.sha256sum] = "f9521919f6f871356912a00577e1131ef1b6ac60bde2e90077e9a287146b083f"

RDEPENDS:sfnt2woff-zopfli = " \
 glibc \
 zlib-ng-compat \
 zopfli \
 "
