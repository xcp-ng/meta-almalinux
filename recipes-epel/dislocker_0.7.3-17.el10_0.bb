# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dislocker"
PV = "0.7.3"
PR = "17.el10_0"
PACKAGES = " \
 dislocker \
 dislocker-libs \
 fuse-dislocker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dislocker-0.7.3-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9721f3b0c99fbe3c5f11a194c77a9aac74f9e587f6701f3c44d887dcd3531c89"

URI_x86_64_v2_dislocker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dislocker-0.7.3-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dislocker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dislocker}"
SRC_URI[x86_64_v2_dislocker.sha256sum] = "8aa7be83f1829399d36fde62e42b7fadce6e4b26161aee3df298f671f3fa0e89"

URI_x86_64_v2_dislocker-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dislocker-libs-0.7.3-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dislocker-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dislocker-libs}"
SRC_URI[x86_64_v2_dislocker-libs.sha256sum] = "81e8246e630beab209ac1b54ab4926107da5ed7b0298b7c362635cc5378f28ac"

URI_x86_64_v2_fuse-dislocker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fuse-dislocker-0.7.3-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fuse-dislocker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fuse-dislocker}"
SRC_URI[x86_64_v2_fuse-dislocker.sha256sum] = "b6dffffc70580e8157eea704079f7ff6e1aea2947b8d98b9daf0eb861faf4ac3"

URI_aarch64_dislocker = "${EPEL_MIRROR}/aarch64/Packages/d/dislocker-0.7.3-17.el10_0.aarch64.rpm;name=aarch64_dislocker;unpack=0"
SRC_URI:append = " ${URI_aarch64_dislocker}"
SRC_URI[aarch64_dislocker.sha256sum] = "9e6031a1a7d22f2a4edc857944123c26a0213887ee68be8146737eb943f2f261"

URI_aarch64_dislocker-libs = "${EPEL_MIRROR}/aarch64/Packages/d/dislocker-libs-0.7.3-17.el10_0.aarch64.rpm;name=aarch64_dislocker-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_dislocker-libs}"
SRC_URI[aarch64_dislocker-libs.sha256sum] = "eb5d9d46ee47b741d60123dce1cbff04e0566aabcb8cdbaae60d374f72d861af"

URI_aarch64_fuse-dislocker = "${EPEL_MIRROR}/aarch64/Packages/f/fuse-dislocker-0.7.3-17.el10_0.aarch64.rpm;name=aarch64_fuse-dislocker;unpack=0"
SRC_URI:append = " ${URI_aarch64_fuse-dislocker}"
SRC_URI[aarch64_fuse-dislocker.sha256sum] = "47123aec2a4e053c8ffc471c2d80302f1a71f7593081f982672cfdb0ba347e1e"

RDEPENDS:dislocker = " \
 alternatives \
 bash \
 dislocker-libs \
 glibc \
 ruby \
 ruby-libs \
 "
RDEPENDS:dislocker-libs = " \
 glibc \
 mbedtls \
 ruby-libs \
 "
RDEPENDS:fuse-dislocker = " \
 alternatives \
 bash \
 dislocker-libs \
 fuse-libs \
 glibc \
 "
