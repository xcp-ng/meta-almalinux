# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "meow"
PV = "2.1.5"
PR = "1.el10_2"
PACKAGES = " \
 meow \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/meow-2.1.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23f4301ac1da4b84d1f475b38b7d7d66a0d8faa661bdc139998b90b046fdeac9"

URI_x86_64_v2_meow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/meow-2.1.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_meow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_meow}"
SRC_URI[x86_64_v2_meow.sha256sum] = "fb9fad819300091693e2820a65f08c7d52f033c7a23b27f770ef5529215b6a65"

URI_aarch64_meow = "${EPEL_MIRROR}/aarch64/Packages/m/meow-2.1.5-1.el10_2.aarch64.rpm;name=aarch64_meow;unpack=0"
SRC_URI:append = " ${URI_aarch64_meow}"
SRC_URI[aarch64_meow.sha256sum] = "ab36084d3be8dce0deed3f45c9781020ec04df718775220122d11ba495993a02"

RDEPENDS:meow = " \
 glibc \
 libgcc \
 "
