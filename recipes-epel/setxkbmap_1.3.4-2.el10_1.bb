# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setxkbmap"
PV = "1.3.4"
PR = "2.el10_1"
PACKAGES = " \
 setxkbmap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/setxkbmap-1.3.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ec63e9be84f28955de6a7f690f7754882606158ccad9f27356b5e6b0944b6f6"

URI_x86_64_v2_setxkbmap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/setxkbmap-1.3.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_setxkbmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setxkbmap}"
SRC_URI[x86_64_v2_setxkbmap.sha256sum] = "5d19c484cd1273ed7c41e99ae25cd7566d56c860067fb48ad7e9c9e1a0e92e78"

URI_aarch64_setxkbmap = "${EPEL_MIRROR}/aarch64/Packages/s/setxkbmap-1.3.4-2.el10_1.aarch64.rpm;name=aarch64_setxkbmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_setxkbmap}"
SRC_URI[aarch64_setxkbmap.sha256sum] = "3815d4be28ed466e8b05e954b3db3d5e5bdd0297fc9bc9ab820f5e1631ec7ae4"

RDEPENDS:setxkbmap = " \
 glibc \
 libX11 \
 libXrandr \
 libxkbfile \
 "
