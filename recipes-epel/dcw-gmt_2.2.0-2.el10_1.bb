# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dcw-gmt"
PV = "2.2.0"
PR = "2.el10_1"
PACKAGES = " \
 dcw-gmt \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dcw-gmt-2.2.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e1a51c4838d4ae11381d2c7cbb361f50b1c39a5771dae5d3b6818fc844bafeb4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dcw-gmt-2.2.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_dcw-gmt;unpack=0"
SRC_URI[x86_64_v2_dcw-gmt.sha256sum] = "5dca0cad155a412622d3aacd93a98cef3ae1b1b8bb603b7bac37d8462e6d9777"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dcw-gmt-2.2.0-2.el10_1.noarch.rpm;name=aarch64_dcw-gmt;unpack=0"
SRC_URI[aarch64_dcw-gmt.sha256sum] = "7b15958bec3a4d60e8607b458d4e3845c56185edf22aa946efc91d29cbcb47bf"

RDEPENDS:dcw-gmt = " \
 "
