# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serdect0.2"
PV = "0.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-serdect0.2+alloc-devel \
 rust-serdect0.2+default-devel \
 rust-serdect0.2+zeroize-devel \
 rust-serdect0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serdect0.2-0.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f2490ac9a171bd4793193088e66e7f493fdeeede070435a2690677387f751a7"

URI_x86_64_v2_rust-serdect0.2+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serdect0.2+alloc-devel-0.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serdect0.2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serdect0.2+alloc-devel}"
SRC_URI[x86_64_v2_rust-serdect0.2+alloc-devel.sha256sum] = "e414f3429321b2eda6165309347796d1dc04d155bdde57493acb420aa60cb59a"

URI_x86_64_v2_rust-serdect0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serdect0.2+default-devel-0.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serdect0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serdect0.2+default-devel}"
SRC_URI[x86_64_v2_rust-serdect0.2+default-devel.sha256sum] = "c27f34e7ae905bfb1df493986ceed24ffa62c0b1d8899f879cfba0167664d57b"

URI_x86_64_v2_rust-serdect0.2+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serdect0.2+zeroize-devel-0.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serdect0.2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serdect0.2+zeroize-devel}"
SRC_URI[x86_64_v2_rust-serdect0.2+zeroize-devel.sha256sum] = "c39fdada046cbd6294e2e939c774cb8e98223d882d4e8fbee7268b6f823e258b"

URI_x86_64_v2_rust-serdect0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serdect0.2-devel-0.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serdect0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serdect0.2-devel}"
SRC_URI[x86_64_v2_rust-serdect0.2-devel.sha256sum] = "173107ba25c61f28e69a5876e477071037da24d51c6b317c6c6a162fc7c21908"

URI_aarch64_rust-serdect0.2+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serdect0.2+alloc-devel-0.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-serdect0.2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serdect0.2+alloc-devel}"
SRC_URI[aarch64_rust-serdect0.2+alloc-devel.sha256sum] = "3d771f8079a7848fec6962b72a7cbc419752da2a55ed069044a9f75e4fca4530"

URI_aarch64_rust-serdect0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serdect0.2+default-devel-0.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-serdect0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serdect0.2+default-devel}"
SRC_URI[aarch64_rust-serdect0.2+default-devel.sha256sum] = "4fd012b74b5a1d59a49934c12e0c5509c3601413ddf9a7602f5e9f3d7a584da9"

URI_aarch64_rust-serdect0.2+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serdect0.2+zeroize-devel-0.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-serdect0.2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serdect0.2+zeroize-devel}"
SRC_URI[aarch64_rust-serdect0.2+zeroize-devel.sha256sum] = "fb22d58feacce3ce294d2dbdaefd9ab7c95a6e3d3c7c79daaa3edd3248bc4d90"

URI_aarch64_rust-serdect0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serdect0.2-devel-0.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-serdect0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serdect0.2-devel}"
SRC_URI[aarch64_rust-serdect0.2-devel.sha256sum] = "32e225f7311524e88d2d38170c5708a17409b1d4e575fb0963404d0fedceaf8c"

RDEPENDS:rust-serdect0.2+alloc-devel = " \
 cargo \
 rust-base16ct0.2+alloc-devel \
 rust-serde+alloc-devel \
 rust-serdect0.2-devel \
 "
RDEPENDS:rust-serdect0.2+default-devel = " \
 cargo \
 rust-serdect0.2+alloc-devel \
 rust-serdect0.2-devel \
 "
RDEPENDS:rust-serdect0.2+zeroize-devel = " \
 cargo \
 rust-serdect0.2-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-serdect0.2-devel = " \
 cargo \
 rust \
 rust-base16ct0.2-devel \
 rust-serde-devel \
 "
