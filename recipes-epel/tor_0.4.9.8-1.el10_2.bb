# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tor"
PV = "0.4.9.8"
PR = "1.el10_2"
PACKAGES = " \
 tor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tor-0.4.9.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2e0685dec9fc840c370329c7e1a347f4a9883054e4100c3ffd6e9656459bc26"

URI_x86_64_v2_tor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tor-0.4.9.8-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tor}"
SRC_URI[x86_64_v2_tor.sha256sum] = "a1a0f4e218bc35ebd4a371aa18b67ac2a9bac155022e0c459569fc719937745b"

URI_aarch64_tor = "${EPEL_MIRROR}/aarch64/Packages/t/tor-0.4.9.8-1.el10_2.aarch64.rpm;name=aarch64_tor;unpack=0"
SRC_URI:append = " ${URI_aarch64_tor}"
SRC_URI[aarch64_tor.sha256sum] = "af9f537af1e9bfe9ddc902249073e431f5ced523d0452f1197113df6debf56a5"

RDEPENDS:tor = " \
 bash \
 glibc \
 libcap \
 libevent \
 libgcc \
 libseccomp \
 libzstd \
 openssl-libs \
 shadow-utils \
 systemd-libs \
 torsocks \
 xz-libs \
 zlib-ng-compat \
 "
