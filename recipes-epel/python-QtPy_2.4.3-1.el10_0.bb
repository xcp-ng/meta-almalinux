# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-QtPy"
PV = "2.4.3"
PR = "1.el10_0"
PACKAGES = " \
 python3-QtPy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-QtPy-2.4.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea0e4b3808a6418aa1f215ac9a7adc687ed77e800e4291508fc3a5bb05eb3aa8"

URI_x86_64_v2_python3-QtPy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-QtPy-2.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-QtPy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-QtPy}"
SRC_URI[x86_64_v2_python3-QtPy.sha256sum] = "af3d0186396dcd5ab141605873dff3f28af4ebddacb7762167962f57a4aa3322"

URI_aarch64_python3-QtPy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-QtPy-2.4.3-1.el10_0.noarch.rpm;name=aarch64_python3-QtPy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-QtPy}"
SRC_URI[aarch64_python3-QtPy.sha256sum] = "fae9bd664c16f19bdb255d7ecae61e576ee16cd9193a7eb6a0cbd56b8aafcbf4"

RDEPENDS:python3-QtPy = " \
 python3 \
 python3-packaging \
 "
