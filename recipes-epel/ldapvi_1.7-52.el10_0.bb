# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ldapvi"
PV = "1.7"
PR = "52.el10_0"
PACKAGES = " \
 ldapvi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/ldapvi-1.7-52.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "721a490fe11b27ebd5093d11f259285c6e90575630f7aac1f685bac5de4e1896"

URI_x86_64_v2_ldapvi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ldapvi-1.7-52.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ldapvi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldapvi}"
SRC_URI[x86_64_v2_ldapvi.sha256sum] = "8d5a5ebf269e8bc67151e6dd4c124b5c568bd6ae9ae8e642854025bfca9abcd9"

URI_aarch64_ldapvi = "${EPEL_MIRROR}/aarch64/Packages/l/ldapvi-1.7-52.el10_0.aarch64.rpm;name=aarch64_ldapvi;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldapvi}"
SRC_URI[aarch64_ldapvi.sha256sum] = "d2acffcfe8b2899c03de8382989e362b908bb074143e6b9b5db91a68c3f230de"

RDEPENDS:ldapvi = " \
 glib2 \
 glibc \
 libxcrypt \
 ncurses-libs \
 openldap \
 openssl-libs \
 popt \
 readline \
 "
