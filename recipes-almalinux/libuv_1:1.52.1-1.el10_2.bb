# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libuv"
PE = "1"
PV = "1.52.1"
PR = "1.el10_2"
PACKAGES = " \
 libuv \
 libuv-devel \
 libuv-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libuv-1.52.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57f2155e9dd3e1fc80c4d6b9b47fa14d972ac4fd33ae497e63aec145b523470d"

URI_x86_64_v2_libuv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuv-1.52.1-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libuv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuv}"
SRC_URI[x86_64_v2_libuv.sha256sum] = "8df2bd3890bf9d47de15ca5e6056b439cd515ee7786d139f6b1f285dce1a4e21"

URI_x86_64_v2_libuv-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuv-devel-1.52.1-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libuv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuv-devel}"
SRC_URI[x86_64_v2_libuv-devel.sha256sum] = "8fc766f863d0eea4c94b21bcd170a63ef695557f067468debe8e488f0852a07a"

URI_x86_64_v2_libuv-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuv-static-1.52.1-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libuv-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuv-static}"
SRC_URI[x86_64_v2_libuv-static.sha256sum] = "25a67f8443b47d1f2faf9c587c448bb5550e760b0d1dd5969cb68abc749449f0"

URI_aarch64_libuv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuv-1.52.1-1.el10_2.aarch64.rpm;name=aarch64_libuv;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuv}"
SRC_URI[aarch64_libuv.sha256sum] = "7169bedaefa6dd6324a5ce75e8eebb8e8f3e440211e1f22afaada9d90f62383e"

URI_aarch64_libuv-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuv-devel-1.52.1-1.el10_2.aarch64.rpm;name=aarch64_libuv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuv-devel}"
SRC_URI[aarch64_libuv-devel.sha256sum] = "3ae871c0e25caade15f9fe961c5bb3fd2d00dd39355f3edd1ff2dd6f0675776a"

URI_aarch64_libuv-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuv-static-1.52.1-1.el10_2.aarch64.rpm;name=aarch64_libuv-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuv-static}"
SRC_URI[aarch64_libuv-static.sha256sum] = "b0817ca5163519bd5ebe7dd38a3f2a470c14f1502cde67281ac3f57d91c95e90"

RDEPENDS:libuv = " \
 glibc \
 "
RDEPENDS:libuv-devel = " \
 cmake-filesystem \
 libuv \
 libuv-static \
 pkgconf-pkg-config \
 "
RDEPENDS:libuv-static = " \
 libuv-devel \
 pkgconf-pkg-config \
 "
