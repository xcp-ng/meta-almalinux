# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libinstpatch"
PV = "1.1.7"
PR = "1.el10_0"
PACKAGES = " \
 libinstpatch \
 libinstpatch-devel \
 libinstpatch-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libinstpatch-1.1.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "703291a5f697b2f1103dd0f42355e9c36d653c0b131224dd920ae1b42233a697"

URI_x86_64_v2_libinstpatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libinstpatch-1.1.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libinstpatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libinstpatch}"
SRC_URI[x86_64_v2_libinstpatch.sha256sum] = "2a82e488b3c887b99ff06f4c10323245321b2c977dc5c720f3c011e60e7cb8f6"

URI_x86_64_v2_libinstpatch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libinstpatch-devel-1.1.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libinstpatch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libinstpatch-devel}"
SRC_URI[x86_64_v2_libinstpatch-devel.sha256sum] = "9b46435f2a9499f36b0fb9d5cf546c951bdcd09b435c3864fb6fbb39d7d3bb2a"

URI_x86_64_v2_libinstpatch-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libinstpatch-doc-1.1.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libinstpatch-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libinstpatch-doc}"
SRC_URI[x86_64_v2_libinstpatch-doc.sha256sum] = "3eaa52c5daba0b16d66e9b0b387a9c9d487981e051b310cb7a7bb9e4fa844a22"

URI_aarch64_libinstpatch = "${EPEL_MIRROR}/aarch64/Packages/l/libinstpatch-1.1.7-1.el10_0.aarch64.rpm;name=aarch64_libinstpatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_libinstpatch}"
SRC_URI[aarch64_libinstpatch.sha256sum] = "f1396396c189460bae1584ee23847856fe19f9490e0f1e64d1be2897f74edd10"

URI_aarch64_libinstpatch-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libinstpatch-devel-1.1.7-1.el10_0.aarch64.rpm;name=aarch64_libinstpatch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libinstpatch-devel}"
SRC_URI[aarch64_libinstpatch-devel.sha256sum] = "62fa92e9f76cdc6dc072ee30335a381d0310211c6d8fc9b34653c0586ad771a6"

URI_aarch64_libinstpatch-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libinstpatch-doc-1.1.7-1.el10_0.noarch.rpm;name=aarch64_libinstpatch-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libinstpatch-doc}"
SRC_URI[aarch64_libinstpatch-doc.sha256sum] = "826576436e75592936e741f8ed8f8921fd69039287b3305a05bdc5f8d56aff89"

RDEPENDS:libinstpatch = " \
 glib2 \
 glibc \
 libsndfile \
 "
RDEPENDS:libinstpatch-devel = " \
 glib2-devel \
 libinstpatch \
 libsndfile-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libinstpatch-doc = " \
 "
