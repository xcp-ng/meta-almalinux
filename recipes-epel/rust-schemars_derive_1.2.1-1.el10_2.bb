# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-schemars_derive"
PV = "1.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-schemars_derive+default-devel \
 rust-schemars_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-schemars_derive-1.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93bd766c8b2ee260a5c9a931111f3b6ac265224afafd980905ea0e62c51cc993"

URI_x86_64_v2_rust-schemars_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars_derive+default-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars_derive+default-devel}"
SRC_URI[x86_64_v2_rust-schemars_derive+default-devel.sha256sum] = "179d671b5a010b7a4eaf49f33e30a85db61676b31f6018f1db532e1e0af51019"

URI_x86_64_v2_rust-schemars_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars_derive-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars_derive-devel}"
SRC_URI[x86_64_v2_rust-schemars_derive-devel.sha256sum] = "3383b5f3ddfd1faf44e21839956183589d27e16955bdd7cfb339358a24e4c910"

URI_aarch64_rust-schemars_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars_derive+default-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-schemars_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars_derive+default-devel}"
SRC_URI[aarch64_rust-schemars_derive+default-devel.sha256sum] = "817d6cc17039556184369db3f69b3fb79153f100d55dc14cda80739a52fad838"

URI_aarch64_rust-schemars_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars_derive-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars_derive-devel}"
SRC_URI[aarch64_rust-schemars_derive-devel.sha256sum] = "0a2d49768ad7688fe3c0d2dcb889232bc279e11fed9a0526e3c2fb902cc2267c"

RDEPENDS:rust-schemars_derive+default-devel = " \
 cargo \
 rust-schemars_derive-devel \
 "
RDEPENDS:rust-schemars_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-serde_derive_internals+default-devel \
 rust-syn+default-devel \
 "
