# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral-version-ranges"
PV = "0.1.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-astral-version-ranges+default-devel \
 rust-astral-version-ranges+proptest-devel \
 rust-astral-version-ranges+serde-devel \
 rust-astral-version-ranges-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-astral-version-ranges-0.1.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a618016b969c5b394d8c1815e8c17932cf0ca07c0be74d9768cfa289fbab0aa"

URI_x86_64_v2_rust-astral-version-ranges+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-version-ranges+default-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-version-ranges+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-version-ranges+default-devel}"
SRC_URI[x86_64_v2_rust-astral-version-ranges+default-devel.sha256sum] = "ffad887b71500ce91a8bcab7f7412582b8af645904a662072ebba92a888fd915"

URI_x86_64_v2_rust-astral-version-ranges+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-version-ranges+proptest-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-version-ranges+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-version-ranges+proptest-devel}"
SRC_URI[x86_64_v2_rust-astral-version-ranges+proptest-devel.sha256sum] = "17e5e5bada74faecc0a8ff83bc994071aed7a367eedfae81fb0ed6c872580f46"

URI_x86_64_v2_rust-astral-version-ranges+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-version-ranges+serde-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-version-ranges+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-version-ranges+serde-devel}"
SRC_URI[x86_64_v2_rust-astral-version-ranges+serde-devel.sha256sum] = "67f339271c0902665baadf4fe7e537633db36c39794a9b929a601cf6b69c8b21"

URI_x86_64_v2_rust-astral-version-ranges-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-version-ranges-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-version-ranges-devel}"
SRC_URI[x86_64_v2_rust-astral-version-ranges-devel.sha256sum] = "a97171ca9df3445aed1e4ed99a8bcb1486f7d0132f150aaefc4177961b2d5502"

URI_aarch64_rust-astral-version-ranges+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-version-ranges+default-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-astral-version-ranges+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-version-ranges+default-devel}"
SRC_URI[aarch64_rust-astral-version-ranges+default-devel.sha256sum] = "b801fa89628f50b4ef91b6e605179d77b30c3dc36afc4097aa9c5969e1725272"

URI_aarch64_rust-astral-version-ranges+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-version-ranges+proptest-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-astral-version-ranges+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-version-ranges+proptest-devel}"
SRC_URI[aarch64_rust-astral-version-ranges+proptest-devel.sha256sum] = "5369e8aaefdd81eefe316307c560c61ee2a5db9e86eaa01c75bfcfb9eb9fe2ec"

URI_aarch64_rust-astral-version-ranges+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-version-ranges+serde-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-astral-version-ranges+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-version-ranges+serde-devel}"
SRC_URI[aarch64_rust-astral-version-ranges+serde-devel.sha256sum] = "838b9b2bf9c4d293dffe50f945738707e253fcc585f0c0293fa5dc50da2ced15"

URI_aarch64_rust-astral-version-ranges-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-version-ranges-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-astral-version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-version-ranges-devel}"
SRC_URI[aarch64_rust-astral-version-ranges-devel.sha256sum] = "33b0ea5de43ec15cdb31a1b0a864bc203a1dcd4e76ad7ba991178c88a19f60c7"

RDEPENDS:rust-astral-version-ranges+default-devel = " \
 cargo \
 rust-astral-version-ranges-devel \
 "
RDEPENDS:rust-astral-version-ranges+proptest-devel = " \
 cargo \
 rust-astral-version-ranges-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-astral-version-ranges+serde-devel = " \
 cargo \
 rust-astral-version-ranges-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-smallvec+serde-devel \
 "
RDEPENDS:rust-astral-version-ranges-devel = " \
 cargo \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 "
