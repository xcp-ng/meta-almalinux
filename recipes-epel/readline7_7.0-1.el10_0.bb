# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "readline7"
PV = "7.0"
PR = "1.el10_0"
PACKAGES = " \
 readline7 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/readline7-7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79b8f665f5336517905106770eff854dbf92ffc3075da48a2756438cfcb136ce"

URI_x86_64_v2_readline7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/readline7-7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_readline7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_readline7}"
SRC_URI[x86_64_v2_readline7.sha256sum] = "78e6b0f3709f946ba93c921c0dce82d7bc2f4e4c6f0c8e920d3eec8b6804d0be"

URI_aarch64_readline7 = "${EPEL_MIRROR}/aarch64/Packages/r/readline7-7.0-1.el10_0.aarch64.rpm;name=aarch64_readline7;unpack=0"
SRC_URI:append = " ${URI_aarch64_readline7}"
SRC_URI[aarch64_readline7.sha256sum] = "38b5f357b7de3b3620aaa5e3395c82fb483105d86b79f8b676763ecccd5c0cfd"

RDEPENDS:readline7 = " \
 glibc \
 ncurses-libs \
 "
