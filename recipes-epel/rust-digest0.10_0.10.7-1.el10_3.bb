# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-digest0.10"
PV = "0.10.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-digest0.10+alloc-devel \
 rust-digest0.10+blobby-devel \
 rust-digest0.10+block-buffer-devel \
 rust-digest0.10+const-oid-devel \
 rust-digest0.10+core-api-devel \
 rust-digest0.10+default-devel \
 rust-digest0.10+dev-devel \
 rust-digest0.10+mac-devel \
 rust-digest0.10+oid-devel \
 rust-digest0.10+rand_core-devel \
 rust-digest0.10+std-devel \
 rust-digest0.10+subtle-devel \
 rust-digest0.10-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-digest0.10-0.10.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b37e4681232e4f2977ad80cb45315c91f71c95458d57741bdc0bfe6009ffba72"

URI_x86_64_v2_rust-digest0.10+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.10+alloc-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.10+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.10+alloc-devel}"
SRC_URI[x86_64_v2_rust-digest0.10+alloc-devel.sha256sum] = "724559b62679633cfac95beb028d3444c66e866db4fb9fddb0694cafa35d5b88"

URI_x86_64_v2_rust-digest0.10+blobby-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.10+blobby-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.10+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.10+blobby-devel}"
SRC_URI[x86_64_v2_rust-digest0.10+blobby-devel.sha256sum] = "18b8edbc72db24c3b9c396ee2795aa36962dc0cbb3db2ec7d351cb01deed2971"

URI_x86_64_v2_rust-digest0.10+block-buffer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.10+block-buffer-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.10+block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.10+block-buffer-devel}"
SRC_URI[x86_64_v2_rust-digest0.10+block-buffer-devel.sha256sum] = "d356a920525099f8320ba86b4da29dccc01da69b81a133e8c91cc4d5ea8be1b3"

URI_x86_64_v2_rust-digest0.10+const-oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.10+const-oid-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.10+const-oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.10+const-oid-devel}"
SRC_URI[x86_64_v2_rust-digest0.10+const-oid-devel.sha256sum] = "6a4887239f80b8be4dc80ef5a4da40dff71e3c3ed4ceb82388a1f0553553fcce"

URI_x86_64_v2_rust-digest0.10+core-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.10+core-api-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.10+core-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.10+core-api-devel}"
SRC_URI[x86_64_v2_rust-digest0.10+core-api-devel.sha256sum] = "a7d448c2fee1769ee141685d298a08531ded1628b767dee9885b764f82a0b11a"

URI_x86_64_v2_rust-digest0.10+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.10+default-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.10+default-devel}"
SRC_URI[x86_64_v2_rust-digest0.10+default-devel.sha256sum] = "46a2a8c04fb77f267331428ebdfd1dc2005eee0f272da1a0acf32d666b38832a"

URI_x86_64_v2_rust-digest0.10+dev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.10+dev-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.10+dev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.10+dev-devel}"
SRC_URI[x86_64_v2_rust-digest0.10+dev-devel.sha256sum] = "adf4b5dd976888ed1a003951bd46f9e60ff063dbcceb4d86f58db429af5ea7ef"

URI_x86_64_v2_rust-digest0.10+mac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.10+mac-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.10+mac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.10+mac-devel}"
SRC_URI[x86_64_v2_rust-digest0.10+mac-devel.sha256sum] = "856d39ed1481f134f731c8edc5811898f3dac895526adde3b3d9898cb29a634b"

URI_x86_64_v2_rust-digest0.10+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.10+oid-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.10+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.10+oid-devel}"
SRC_URI[x86_64_v2_rust-digest0.10+oid-devel.sha256sum] = "2b43208d4655c7fc17a528eaf7a9895697b9b8548ae63f56dd52ac49d9eafdc8"

URI_x86_64_v2_rust-digest0.10+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.10+rand_core-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.10+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.10+rand_core-devel}"
SRC_URI[x86_64_v2_rust-digest0.10+rand_core-devel.sha256sum] = "7f379a3cc0503ef0ec14295a7be5bc8bff194d91cdbfdba25db7fd07d59c8984"

URI_x86_64_v2_rust-digest0.10+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.10+std-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.10+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.10+std-devel}"
SRC_URI[x86_64_v2_rust-digest0.10+std-devel.sha256sum] = "eee2ae110507e34d7271b8f9fea86b13b956b582399cc4985ed8576baffc3fae"

URI_x86_64_v2_rust-digest0.10+subtle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.10+subtle-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.10+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.10+subtle-devel}"
SRC_URI[x86_64_v2_rust-digest0.10+subtle-devel.sha256sum] = "d2045859ad1139637066e508325871ad571393f6e8c087f1b6116fdd083b4387"

URI_x86_64_v2_rust-digest0.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest0.10-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest0.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest0.10-devel}"
SRC_URI[x86_64_v2_rust-digest0.10-devel.sha256sum] = "35ca932d44e1c916865428b46ecacd1d8bb8ca107db5645e21a2cb830a625504"

URI_aarch64_rust-digest0.10+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.10+alloc-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-digest0.10+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.10+alloc-devel}"
SRC_URI[aarch64_rust-digest0.10+alloc-devel.sha256sum] = "64b5854131ef167ec97b0eefdfe5b6537b819055c6418c505fcbded52b00f93c"

URI_aarch64_rust-digest0.10+blobby-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.10+blobby-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-digest0.10+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.10+blobby-devel}"
SRC_URI[aarch64_rust-digest0.10+blobby-devel.sha256sum] = "36cf11abcfc884951892f709a3493a3ef58312e359fe453091ed0914f191a772"

URI_aarch64_rust-digest0.10+block-buffer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.10+block-buffer-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-digest0.10+block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.10+block-buffer-devel}"
SRC_URI[aarch64_rust-digest0.10+block-buffer-devel.sha256sum] = "5cf418b4184fb12510152cc6ad512c8e5083df585e152ea30929b2d95cb529ec"

URI_aarch64_rust-digest0.10+const-oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.10+const-oid-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-digest0.10+const-oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.10+const-oid-devel}"
SRC_URI[aarch64_rust-digest0.10+const-oid-devel.sha256sum] = "90aad2186346e29efc69c2bd45b3a8a01a0c3a573246d3ded82e2d4cd45c60fc"

URI_aarch64_rust-digest0.10+core-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.10+core-api-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-digest0.10+core-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.10+core-api-devel}"
SRC_URI[aarch64_rust-digest0.10+core-api-devel.sha256sum] = "a9b2eeb1dd9838459e032afc3c856d0c709d76cd2f822cc32f6d2f724f32b9b7"

URI_aarch64_rust-digest0.10+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.10+default-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-digest0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.10+default-devel}"
SRC_URI[aarch64_rust-digest0.10+default-devel.sha256sum] = "6c3b79f801fd52f776bbbd90a7bb3a7bcdfa85d1eb08b8eba7e5d50581b69f26"

URI_aarch64_rust-digest0.10+dev-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.10+dev-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-digest0.10+dev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.10+dev-devel}"
SRC_URI[aarch64_rust-digest0.10+dev-devel.sha256sum] = "9a7ada23bd390075d1340ab465c34a711c432fe71cfab9331c36e7fc772adcfc"

URI_aarch64_rust-digest0.10+mac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.10+mac-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-digest0.10+mac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.10+mac-devel}"
SRC_URI[aarch64_rust-digest0.10+mac-devel.sha256sum] = "a2e76bcfb6c16cea45cd29a60254b07872e801610405bdb57466339637b99b94"

URI_aarch64_rust-digest0.10+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.10+oid-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-digest0.10+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.10+oid-devel}"
SRC_URI[aarch64_rust-digest0.10+oid-devel.sha256sum] = "e4ad16bf103b0da1b33aaea7c411341f0db239dcea8c407e35b00ff6250d4276"

URI_aarch64_rust-digest0.10+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.10+rand_core-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-digest0.10+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.10+rand_core-devel}"
SRC_URI[aarch64_rust-digest0.10+rand_core-devel.sha256sum] = "9f66a5b4c361710f746d76c614b414c2c5205c570615ace77ec09260bf924ae9"

URI_aarch64_rust-digest0.10+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.10+std-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-digest0.10+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.10+std-devel}"
SRC_URI[aarch64_rust-digest0.10+std-devel.sha256sum] = "2619e2ec2ce12316f10a62287c04b55f3e10a711fd2adf64e358bab223c4f669"

URI_aarch64_rust-digest0.10+subtle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.10+subtle-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-digest0.10+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.10+subtle-devel}"
SRC_URI[aarch64_rust-digest0.10+subtle-devel.sha256sum] = "ba173c8baab1e0726e41ce5e4684a68a5c20ac07f89b92667501c4f4b7cf9f10"

URI_aarch64_rust-digest0.10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest0.10-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-digest0.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest0.10-devel}"
SRC_URI[aarch64_rust-digest0.10-devel.sha256sum] = "5d117bf320bb0c072d1b6ce4f465d418aa4804889f02bdcaee61042f3acac34c"

RDEPENDS:rust-digest0.10+alloc-devel = " \
 cargo \
 rust-digest0.10-devel \
 "
RDEPENDS:rust-digest0.10+blobby-devel = " \
 cargo \
 rust-blobby0.3+default-devel \
 rust-digest0.10-devel \
 "
RDEPENDS:rust-digest0.10+block-buffer-devel = " \
 cargo \
 rust-block-buffer0.10+default-devel \
 rust-digest0.10-devel \
 "
RDEPENDS:rust-digest0.10+const-oid-devel = " \
 cargo \
 rust-const-oid0.9+default-devel \
 rust-digest0.10-devel \
 "
RDEPENDS:rust-digest0.10+core-api-devel = " \
 cargo \
 rust-digest0.10+block-buffer-devel \
 rust-digest0.10-devel \
 "
RDEPENDS:rust-digest0.10+default-devel = " \
 cargo \
 rust-digest0.10+core-api-devel \
 rust-digest0.10-devel \
 "
RDEPENDS:rust-digest0.10+dev-devel = " \
 cargo \
 rust-digest0.10+blobby-devel \
 rust-digest0.10-devel \
 "
RDEPENDS:rust-digest0.10+mac-devel = " \
 cargo \
 rust-digest0.10+subtle-devel \
 rust-digest0.10-devel \
 "
RDEPENDS:rust-digest0.10+oid-devel = " \
 cargo \
 rust-digest0.10+const-oid-devel \
 rust-digest0.10-devel \
 "
RDEPENDS:rust-digest0.10+rand_core-devel = " \
 cargo \
 rust-crypto-common0.1+rand_core-devel \
 rust-digest0.10-devel \
 "
RDEPENDS:rust-digest0.10+std-devel = " \
 cargo \
 rust-crypto-common0.1+std-devel \
 rust-digest0.10+alloc-devel \
 rust-digest0.10-devel \
 "
RDEPENDS:rust-digest0.10+subtle-devel = " \
 cargo \
 rust-digest0.10-devel \
 rust-subtle-devel \
 "
RDEPENDS:rust-digest0.10-devel = " \
 cargo \
 rust-crypto-common0.1+default-devel \
 "
