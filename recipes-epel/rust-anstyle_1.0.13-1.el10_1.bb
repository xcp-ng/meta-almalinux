# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle"
PV = "1.0.13"
PR = "1.el10_1"
PACKAGES = " \
 rust-anstyle+default-devel \
 rust-anstyle+std-devel \
 rust-anstyle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-1.0.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6115e1e52244408d295830c7c1e4dd3a705eafb4178ab00536109b8ce4cfcbe"

URI_x86_64_v2_rust-anstyle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle+default-devel-1.0.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle+default-devel.sha256sum] = "b40d904292378186d0faab84652e542f3631e5d86ebf840ab9781898af9ca39a"

URI_x86_64_v2_rust-anstyle+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle+std-devel-1.0.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle+std-devel}"
SRC_URI[x86_64_v2_rust-anstyle+std-devel.sha256sum] = "e9726d5ff4a45e13be14c9971a87ef45b3f5fa9627ad7df49ad5d63f38ff21f5"

URI_x86_64_v2_rust-anstyle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-devel-1.0.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-devel}"
SRC_URI[x86_64_v2_rust-anstyle-devel.sha256sum] = "1f340bcc8dba58f889e4ccf5ab86d63df968ee1ab3c0b89e9fc8dfcb2e3b71de"

URI_aarch64_rust-anstyle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle+default-devel-1.0.13-1.el10_1.noarch.rpm;name=aarch64_rust-anstyle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle+default-devel}"
SRC_URI[aarch64_rust-anstyle+default-devel.sha256sum] = "4935549b07f9045561c0d66ea5eb024dd459d6a8b30016fa9e32b70c195339eb"

URI_aarch64_rust-anstyle+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle+std-devel-1.0.13-1.el10_1.noarch.rpm;name=aarch64_rust-anstyle+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle+std-devel}"
SRC_URI[aarch64_rust-anstyle+std-devel.sha256sum] = "b788f7ed2772d5616350aa82d8d36827da641a9914e3df64e639e3bd4a834864"

URI_aarch64_rust-anstyle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-devel-1.0.13-1.el10_1.noarch.rpm;name=aarch64_rust-anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-devel}"
SRC_URI[aarch64_rust-anstyle-devel.sha256sum] = "eed3c3a60ce175ae9af5ba1cc5e70503263132032741b0f2db043b8c916089aa"

RDEPENDS:rust-anstyle+default-devel = " \
 cargo \
 rust-anstyle+std-devel \
 rust-anstyle-devel \
 "
RDEPENDS:rust-anstyle+std-devel = " \
 cargo \
 rust-anstyle-devel \
 "
RDEPENDS:rust-anstyle-devel = " \
 cargo \
 rust \
 "
