# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lujavrite"
PV = "1.0.2"
PR = "7.el10"
PACKAGES = " \
 lujavrite \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/lujavrite-1.0.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f87c27a0d334cdfecb4e206b30f1b5322f29f7ca213e765f6a641423750ad479"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/lujavrite-1.0.2-7.el10.x86_64_v2.rpm;name=x86_64_v2_lujavrite;unpack=0"
SRC_URI[x86_64_v2_lujavrite.sha256sum] = "d18af481f117328cdd41a80e2550c2a16deb1811e5a5e121d436ffa86ff0fc7b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/lujavrite-1.0.2-7.el10.aarch64.rpm;name=aarch64_lujavrite;unpack=0"
SRC_URI[aarch64_lujavrite.sha256sum] = "3238a6b5024c3392ec29b2702d7392193142433f214806f53388af89190b9321"

RDEPENDS:lujavrite = " \
 glibc \
 lua-libs \
 "
