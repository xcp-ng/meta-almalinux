# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-ast"
PV = "1.1.3"
PR = "1.el10_2"
PACKAGES = " \
 php-ast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-ast-1.1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6f7c98e512451e4e21c1f9c069edf4b5508714486eb38e272798bb8b87eb930"

URI_x86_64_v2_php-ast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-ast-1.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-ast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-ast}"
SRC_URI[x86_64_v2_php-ast.sha256sum] = "6e03899a2358b13f29ed73fe1943066a4553cb6cbedb898ffc0ed32c71da720e"

URI_aarch64_php-ast = "${EPEL_MIRROR}/aarch64/Packages/p/php-ast-1.1.3-1.el10_2.aarch64.rpm;name=aarch64_php-ast;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-ast}"
SRC_URI[aarch64_php-ast.sha256sum] = "4d65d65712a1ae8a81a7ea792e389d7ea80bfcb5da355ebed239574e57ae407e"

RDEPENDS:php-ast:x86_64_v2 = " \
 glibc \
 php-common \
 virtual/php-tokenizer_x86-64_ \
"
RDEPENDS:php-ast:aarch64 = " \
 glibc \
 php-common \
 virtual/php-tokenizer_aarch-64_ \
"
