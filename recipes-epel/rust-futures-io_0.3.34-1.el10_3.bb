# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-io"
PV = "0.3.34"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-io+default-devel \
 rust-futures-io+std-devel \
 rust-futures-io+unstable-devel \
 rust-futures-io-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-futures-io-0.3.34-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2fac37dab19a301fb1d2abce5874ba7eb0f8daca9ad15e71bda1c7a23907c590"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io+default-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-io+default-devel.sha256sum] = "5a94bd4bef46eb7ef7011535ef363b0f1e9b6e986d73dad8120e326a7804fbae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io+std-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-io+std-devel.sha256sum] = "c960a0ebcc620c4596abe2731b160906af300e8bc7cb9fff4c578755a7e09b0f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io+unstable-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io+unstable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-io+unstable-devel.sha256sum] = "32199ecbdc3b925f32d47a8405dd0989eb5ce7744e056c5126b5ac97fbe3b7ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-io-devel.sha256sum] = "0b901596994b931af6422de4b42e4a64e54d585089cd09189a573c10e5d9b6d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io+default-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-io+default-devel;unpack=0"
SRC_URI[aarch64_rust-futures-io+default-devel.sha256sum] = "ecc655cd9559acd965a3876eb6dec198370519f19c46118e5ee2158bb35ebb7b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io+std-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-io+std-devel;unpack=0"
SRC_URI[aarch64_rust-futures-io+std-devel.sha256sum] = "1b35bcff9368b5b751886441601ae3c10f54c37dfb61a068dac6fa48f5ba4ee9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io+unstable-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-io+unstable-devel;unpack=0"
SRC_URI[aarch64_rust-futures-io+unstable-devel.sha256sum] = "ae789db70e2d416b8bd4fded8e96608d909e77ff7872f9aff603ce1c7bde9ccd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-io-devel;unpack=0"
SRC_URI[aarch64_rust-futures-io-devel.sha256sum] = "e1ec2e3bb9901d77257b2898b4e95a5311bc347abc154c2306369cbe7be6ad99"

RDEPENDS:rust-futures-io+default-devel = " \
 cargo \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 "
RDEPENDS:rust-futures-io+std-devel = " \
 cargo \
 rust-futures-io-devel \
 "
RDEPENDS:rust-futures-io+unstable-devel = " \
 cargo \
 rust-futures-io-devel \
 "
RDEPENDS:rust-futures-io-devel = " \
 cargo \
 rust \
 "
