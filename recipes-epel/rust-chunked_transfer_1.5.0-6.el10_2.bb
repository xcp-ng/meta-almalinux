# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chunked_transfer"
PV = "1.5.0"
PR = "6.el10_2"
PACKAGES = " \
 rust-chunked_transfer+default-devel \
 rust-chunked_transfer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chunked_transfer-1.5.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bfa12ec68867bb3861b857f5d4a601be709ebd848e089d9d48b38d172200d42"

URI_x86_64_v2_rust-chunked_transfer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chunked_transfer+default-devel-1.5.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chunked_transfer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chunked_transfer+default-devel}"
SRC_URI[x86_64_v2_rust-chunked_transfer+default-devel.sha256sum] = "141c29a99729eacfdc66f7e2ccbd3124ab1d40a8ffbbb9ce1112c888e6c192e5"

URI_x86_64_v2_rust-chunked_transfer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chunked_transfer-devel-1.5.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chunked_transfer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chunked_transfer-devel}"
SRC_URI[x86_64_v2_rust-chunked_transfer-devel.sha256sum] = "fe74376f24a4b03ddf45d460365d94346f19da54e81f9134b03df4f26e3efb65"

URI_aarch64_rust-chunked_transfer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chunked_transfer+default-devel-1.5.0-6.el10_2.noarch.rpm;name=aarch64_rust-chunked_transfer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chunked_transfer+default-devel}"
SRC_URI[aarch64_rust-chunked_transfer+default-devel.sha256sum] = "5b79bc6b87f19b3335fcb0ca928e2cd015007a29f3c11ea472461c051c87913b"

URI_aarch64_rust-chunked_transfer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chunked_transfer-devel-1.5.0-6.el10_2.noarch.rpm;name=aarch64_rust-chunked_transfer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chunked_transfer-devel}"
SRC_URI[aarch64_rust-chunked_transfer-devel.sha256sum] = "e89a54d70bb4ce1459b4485d13f02fff3ef1a016b0fb27b4f4b35fc7ed70a79a"

RDEPENDS:rust-chunked_transfer+default-devel = " \
 cargo \
 rust-chunked_transfer-devel \
 "
RDEPENDS:rust-chunked_transfer-devel = " \
 cargo \
 "
