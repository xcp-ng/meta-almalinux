# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-sdk"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-sdk \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-sdk-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2ad811d5ec1887f6a1b344bb258519daad167563fc0a83bac671d074567c9e09"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-sdk-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-sdk;unpack=0"
SRC_URI[x86_64_v2_plasma-sdk.sha256sum] = "5ffdafa8f27d20db2423e937fa48b13fcc6f38ed0fece61bd5eff7a09c6ae977"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-sdk-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-sdk;unpack=0"
SRC_URI[aarch64_plasma-sdk.sha256sum] = "9b16252613a26fd81539b96acf9daf68cffe8971a288ddad02cc40a3e4cd1541"

RDEPENDS:plasma-sdk = " \
 glibc \
 hicolor-icon-theme \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kpackage \
 kf6-ksvg \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 libplasma \
 libstdc++ \
 plasma5support \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
