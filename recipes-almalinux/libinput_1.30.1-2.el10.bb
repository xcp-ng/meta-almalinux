# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libinput"
PV = "1.30.1"
PR = "2.el10"
PACKAGES = " \
 libinput \
 libinput-devel \
 libinput-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libinput-1.30.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "661da35f798dec0b9290f26dc05cc3db7dba017220cb0da37a23545eac743a77"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libinput-1.30.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_libinput;unpack=0"
SRC_URI[x86_64_v2_libinput.sha256sum] = "fc4355d7234571a461603e47abe903b652fe973c323197e5955f89156b1aadbb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libinput-devel-1.30.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_libinput-devel;unpack=0"
SRC_URI[x86_64_v2_libinput-devel.sha256sum] = "8f534ca8d15df35b2b80215a9d3e457bd07eed192e5e6cb9c1db7e0ede1e3394"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libinput-utils-1.30.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_libinput-utils;unpack=0"
SRC_URI[x86_64_v2_libinput-utils.sha256sum] = "b6ec32d3a415f8fa0439201561d82a81ab01cd42fb8522b80c2653ebfec9ae5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libinput-1.30.1-2.el10.aarch64.rpm;name=aarch64_libinput;unpack=0"
SRC_URI[aarch64_libinput.sha256sum] = "7cc446b9d7aa1921c8bcd1bb297558f394a0591d0051c062e1ccdb3663a1f425"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libinput-devel-1.30.1-2.el10.aarch64.rpm;name=aarch64_libinput-devel;unpack=0"
SRC_URI[aarch64_libinput-devel.sha256sum] = "a9b289855e7113e9fe36d4d900ff8b4d0e5e793aafa0184a51768ace26ed30ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libinput-utils-1.30.1-2.el10.aarch64.rpm;name=aarch64_libinput-utils;unpack=0"
SRC_URI[aarch64_libinput-utils.sha256sum] = "d38326ffb42d7e9f42b4614b18bab76fc361ddaf960c1839aa1898bb5ee5b452"

RDEPENDS:libinput = " \
 bash \
 glibc \
 libevdev \
 libgcc \
 libwacom \
 mtdev \
 systemd-libs \
 "
RDEPENDS:libinput-devel = " \
 libinput \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:libinput-utils = " \
 glibc \
 libevdev \
 libgcc \
 libinput \
 python3 \
 python3-libevdev \
 python3-pyudev \
 systemd-libs \
 "
