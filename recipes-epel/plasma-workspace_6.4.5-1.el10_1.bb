# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-workspace"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 libkworkspace6 \
 plasma-lookandfeel-fedora \
 plasma-workspace \
 plasma-workspace-common \
 plasma-workspace-devel \
 plasma-workspace-doc \
 plasma-workspace-libs \
 sddm-wayland-plasma \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-workspace-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ca62476396336c1991cc779297c078d4440a8ffe534e018bb521b8cebf10198"

URI_x86_64_v2_libkworkspace6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkworkspace6-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkworkspace6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkworkspace6}"
SRC_URI[x86_64_v2_libkworkspace6.sha256sum] = "fd90580e63e4129f65eb0681728feec04a2c686a74369f7babb7082095a27413"

URI_x86_64_v2_plasma-lookandfeel-fedora = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-lookandfeel-fedora-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-lookandfeel-fedora;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-lookandfeel-fedora}"
SRC_URI[x86_64_v2_plasma-lookandfeel-fedora.sha256sum] = "2ee65ff08d1220ed2f91a87553c2817d307fa7188f489a12e8d654a94e068ae8"

URI_x86_64_v2_plasma-workspace = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace}"
SRC_URI[x86_64_v2_plasma-workspace.sha256sum] = "f18797d8a170d288e1b1e8b974070b59dc0aecd639cb7cce8a70dcf940981309"

URI_x86_64_v2_plasma-workspace-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-common-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-common}"
SRC_URI[x86_64_v2_plasma-workspace-common.sha256sum] = "a8c4d353e8e3987f943661fed4ee01b102af18745114ff2e3d4f04b6843df623"

URI_x86_64_v2_plasma-workspace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-devel-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-devel}"
SRC_URI[x86_64_v2_plasma-workspace-devel.sha256sum] = "5751efc3c0ea9b78882fd80c36fd096e1d10100944f945a9b5a2f7547e4eaa98"

URI_x86_64_v2_plasma-workspace-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-doc-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-workspace-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-doc}"
SRC_URI[x86_64_v2_plasma-workspace-doc.sha256sum] = "11ac34d186b9643a7e10f2219cb6dda6f9fdd0959b16e202f179c646db4e7f43"

URI_x86_64_v2_plasma-workspace-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-libs-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-libs}"
SRC_URI[x86_64_v2_plasma-workspace-libs.sha256sum] = "f068626225e839ba56b221f8e7e80d219dbd672359621bee875f9ea25cdbb1e4"

URI_x86_64_v2_sddm-wayland-plasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-wayland-plasma-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-wayland-plasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-wayland-plasma}"
SRC_URI[x86_64_v2_sddm-wayland-plasma.sha256sum] = "b68dac5e8c80666c8386d0173ef153456597afb66cb85824cfedd3cba1908a99"
RPROVIDES:sddm-wayland-plasma:append:x86_64_v2 = " virtual/sddm-greeter-displayserver"

URI_aarch64_libkworkspace6 = "${EPEL_MIRROR}/aarch64/Packages/l/libkworkspace6-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_libkworkspace6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkworkspace6}"
SRC_URI[aarch64_libkworkspace6.sha256sum] = "0b216ffdff6d5a927abb32575412b127b07f0cf3110564d3f0f8a9f7547aee4c"

URI_aarch64_plasma-lookandfeel-fedora = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-lookandfeel-fedora-6.4.5-1.el10_1.noarch.rpm;name=aarch64_plasma-lookandfeel-fedora;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-lookandfeel-fedora}"
SRC_URI[aarch64_plasma-lookandfeel-fedora.sha256sum] = "eb28d3382845affec7af66fae52a0f3ab2ea36ac83daa64b26eb8c4b150af79c"

URI_aarch64_plasma-workspace = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-workspace;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace}"
SRC_URI[aarch64_plasma-workspace.sha256sum] = "e73340c98ed67eaec14826a0b27676b068026d012f287ace5448e3626759a780"

URI_aarch64_plasma-workspace-common = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-common-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-workspace-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-common}"
SRC_URI[aarch64_plasma-workspace-common.sha256sum] = "babeeef80333a2f705e05a8a00fa59d1e990ad276e8902e9734e5df27fe7881a"

URI_aarch64_plasma-workspace-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-devel-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-workspace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-devel}"
SRC_URI[aarch64_plasma-workspace-devel.sha256sum] = "85cf0fb8fa0cb8b6f739617699f45ebb5a5945d4041d9f254b3f49ee56b9f522"

URI_aarch64_plasma-workspace-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-doc-6.4.5-1.el10_1.noarch.rpm;name=aarch64_plasma-workspace-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-doc}"
SRC_URI[aarch64_plasma-workspace-doc.sha256sum] = "660a8551ee662a24db0a54e267becfecb8b9e3633cbae3affbf3a42d794438ad"

URI_aarch64_plasma-workspace-libs = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-libs-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-workspace-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-libs}"
SRC_URI[aarch64_plasma-workspace-libs.sha256sum] = "69feb519377805638528ed0dcfd1a39580dec1a7f2855b774aeff9d4a738fb30"

URI_aarch64_sddm-wayland-plasma = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-wayland-plasma-6.4.5-1.el10_1.noarch.rpm;name=aarch64_sddm-wayland-plasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-wayland-plasma}"
SRC_URI[aarch64_sddm-wayland-plasma.sha256sum] = "7a0ff0c88d88715d1b58b47c889b4729c1f8af8801677fee87bb3cc740025857"
RPROVIDES:sddm-wayland-plasma:append:aarch64 = " virtual/sddm-greeter-displayserver"

RDEPENDS:libkworkspace6 = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 libXau \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-workspace-common \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwayland \
 "
RDEPENDS:plasma-lookandfeel-fedora = " \
 plasma-workspace \
 qt6-qtvirtualkeyboard \
 "
RDEPENDS:plasma-workspace = " \
 PackageKit-Qt6 \
 appstream-qt \
 bash \
 dbus \
 dbus-libs \
 dbus-tools \
 fontconfig \
 glibc \
 gnome-menus \
 iso-codes \
 kactivitymanagerd \
 kde-settings-plasma \
 kf6-baloo \
 kf6-baloo-libs \
 kf6-frameworkintegration \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kded \
 kf6-kdoctools \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kparts \
 kf6-kquickcharts \
 kf6-krunner \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ksvg \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 kio-extras \
 kio-fuse \
 kscreenlocker \
 ksystemstats \
 kwayland \
 kwin \
 layer-shell-qt \
 libICE \
 libSM \
 libX11 \
 libXcursor \
 libXfixes \
 libXtst \
 libcanberra \
 libicu \
 libkexiv2-qt6 \
 libksysguard \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 maliit-keyboard \
 ocean-sound-theme \
 plasma-activities \
 plasma-activities-stats \
 plasma-desktop \
 plasma-lookandfeel-fedora \
 plasma-workspace-common \
 plasma-workspace-libs \
 plasma5support \
 policycoreutils \
 polkit-kde \
 powerdevil \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 qt6-qtvirtualkeyboard \
 qt6-qtwayland \
 socat \
 systemd \
 unity-gtk3-module \
 uresourced \
 virtual/coreutils \
 xcb-util \
 xcb-util-cursor \
 xcb-util-image \
 xdg-desktop-portal-kde \
 xmessage \
 xorg-x11-server-Xwayland \
 xprop \
 xrdb \
 zlib-ng-compat \
 "
RDEPENDS:plasma-workspace-common = " \
 "
RDEPENDS:plasma-workspace-devel = " \
 cmake-filesystem \
 libkworkspace6 \
 plasma-workspace-libs \
 "
RDEPENDS:plasma-workspace-doc = " \
 plasma-workspace-common \
 "
RDEPENDS:plasma-workspace-libs = " \
 appstream-qt \
 fontconfig \
 freetype \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kpackage \
 kf6-kparts \
 kf6-krunner \
 kf6-kservice \
 kf6-ksvg \
 kf6-kunitconversion \
 kf6-kuserfeedback \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-networkmanager-qt \
 kf6-prison \
 kf6-solid \
 kwayland \
 libX11 \
 libXcursor \
 libXfixes \
 libXft \
 libcanberra \
 libgcc \
 libksysguard \
 libkworkspace6 \
 libplasma \
 libqalculate \
 libstdc++ \
 libwayland-client \
 libxcb \
 libxcrypt \
 phonon-qt6 \
 plasma-activities \
 plasma-activities-stats \
 plasma-workspace-common \
 plasma5support \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 qt6-qtsvg \
 qt6-qtwayland \
 systemd-libs \
 xcb-util \
 xcb-util-cursor \
 "
RDEPENDS:sddm-wayland-plasma = " \
 kwin \
 layer-shell-qt \
 maliit-keyboard \
 "
