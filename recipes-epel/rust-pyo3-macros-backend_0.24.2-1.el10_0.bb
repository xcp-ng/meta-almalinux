# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros-backend"
PV = "0.24.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3-macros-backend+default-devel \
 rust-pyo3-macros-backend+experimental-async-devel \
 rust-pyo3-macros-backend-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-backend-0.24.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfbe9d50c39862039a5ef5036bc19d69154d1d9d1c151bf965aacce2742eebf7"

URI_x86_64_v2_rust-pyo3-macros-backend+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend+default-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend+default-devel.sha256sum] = "54e4c92a6d360ddbbab42ee90bb2f32b62334f9e63fd0e87c8cf051eab1436a8"

URI_x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend+experimental-async-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel.sha256sum] = "94232e0c98032bff655cd1f4155731e51bf61ed450dcc3d5ff3a25a679b45916"

URI_x86_64_v2_rust-pyo3-macros-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend-devel.sha256sum] = "46583a6054fbb898ddcba8a4068ff04a9e5197cc5193cf67bf28438d7e6d337d"

URI_aarch64_rust-pyo3-macros-backend+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend+default-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend+default-devel.sha256sum] = "d98b0915efb9c37569bb6752c7b79fc28bcfd239b64174448de1853cff93d0c6"

URI_aarch64_rust-pyo3-macros-backend+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend+experimental-async-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros-backend+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend+experimental-async-devel.sha256sum] = "c7c64ad9a94aa81828fb84e8a4708e5fb5b47d44726e53ae088b573e27cec743"

URI_aarch64_rust-pyo3-macros-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend-devel.sha256sum] = "9ddd93ad05349294ac42855cee6f3daa1877e79e6c13cab9f1fe7c6fd1ae17f8"

RDEPENDS:rust-pyo3-macros-backend+default-devel = " \
 cargo \
 rust-pyo3-macros-backend-devel \
 "
RDEPENDS:rust-pyo3-macros-backend+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend-devel \
 "
RDEPENDS:rust-pyo3-macros-backend-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2-devel \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-build-config+resolve-config-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
