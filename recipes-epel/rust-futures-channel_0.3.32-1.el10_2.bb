# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-channel"
PV = "0.3.32"
PR = "1.el10_2"
PACKAGES = " \
 rust-futures-channel+alloc-devel \
 rust-futures-channel+cfg-target-has-atomic-devel \
 rust-futures-channel+default-devel \
 rust-futures-channel+futures-sink-devel \
 rust-futures-channel+sink-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel+unstable-devel \
 rust-futures-channel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-channel-0.3.32-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6b04de433c9c6e917e434d5d3841f1cc453df2c99cde8ebf26161ca89c60fa6"

URI_x86_64_v2_rust-futures-channel+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+alloc-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+alloc-devel.sha256sum] = "cad993f1ac35211d69e956f271e17aeb8a5732f4b14eef9be74855760201ffc2"

URI_x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+cfg-target-has-atomic-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel.sha256sum] = "41704053724cb3a47305b1484d4c51236befa355e746105b8e02f36389acf83a"

URI_x86_64_v2_rust-futures-channel+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+default-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+default-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+default-devel.sha256sum] = "b2bc56c06de8c8d0bcad808088cffea67076b1dafd9dcef7c1614cf1c3908ff6"

URI_x86_64_v2_rust-futures-channel+futures-sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+futures-sink-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+futures-sink-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+futures-sink-devel.sha256sum] = "90c3a6bb6a0f8a8b2c57960d53ddb8fc977758c18cac36a99fb56f7fe84718d6"

URI_x86_64_v2_rust-futures-channel+sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+sink-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+sink-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+sink-devel.sha256sum] = "4abdd6d5dc492ed2cb9275f667db70d32bde460fe54886e4c47d7b56f755f9b4"

URI_x86_64_v2_rust-futures-channel+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+std-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+std-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+std-devel.sha256sum] = "843dcf550cf92d5688ea4a9ef48a328c5d68654dbb364caaf7ad856a0e081a8e"

URI_x86_64_v2_rust-futures-channel+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+unstable-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+unstable-devel.sha256sum] = "30cae2776984fdd65453c93dcf19e4abfa61cc8f6d0cfbe42da12c0144683f97"

URI_x86_64_v2_rust-futures-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel-devel}"
SRC_URI[x86_64_v2_rust-futures-channel-devel.sha256sum] = "5a62f7d3fa6399380bb9d66badf4931b77640b85be2353facc34ea124593e8af"

URI_aarch64_rust-futures-channel+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+alloc-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-channel+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+alloc-devel}"
SRC_URI[aarch64_rust-futures-channel+alloc-devel.sha256sum] = "abad54cc5c9a0553aad4afe3d7fe372ef328440a562293ab3c0c45b61c5ee920"

URI_aarch64_rust-futures-channel+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+cfg-target-has-atomic-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-channel+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures-channel+cfg-target-has-atomic-devel.sha256sum] = "381915a06fdfd4b0c6b9eaad4b54103d91846fc9ab33e5a5d075bf235f67e686"

URI_aarch64_rust-futures-channel+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+default-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+default-devel}"
SRC_URI[aarch64_rust-futures-channel+default-devel.sha256sum] = "becb687407fe3d54fa11b760d0ec4828ecf2c2a5d9663fe875dce0e428c601fe"

URI_aarch64_rust-futures-channel+futures-sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+futures-sink-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-channel+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+futures-sink-devel}"
SRC_URI[aarch64_rust-futures-channel+futures-sink-devel.sha256sum] = "52495da4cb9222f40f6feda0124150bca01d5fff6bbd1d782f524f85d7e435c2"

URI_aarch64_rust-futures-channel+sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+sink-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-channel+sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+sink-devel}"
SRC_URI[aarch64_rust-futures-channel+sink-devel.sha256sum] = "12597c9fc304a51156446bc3b3ae06d07b42437033afd2d271e0c6828abf5b30"

URI_aarch64_rust-futures-channel+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+std-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+std-devel}"
SRC_URI[aarch64_rust-futures-channel+std-devel.sha256sum] = "99a333612f67c163ff6896944acff1476385b2daadbb34537c003ac70ffca1c4"

URI_aarch64_rust-futures-channel+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+unstable-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-channel+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+unstable-devel}"
SRC_URI[aarch64_rust-futures-channel+unstable-devel.sha256sum] = "d2890f59591755129e33b4a631c2cf0e21c5a5a8482d3cb277ce2b025131c35c"

URI_aarch64_rust-futures-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel-devel}"
SRC_URI[aarch64_rust-futures-channel-devel.sha256sum] = "cd479cf3ffc0a7bf8c6951fd8fb2840bddb12c8c61e4a22f2a3a9c1f96b118a0"

RDEPENDS:rust-futures-channel+alloc-devel = " \
 cargo \
 rust-futures-channel-devel \
 rust-futures-core+alloc-devel \
 "
RDEPENDS:rust-futures-channel+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel+default-devel = " \
 cargo \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel+futures-sink-devel = " \
 cargo \
 rust-futures-channel-devel \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-channel+sink-devel = " \
 cargo \
 rust-futures-channel+futures-sink-devel \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel+std-devel = " \
 cargo \
 rust-futures-channel+alloc-devel \
 rust-futures-channel-devel \
 rust-futures-core+std-devel \
 "
RDEPENDS:rust-futures-channel+unstable-devel = " \
 cargo \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 "
