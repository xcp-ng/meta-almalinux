# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tpm2-pkcs11"
PV = "1.9.0"
PR = "7.el10"
PACKAGES = " \
 tpm2-pkcs11 \
 tpm2-pkcs11-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tpm2-pkcs11-1.9.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "764903505ae45c84f14bd9df7ef1b5fd63640da77e7a61fcdcaf11c2f43597fd"

URI_x86_64_v2_tpm2-pkcs11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tpm2-pkcs11-1.9.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_tpm2-pkcs11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tpm2-pkcs11}"
SRC_URI[x86_64_v2_tpm2-pkcs11.sha256sum] = "150a85a25b2eb0346ea5449515e31d15f7d6e6833b03f3efd740aa1bd0ed9115"

URI_x86_64_v2_tpm2-pkcs11-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tpm2-pkcs11-tools-1.9.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_tpm2-pkcs11-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tpm2-pkcs11-tools}"
SRC_URI[x86_64_v2_tpm2-pkcs11-tools.sha256sum] = "4b8cc55c591294c02d0be736e45e274233174ecf695e588380d49a3041cd8e4a"

URI_aarch64_tpm2-pkcs11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tpm2-pkcs11-1.9.0-7.el10.aarch64.rpm;name=aarch64_tpm2-pkcs11;unpack=0"
SRC_URI:append = " ${URI_aarch64_tpm2-pkcs11}"
SRC_URI[aarch64_tpm2-pkcs11.sha256sum] = "9922a230ca33a38817253150ce7efd5a038e568b4169604d2317443d5d7480f9"

URI_aarch64_tpm2-pkcs11-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tpm2-pkcs11-tools-1.9.0-7.el10.aarch64.rpm;name=aarch64_tpm2-pkcs11-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_tpm2-pkcs11-tools}"
SRC_URI[aarch64_tpm2-pkcs11-tools.sha256sum] = "44b4b7a25af4ad596204e0110e638b6786bb7b38190bc10edea22bc084f1fcc2"

RDEPENDS:tpm2-pkcs11 = " \
 glibc \
 libyaml \
 openssl-libs \
 sqlite-libs \
 tpm2-tss \
 tpm2-tss-fapi \
 "
RDEPENDS:tpm2-pkcs11-tools = " \
 bash \
 python3 \
 python3-cryptography \
 python3-pyasn1-modules \
 python3-pyyaml \
 python3-tpm2-pytss \
 "
