# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-xdg-basedir"
PV = "0.2.2"
PR = "46.el10_0"
PACKAGES = " \
 ghc-xdg-basedir \
 ghc-xdg-basedir-devel \
 ghc-xdg-basedir-doc \
 ghc-xdg-basedir-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-xdg-basedir-0.2.2-46.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ebbd40e47678b4ec2b3071f685239b3980bbd1c137e6c622aae1b3cbd70b2ed"

URI_x86_64_v2_ghc-xdg-basedir = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xdg-basedir-0.2.2-46.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xdg-basedir;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xdg-basedir}"
SRC_URI[x86_64_v2_ghc-xdg-basedir.sha256sum] = "0a6bcd4187302eafd0c5e88b47e809f08262ade4712905ee1d828470d6bf8feb"

URI_x86_64_v2_ghc-xdg-basedir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xdg-basedir-devel-0.2.2-46.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xdg-basedir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xdg-basedir-devel}"
SRC_URI[x86_64_v2_ghc-xdg-basedir-devel.sha256sum] = "dfef5c8f1d5c5606df33cb989f0be3fd7bb14baa773493e9a078cde065bf9329"

URI_x86_64_v2_ghc-xdg-basedir-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xdg-basedir-doc-0.2.2-46.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-xdg-basedir-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xdg-basedir-doc}"
SRC_URI[x86_64_v2_ghc-xdg-basedir-doc.sha256sum] = "645be2c5ef8d96bd90ccb25bd4f7ceb94b0601ec6d4874297aa57d2e3e58b80e"

URI_x86_64_v2_ghc-xdg-basedir-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xdg-basedir-prof-0.2.2-46.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xdg-basedir-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xdg-basedir-prof}"
SRC_URI[x86_64_v2_ghc-xdg-basedir-prof.sha256sum] = "854d29f1e564693c65933445086bdd02adb0bfac96e54db659abe20eda19869b"

URI_aarch64_ghc-xdg-basedir = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xdg-basedir-0.2.2-46.el10_0.aarch64.rpm;name=aarch64_ghc-xdg-basedir;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xdg-basedir}"
SRC_URI[aarch64_ghc-xdg-basedir.sha256sum] = "a506d25f5e1d550288bea492fa6d617215d038995a076bd5ab4b5b1c94bdc266"

URI_aarch64_ghc-xdg-basedir-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xdg-basedir-devel-0.2.2-46.el10_0.aarch64.rpm;name=aarch64_ghc-xdg-basedir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xdg-basedir-devel}"
SRC_URI[aarch64_ghc-xdg-basedir-devel.sha256sum] = "df9d124864e9fa3acd7cbd0070748691bfb3548779077aae90248aa14b2ce838"

URI_aarch64_ghc-xdg-basedir-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xdg-basedir-doc-0.2.2-46.el10_0.noarch.rpm;name=aarch64_ghc-xdg-basedir-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xdg-basedir-doc}"
SRC_URI[aarch64_ghc-xdg-basedir-doc.sha256sum] = "fd9baa40fefa684de1721ec86f42392cd006f9d88f08dbb02508ae07cedba65b"

URI_aarch64_ghc-xdg-basedir-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xdg-basedir-prof-0.2.2-46.el10_0.aarch64.rpm;name=aarch64_ghc-xdg-basedir-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xdg-basedir-prof}"
SRC_URI[aarch64_ghc-xdg-basedir-prof.sha256sum] = "b163a5afaab1e7bb0f94f7de6684b0bf9cf2359b613a7c66c3f990b332efb2fd"

RDEPENDS:ghc-xdg-basedir = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-xdg-basedir-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-xdg-basedir \
 "
RDEPENDS:ghc-xdg-basedir-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-xdg-basedir-prof = " \
 ghc-base-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-xdg-basedir-devel \
 "
