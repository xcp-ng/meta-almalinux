# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cppunit"
PV = "1.15.1"
PR = "23.el10"
PACKAGES = " \
 cppunit \
 cppunit-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/cppunit-1.15.1-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8e856e8d6857c658c0fca259da00d0201d5c842df19129e74ec38cf40659542"

URI_x86_64_v2_cppunit = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cppunit-1.15.1-23.el10.x86_64_v2.rpm;name=x86_64_v2_cppunit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cppunit}"
SRC_URI[x86_64_v2_cppunit.sha256sum] = "328ad349c6dd3dde09a7574008d3b084dcb6fc536ceb7c77e9867a0429a267d2"

URI_x86_64_v2_cppunit-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cppunit-devel-1.15.1-23.el10.x86_64_v2.rpm;name=x86_64_v2_cppunit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cppunit-devel}"
SRC_URI[x86_64_v2_cppunit-devel.sha256sum] = "830d4db3889438030d94260b8d77c506a27e18d27cad6fdddd1ea647763b1d4f"

URI_aarch64_cppunit = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cppunit-1.15.1-23.el10.aarch64.rpm;name=aarch64_cppunit;unpack=0"
SRC_URI:append = " ${URI_aarch64_cppunit}"
SRC_URI[aarch64_cppunit.sha256sum] = "ef83d69b66af05375af8f01dc1bfbac9110a791586b417d220852c877d7f2a38"

URI_aarch64_cppunit-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cppunit-devel-1.15.1-23.el10.aarch64.rpm;name=aarch64_cppunit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cppunit-devel}"
SRC_URI[aarch64_cppunit-devel.sha256sum] = "94cd66efd07c6bd856488052129fcb66337555881f60266e1ead0a52e3330ee2"

RDEPENDS:cppunit = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:cppunit-devel = " \
 cppunit \
 pkgconf-pkg-config \
 "
