# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lru"
PV = "0.14.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-lru+default-devel \
 rust-lru+hashbrown-devel \
 rust-lru-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lru-0.14.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bc7758fdd992916b595fc4fadbcd526dd36d8973ccfdab10e087a4b5370099d"

URI_x86_64_v2_rust-lru+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru+default-devel-0.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru+default-devel}"
SRC_URI[x86_64_v2_rust-lru+default-devel.sha256sum] = "879c8273a97a198520dfeba4ae14cb72f13d69637e729665a2958d37e63a17a8"

URI_x86_64_v2_rust-lru+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru+hashbrown-devel-0.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-lru+hashbrown-devel.sha256sum] = "4b56e9feb2a99072d7eb20c181ae3f6be3ad1fd3b80cb2202d5835ad671ed798"

URI_x86_64_v2_rust-lru-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru-devel-0.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru-devel}"
SRC_URI[x86_64_v2_rust-lru-devel.sha256sum] = "d4c07b56ac0b15550d766e3866680eefa008c8be5c29bc8e2a3069013ae802c2"

URI_aarch64_rust-lru+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru+default-devel-0.14.0-1.el10_1.noarch.rpm;name=aarch64_rust-lru+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru+default-devel}"
SRC_URI[aarch64_rust-lru+default-devel.sha256sum] = "5bce84bb91d5bbe4883107f79ee8c586b3e2c08618926b69bb1f8b3cf9ca0639"

URI_aarch64_rust-lru+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru+hashbrown-devel-0.14.0-1.el10_1.noarch.rpm;name=aarch64_rust-lru+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru+hashbrown-devel}"
SRC_URI[aarch64_rust-lru+hashbrown-devel.sha256sum] = "0315cb7fec299cc898681d402a9782a3480c39855f9e365e9674801920574d05"

URI_aarch64_rust-lru-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru-devel-0.14.0-1.el10_1.noarch.rpm;name=aarch64_rust-lru-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru-devel}"
SRC_URI[aarch64_rust-lru-devel.sha256sum] = "223ebac745a8ee65bea945f82e74ffa79054c81920c910232510982230721d71"

RDEPENDS:rust-lru+default-devel = " \
 cargo \
 rust-lru+hashbrown-devel \
 rust-lru-devel \
 "
RDEPENDS:rust-lru+hashbrown-devel = " \
 cargo \
 rust-hashbrown+default-devel \
 rust-lru-devel \
 "
RDEPENDS:rust-lru-devel = " \
 cargo \
 "
