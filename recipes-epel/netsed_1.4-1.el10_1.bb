# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netsed"
PV = "1.4"
PR = "1.el10_1"
PACKAGES = " \
 netsed \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netsed-1.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d8a834a88908c275ea4ef86e88886269c1c07553ff3091f5912e14446d2c123"

URI_x86_64_v2_netsed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netsed-1.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netsed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netsed}"
SRC_URI[x86_64_v2_netsed.sha256sum] = "77475cc9b81b186b21f3dfc185d466e36c108b02239bf35a17ce321da27e8a76"

URI_aarch64_netsed = "${EPEL_MIRROR}/aarch64/Packages/n/netsed-1.4-1.el10_1.aarch64.rpm;name=aarch64_netsed;unpack=0"
SRC_URI:append = " ${URI_aarch64_netsed}"
SRC_URI[aarch64_netsed.sha256sum] = "04fb647cf0d87af1c62d79aa0bc6859d5612eb95c2193df9129b394621dbf99d"

RDEPENDS:netsed = " \
 glibc \
 "
