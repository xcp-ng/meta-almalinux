# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-php"
PV = "0.23.11"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree-sitter-php+default-devel \
 rust-tree-sitter-php-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-php-0.23.11-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "204dcada5d5c01f646eb79d1f10550a90f587ea4027662a7454f651afb281c54"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-php+default-devel-0.23.11-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-php+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tree-sitter-php+default-devel.sha256sum] = "b9c6dc6943738e82e81fd1d88b8681507861325bae28ae2e479fb8de42d8e09d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-php-devel-0.23.11-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-php-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tree-sitter-php-devel.sha256sum] = "9851047434f3aed666d17036f9516c2592051e5f6d306d71fe1ab7436273f6f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-php+default-devel-0.23.11-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-php+default-devel;unpack=0"
SRC_URI[aarch64_rust-tree-sitter-php+default-devel.sha256sum] = "72a70876194eaad62a8c183f108aaaa849aa7b0888be8e815793118e35665e86"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-php-devel-0.23.11-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-php-devel;unpack=0"
SRC_URI[aarch64_rust-tree-sitter-php-devel.sha256sum] = "bd8bf34cfbe49c5da9049e0c828ba39f4d96b9dd58aaa317e387756f0f2af8b8"

RDEPENDS:rust-tree-sitter-php+default-devel = " \
 cargo \
 rust-tree-sitter-php-devel \
 "
RDEPENDS:rust-tree-sitter-php-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
