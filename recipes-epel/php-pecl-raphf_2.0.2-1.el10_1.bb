# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-raphf"
PV = "2.0.2"
PR = "1.el10_1"
PACKAGES = " \
 php-pecl-raphf \
 php-pecl-raphf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-raphf-2.0.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fbeed2781abc02ca77744516beaf7126e7b4c2b1568008fb38b5c171cd74152"

URI_x86_64_v2_php-pecl-raphf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-raphf-2.0.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-raphf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-raphf}"
SRC_URI[x86_64_v2_php-pecl-raphf.sha256sum] = "40841f230d746673a2f56803670ddda6c11d88d2795e38e858caef75feeecb8e"

URI_x86_64_v2_php-pecl-raphf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-raphf-devel-2.0.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-raphf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-raphf-devel}"
SRC_URI[x86_64_v2_php-pecl-raphf-devel.sha256sum] = "17469b9f3e41f0d01b906195741163c9be14b15a24ff3daad4de1478134030a1"

URI_aarch64_php-pecl-raphf = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-raphf-2.0.2-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-raphf;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-raphf}"
SRC_URI[aarch64_php-pecl-raphf.sha256sum] = "28afbbfa46e636051ba6e9a9a62cd33aa0fbfc5166f53582037676c739a2566d"

URI_aarch64_php-pecl-raphf-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-raphf-devel-2.0.2-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-raphf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-raphf-devel}"
SRC_URI[aarch64_php-pecl-raphf-devel.sha256sum] = "fba39f2b1415ae938dd136c3453a60bedc0785e37f2d06d6480ba705b03be2c5"

RDEPENDS:php-pecl-raphf = " \
 glibc \
 php-common \
 "
RDEPENDS:php-pecl-raphf-devel = " \
 php-devel \
 php-pecl-raphf \
 "
