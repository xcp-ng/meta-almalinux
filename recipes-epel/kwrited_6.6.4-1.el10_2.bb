# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwrited"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kwrited \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwrited-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fad7091844a1af49ab150d0fcd14c82ff0b95f5fd4c46c3cd93b6ef87d745734"

URI_x86_64_v2_kwrited = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwrited-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwrited;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwrited}"
SRC_URI[x86_64_v2_kwrited.sha256sum] = "c773bcddf2d4579373d98854242b23de4efa2f2a25ebad88427bedc5274a893c"

URI_aarch64_kwrited = "${EPEL_MIRROR}/aarch64/Packages/k/kwrited-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kwrited;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwrited}"
SRC_URI[aarch64_kwrited.sha256sum] = "58f86a85e355bbf2e3c064cab531900c18d566d9aba63f402382ffa3a6929895"

RDEPENDS:kwrited = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-knotifications \
 kf6-kpty \
 libstdc++ \
 qt6-qtbase \
 "
