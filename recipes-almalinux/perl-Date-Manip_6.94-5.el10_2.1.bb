# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Date-Manip"
PV = "6.94"
PR = "5.el10_2.1"
PACKAGES = " \
 perl-Date-Manip \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Date-Manip-6.94-5.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0182b715c9031d7ee06285fe20ff80cfef451bea697ab111a330a20c5e66aa0"

URI_x86_64_v2_perl-Date-Manip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Date-Manip-6.94-5.el10_2.1.noarch.rpm;name=x86_64_v2_perl-Date-Manip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Date-Manip}"
SRC_URI[x86_64_v2_perl-Date-Manip.sha256sum] = "10d103055b714ff49d9c99838b44a6ae39437022daa8f3446516cf8eca19f1d6"

URI_aarch64_perl-Date-Manip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Date-Manip-6.94-5.el10_2.1.noarch.rpm;name=aarch64_perl-Date-Manip;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Date-Manip}"
SRC_URI[aarch64_perl-Date-Manip.sha256sum] = "10d103055b714ff49d9c99838b44a6ae39437022daa8f3446516cf8eca19f1d6"

RDEPENDS:perl-Date-Manip = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Date-Manip \
 perl-Encode \
 perl-Exporter \
 perl-File-Find \
 perl-IO \
 perl-PathTools \
 perl-Storable \
 perl-interpreter \
 perl-libs \
 "
