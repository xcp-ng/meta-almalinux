# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plymouth-kcm"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plymouth-kcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plymouth-kcm-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddb49cb00aa6ebfb2cc7f2aeeb1688d9bb768d965bfd0709c69809697a350031"

URI_x86_64_v2_plymouth-kcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plymouth-kcm-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plymouth-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-kcm}"
SRC_URI[x86_64_v2_plymouth-kcm.sha256sum] = "aab3480793f3c0ca63996f68e5c35fa9512bee691e30d47a8c30b4c220196983"

URI_aarch64_plymouth-kcm = "${EPEL_MIRROR}/aarch64/Packages/p/plymouth-kcm-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plymouth-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-kcm}"
SRC_URI[aarch64_plymouth-kcm.sha256sum] = "0f73bb28e6b631c2da515d89a6b436e25857cd5da2682f6793921cc852ec9627"

RDEPENDS:plymouth-kcm = " \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-knewstuff \
 libstdc++ \
 plymouth \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
