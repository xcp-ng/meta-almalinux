# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nasm-rs"
PV = "0.2.5"
PR = "4.el10_0"
PACKAGES = " \
 rust-nasm-rs+default-devel \
 rust-nasm-rs+parallel-devel \
 rust-nasm-rs+rayon-devel \
 rust-nasm-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nasm-rs-0.2.5-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f5482b1aa58cf3321df8b5c4943243ac5f1aa3daba899ac87b5b63701d4787d"

URI_x86_64_v2_rust-nasm-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nasm-rs+default-devel-0.2.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nasm-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nasm-rs+default-devel}"
SRC_URI[x86_64_v2_rust-nasm-rs+default-devel.sha256sum] = "9cfcf3131864631d5b919352bd9f903f58c688eddf7a2f57137fdabd26e9e15b"

URI_x86_64_v2_rust-nasm-rs+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nasm-rs+parallel-devel-0.2.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nasm-rs+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nasm-rs+parallel-devel}"
SRC_URI[x86_64_v2_rust-nasm-rs+parallel-devel.sha256sum] = "82745dd6f28cdcf1342f6ade72a456855bcf7289d7cdeaf355070d369745dfbb"

URI_x86_64_v2_rust-nasm-rs+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nasm-rs+rayon-devel-0.2.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nasm-rs+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nasm-rs+rayon-devel}"
SRC_URI[x86_64_v2_rust-nasm-rs+rayon-devel.sha256sum] = "f91e230a24d4d0a3eb0347682429b2f0d37f1949004dd9a9bac69becbb95aa8e"

URI_x86_64_v2_rust-nasm-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nasm-rs-devel-0.2.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nasm-rs-devel}"
SRC_URI[x86_64_v2_rust-nasm-rs-devel.sha256sum] = "122d22ceaadf4d4d01a5ad0f9452095dddb8cc591194ab8eea69ce038f138666"

URI_aarch64_rust-nasm-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nasm-rs+default-devel-0.2.5-4.el10_0.noarch.rpm;name=aarch64_rust-nasm-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nasm-rs+default-devel}"
SRC_URI[aarch64_rust-nasm-rs+default-devel.sha256sum] = "5fd3208981972a7bc93aa6685ed3f10c931b5791bcef3aa542c582f7e8fdc325"

URI_aarch64_rust-nasm-rs+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nasm-rs+parallel-devel-0.2.5-4.el10_0.noarch.rpm;name=aarch64_rust-nasm-rs+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nasm-rs+parallel-devel}"
SRC_URI[aarch64_rust-nasm-rs+parallel-devel.sha256sum] = "78eff73c675f5acecd5391d6120eb86b287ce88537aed62e05cde3fa9e57cb4f"

URI_aarch64_rust-nasm-rs+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nasm-rs+rayon-devel-0.2.5-4.el10_0.noarch.rpm;name=aarch64_rust-nasm-rs+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nasm-rs+rayon-devel}"
SRC_URI[aarch64_rust-nasm-rs+rayon-devel.sha256sum] = "c4bc44c7f5b2cd11a0f9c6cc2e9da9413291ad8407e9c22db284b7f6b5b727d3"

URI_aarch64_rust-nasm-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nasm-rs-devel-0.2.5-4.el10_0.noarch.rpm;name=aarch64_rust-nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nasm-rs-devel}"
SRC_URI[aarch64_rust-nasm-rs-devel.sha256sum] = "a804911e4aff1cf2f3ad40d30285aab1d6b38532ebc812b06bd7d7caea26bbe6"

RDEPENDS:rust-nasm-rs+default-devel = " \
 cargo \
 rust-nasm-rs-devel \
 "
RDEPENDS:rust-nasm-rs+parallel-devel = " \
 cargo \
 rust-nasm-rs+rayon-devel \
 rust-nasm-rs-devel \
 "
RDEPENDS:rust-nasm-rs+rayon-devel = " \
 cargo \
 rust-nasm-rs-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-nasm-rs-devel = " \
 cargo \
 nasm \
 "
