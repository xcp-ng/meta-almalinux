# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet9.0"
PV = "9.0.116"
PR = "1.el10_1"
PACKAGES = " \
 aspnetcore-runtime-9.0 \
 aspnetcore-runtime-dbg-9.0 \
 aspnetcore-targeting-pack-9.0 \
 dotnet-apphost-pack-9.0 \
 dotnet-hostfxr-9.0 \
 dotnet-runtime-9.0 \
 dotnet-runtime-dbg-9.0 \
 dotnet-sdk-9.0 \
 dotnet-sdk-9.0-source-built-artifacts \
 dotnet-sdk-aot-9.0 \
 dotnet-sdk-dbg-9.0 \
 dotnet-targeting-pack-9.0 \
 dotnet-templates-9.0 \
 netstandard-targeting-pack-2.1 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet9.0-9.0.116-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df03e5d106aa347eb3af37c53360308dc51f1960edaa800e466037824c994fd4"

URI_x86_64_v2_aspnetcore-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-9.0-9.0.15-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-9.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-9.0.sha256sum] = "7f40060ae1b0a380c06a2e37a5b5f25979b929f034200250204f5af2d98839e8"

URI_x86_64_v2_aspnetcore-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-9.0-9.0.15-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-dbg-9.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-9.0.sha256sum] = "2a748235217a3ee29de102f928e6358830a3806ed5d137aef1c601266a9abe8b"

URI_x86_64_v2_aspnetcore-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-9.0-9.0.15-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-targeting-pack-9.0}"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-9.0.sha256sum] = "e63943d7df6d3b6e5bc2950aae811007913028305c014e7b66b34e871beacbc3"

URI_x86_64_v2_dotnet-apphost-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-9.0-9.0.15-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-apphost-pack-9.0}"
SRC_URI[x86_64_v2_dotnet-apphost-pack-9.0.sha256sum] = "a5ad87c6e8daed54b8de843e82ba3f58d7d32301e6ef85122ceec0fd58d7a9a8"

URI_x86_64_v2_dotnet-hostfxr-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-9.0-9.0.15-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-hostfxr-9.0}"
SRC_URI[x86_64_v2_dotnet-hostfxr-9.0.sha256sum] = "c02e9a4762cabbf0c5900e83052286a78b091bb1c9aafad75f10bb78c7447094"

URI_x86_64_v2_dotnet-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-9.0-9.0.15-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-9.0}"
SRC_URI[x86_64_v2_dotnet-runtime-9.0.sha256sum] = "20e0c1fb5edb6130bb1a2d77da8023bec7036264c91c1d38c06d8c5e46fa308c"

URI_x86_64_v2_dotnet-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-9.0-9.0.15-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-dbg-9.0}"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-9.0.sha256sum] = "95039f2e83600a0a6409628a2554d4c501f4f49efb451b09aef686563ec4b209"

URI_x86_64_v2_dotnet-sdk-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-9.0-9.0.116-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-9.0}"
SRC_URI[x86_64_v2_dotnet-sdk-9.0.sha256sum] = "4837aa0147c946714651d06b90de30ca1ed8f5e7f627485e32f0f22ecc4e2dc0"

URI_x86_64_v2_dotnet-sdk-9.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-9.0-source-built-artifacts-9.0.116-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-9.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-9.0-source-built-artifacts}"
SRC_URI[x86_64_v2_dotnet-sdk-9.0-source-built-artifacts.sha256sum] = "013f7c09c7278334f48d6f5d375b7eb6344df12be4ddbefd9bb6641523e22adc"

URI_x86_64_v2_dotnet-sdk-aot-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-aot-9.0-9.0.116-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-aot-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-aot-9.0}"
SRC_URI[x86_64_v2_dotnet-sdk-aot-9.0.sha256sum] = "b7f8e6250ce0d19830b9c92e3cccaf41152b1e2c9ec7b123fd84734b33594b16"

URI_x86_64_v2_dotnet-sdk-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-9.0-9.0.116-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-dbg-9.0}"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-9.0.sha256sum] = "d1ad6d80297aad39ee7238cad805225610021152b244ca9c58303cad77eaaae0"

URI_x86_64_v2_dotnet-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-9.0-9.0.15-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-targeting-pack-9.0}"
SRC_URI[x86_64_v2_dotnet-targeting-pack-9.0.sha256sum] = "f8d737b1681b2f73cfc30fed95a6cd6552836ab7f84735b10c8f5b85bf52c442"

URI_x86_64_v2_dotnet-templates-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-9.0-9.0.116-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-templates-9.0}"
SRC_URI[x86_64_v2_dotnet-templates-9.0.sha256sum] = "18df4763f85ccd8accdb31e8cf7e8101a18c2519cc9518bf07e2e7f908694647"

URI_x86_64_v2_netstandard-targeting-pack-2.1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/netstandard-targeting-pack-2.1-9.0.116-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_netstandard-targeting-pack-2.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netstandard-targeting-pack-2.1}"
SRC_URI[x86_64_v2_netstandard-targeting-pack-2.1.sha256sum] = "c5ac031ab5dc9ce549a86f49d068a65ee88f1b6c84269efe2d6648564a2bc7db"

URI_aarch64_aspnetcore-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-9.0-9.0.15-1.el10_1.aarch64.rpm;name=aarch64_aspnetcore-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-9.0}"
SRC_URI[aarch64_aspnetcore-runtime-9.0.sha256sum] = "dc4d42738177d9e3dc68fd089aa07737839c8bce4b884048510911171bdcbd71"

URI_aarch64_aspnetcore-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-9.0-9.0.15-1.el10_1.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-dbg-9.0}"
SRC_URI[aarch64_aspnetcore-runtime-dbg-9.0.sha256sum] = "65ee5c8d8f0257cd350a1e05f97084b5561385a53d3a6bd789e948c141e16768"

URI_aarch64_aspnetcore-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-9.0-9.0.15-1.el10_1.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-targeting-pack-9.0}"
SRC_URI[aarch64_aspnetcore-targeting-pack-9.0.sha256sum] = "b00e2c34eb106375dd2bdf84bbd901ec4799bf7aba1f2fe2fdc67060f5628fbe"

URI_aarch64_dotnet-apphost-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-9.0-9.0.15-1.el10_1.aarch64.rpm;name=aarch64_dotnet-apphost-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-apphost-pack-9.0}"
SRC_URI[aarch64_dotnet-apphost-pack-9.0.sha256sum] = "1246ac75b244ae3655eb33e32e7dbd686784edaffe775e0f7ed6ac06d2183f67"

URI_aarch64_dotnet-hostfxr-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-9.0-9.0.15-1.el10_1.aarch64.rpm;name=aarch64_dotnet-hostfxr-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-hostfxr-9.0}"
SRC_URI[aarch64_dotnet-hostfxr-9.0.sha256sum] = "f91d7b85677eba2e43548824578fcdb75a1e33fd2e994459819b4f13bddaf0c2"

URI_aarch64_dotnet-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-9.0-9.0.15-1.el10_1.aarch64.rpm;name=aarch64_dotnet-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-9.0}"
SRC_URI[aarch64_dotnet-runtime-9.0.sha256sum] = "db3b1699b3603720e755960a88684618cf15785403e6059d6a2de7d607cd0c70"

URI_aarch64_dotnet-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-9.0-9.0.15-1.el10_1.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-dbg-9.0}"
SRC_URI[aarch64_dotnet-runtime-dbg-9.0.sha256sum] = "4d2096849d0eb731d31c9d154c3e491c2a0f0403dc9e89b3ec2f8a8044de8e5f"

URI_aarch64_dotnet-sdk-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-9.0-9.0.116-1.el10_1.aarch64.rpm;name=aarch64_dotnet-sdk-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-9.0}"
SRC_URI[aarch64_dotnet-sdk-9.0.sha256sum] = "ebc19f0f6e9643105c33c6dceef1e72dd598b664ff5c55a288caad2ea137c9d6"

URI_aarch64_dotnet-sdk-9.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-9.0-source-built-artifacts-9.0.116-1.el10_1.aarch64.rpm;name=aarch64_dotnet-sdk-9.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-9.0-source-built-artifacts}"
SRC_URI[aarch64_dotnet-sdk-9.0-source-built-artifacts.sha256sum] = "b770dc98c8219779da1649887a6e6417881cc688e6c6f9cac5d09a591cec8951"

URI_aarch64_dotnet-sdk-aot-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-aot-9.0-9.0.116-1.el10_1.aarch64.rpm;name=aarch64_dotnet-sdk-aot-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-aot-9.0}"
SRC_URI[aarch64_dotnet-sdk-aot-9.0.sha256sum] = "e6c65c4676e78a69a04e5a3a23c30fd55667f58f40704b730ac4fc8361331b53"

URI_aarch64_dotnet-sdk-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-9.0-9.0.116-1.el10_1.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-dbg-9.0}"
SRC_URI[aarch64_dotnet-sdk-dbg-9.0.sha256sum] = "16bcbfd47911199e2f131792134e9ab45843d26d9e7014c0382937e9ebc55082"

URI_aarch64_dotnet-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-9.0-9.0.15-1.el10_1.aarch64.rpm;name=aarch64_dotnet-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-targeting-pack-9.0}"
SRC_URI[aarch64_dotnet-targeting-pack-9.0.sha256sum] = "6b3a4d90ba904230da7cb74c1b8f899f36fb69912fecdf269baa2edd4e50c481"

URI_aarch64_dotnet-templates-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-9.0-9.0.116-1.el10_1.aarch64.rpm;name=aarch64_dotnet-templates-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-templates-9.0}"
SRC_URI[aarch64_dotnet-templates-9.0.sha256sum] = "2b20b9123fbd94c5e75d0ef8731bf2c03a21725755fb2c396d3c0f53c3e591d4"

URI_aarch64_netstandard-targeting-pack-2.1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/netstandard-targeting-pack-2.1-9.0.116-1.el10_1.aarch64.rpm;name=aarch64_netstandard-targeting-pack-2.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_netstandard-targeting-pack-2.1}"
SRC_URI[aarch64_netstandard-targeting-pack-2.1.sha256sum] = "e62c1e032e8580f4bdb2680faca4e6c61c6ee6b1ea127697ad43971e3b51e13f"

RDEPENDS:aspnetcore-runtime-9.0 = " \
 dotnet-runtime-9.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-9.0 = " \
 aspnetcore-runtime-9.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-9.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-9.0 = " \
 dotnet-host \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-hostfxr-9.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-9.0 = " \
 dotnet-hostfxr-9.0 \
 glibc \
 libbrotli \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-9.0 = " \
 dotnet-runtime-9.0 \
 "
RDEPENDS:dotnet-sdk-9.0 = " \
 aspnetcore-runtime-9.0 \
 aspnetcore-targeting-pack-9.0 \
 dotnet-apphost-pack-9.0 \
 dotnet-runtime-9.0 \
 dotnet-targeting-pack-9.0 \
 dotnet-templates-9.0 \
 glibc \
 libgcc \
 libstdc++ \
 netstandard-targeting-pack-2.1 \
 "
RDEPENDS:dotnet-sdk-9.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-aot-9.0 = " \
 bash \
 brotli-devel \
 clang \
 dotnet-sdk-9.0 \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-devel \
 openssl-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:dotnet-sdk-dbg-9.0 = " \
 dotnet-sdk-9.0 \
 "
RDEPENDS:dotnet-targeting-pack-9.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-9.0 = " \
 dotnet-host \
 "
RDEPENDS:netstandard-targeting-pack-2.1 = " \
 dotnet-host \
 "
