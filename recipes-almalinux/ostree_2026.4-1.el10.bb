# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ostree"
PV = "2026.4"
PR = "1.el10"
PACKAGES = " \
 ostree \
 ostree-devel \
 ostree-grub2 \
 ostree-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ostree-2026.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "88b3556d22b68dd4c8d116a7a980844ebe2370a69435e5e463bd2f9b00ab2c17"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ostree-2026.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_ostree;unpack=0"
SRC_URI[x86_64_v2_ostree.sha256sum] = "7e5e034b0a0c2d1857d6f3e32f1d59af0dc50d19e9792bce097f6671ecd19ba0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ostree-devel-2026.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_ostree-devel;unpack=0"
SRC_URI[x86_64_v2_ostree-devel.sha256sum] = "43f59e27a04d27cd0f935d03c53c492175d0f574da8bce8c1533a72d234bdbfd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ostree-grub2-2026.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_ostree-grub2;unpack=0"
SRC_URI[x86_64_v2_ostree-grub2.sha256sum] = "2e89196aa7b76de50aca00fe6070001e492cec61789d809c539a74e854954b75"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ostree-libs-2026.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_ostree-libs;unpack=0"
SRC_URI[x86_64_v2_ostree-libs.sha256sum] = "e09c0708baecac3b485de85b6edecd532e032754462651b70d16ebbe8643fe68"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ostree-2026.4-1.el10.aarch64.rpm;name=aarch64_ostree;unpack=0"
SRC_URI[aarch64_ostree.sha256sum] = "231bb9aa7eb35b1edc078d38d6e1c897279b3f51da6214db6bd86e8890de3f7f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ostree-devel-2026.4-1.el10.aarch64.rpm;name=aarch64_ostree-devel;unpack=0"
SRC_URI[aarch64_ostree-devel.sha256sum] = "c3a21fa3e53a88b18d4c7917900a0ae35130b614f053b24c67a79c0c6054b25b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ostree-grub2-2026.4-1.el10.aarch64.rpm;name=aarch64_ostree-grub2;unpack=0"
SRC_URI[aarch64_ostree-grub2.sha256sum] = "759a7cdb4db45bb902c7298b9e55638d6adbc8f7b2fb4f174e4147b9dd09f773"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ostree-libs-2026.4-1.el10.aarch64.rpm;name=aarch64_ostree-libs;unpack=0"
SRC_URI[aarch64_ostree-libs.sha256sum] = "c8a899874d0c0718f5c9676c0763c9dd1293f100db0dd08761fe6112bc5ddd28"

RDEPENDS:ostree = " \
 bash \
 composefs \
 composefs-libs \
 dracut \
 fuse-libs \
 glib2 \
 glibc \
 gnupg2 \
 libarchive \
 libgcc \
 libselinux \
 openssl-libs \
 ostree-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:ostree-devel = " \
 composefs-devel \
 glib2-devel \
 libarchive-devel \
 libcurl-devel \
 libgpg-error-devel \
 libselinux-devel \
 openssl-devel \
 ostree-libs \
 pkgconf-pkg-config \
 systemd-devel \
 virtual/pkgconfig_gpgme__ge_1.8.0 \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:ostree-grub2:x86_64_v2 = " \
 bash \
 grub2-pc \
 ostree \
"
RDEPENDS:ostree-grub2:aarch64 = " \
 bash \
 grub2-efi-aa64 \
 ostree \
"
RDEPENDS:ostree-libs = " \
 composefs-libs \
 glib2 \
 glibc \
 gpgme \
 libarchive \
 libgcc \
 libgpg-error \
 libmount \
 libselinux \
 openssl-libs \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
