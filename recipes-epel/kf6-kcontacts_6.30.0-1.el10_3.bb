# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcontacts"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcontacts \
 kf6-kcontacts-devel \
 kf6-kcontacts-doc \
 kf6-kcontacts-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kcontacts-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6656142286e53aa96427470f4c8f8ec1f716472b9cefc53ace06ad22fdd706bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcontacts;unpack=0"
SRC_URI[x86_64_v2_kf6-kcontacts.sha256sum] = "85d708e835eab4749e59d05bad552dafcc150cef38a2a67cdc2860c46a35ec4c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcontacts-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kcontacts-devel.sha256sum] = "2b8cd41ceb56361cd1c4cc138dbaf2d715a534e6ee834b4dae0d72265ab82e96"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcontacts-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kcontacts-doc.sha256sum] = "c02ab5576228d6c1a67a5ee860fe6c8961cb40dd4ace85d48b002690bd698e11"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcontacts-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kcontacts-html.sha256sum] = "f271a70c7c858dbc92ab8c4435b1f3055bd754826e5a6a46785bd5c993b06e61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcontacts;unpack=0"
SRC_URI[aarch64_kf6-kcontacts.sha256sum] = "af751d493317e782a74539bae6eebee97a0fcb223e53b29c633addfb6535cd54"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcontacts-devel;unpack=0"
SRC_URI[aarch64_kf6-kcontacts-devel.sha256sum] = "43eca4564e1f17ded57bc74a49d7d87ff69ca7e614d3977d3b0c200318aaf93d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcontacts-doc;unpack=0"
SRC_URI[aarch64_kf6-kcontacts-doc.sha256sum] = "3b8e4257b2671e9d179f0971a50a35433fb1051c45f41105d58fdd1a2a5ea324"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcontacts-html;unpack=0"
SRC_URI[aarch64_kf6-kcontacts-html.sha256sum] = "6c8840e74496f7b06121874f402b2898e690f3ae19042e9957cd5df7ea5239e4"

RDEPENDS:kf6-kcontacts = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcontacts-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcodecs-devel \
 kf6-kcontacts \
 kf6-kcoreaddons-devel \
 kf6-ki18n-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcontacts-doc = " \
 "
RDEPENDS:kf6-kcontacts-html = " \
 "
