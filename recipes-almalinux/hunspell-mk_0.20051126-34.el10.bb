# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-mk"
PV = "0.20051126"
PR = "34.el10"
PACKAGES = " \
 hunspell-mk \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-mk-0.20051126-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6becbffdd0c954980fc3ab4dc02e21d23e6292ae9d7af18ed43a3cc6d37d6f29"

URI_x86_64_v2_hunspell-mk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-mk-0.20051126-34.el10.noarch.rpm;name=x86_64_v2_hunspell-mk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-mk}"
SRC_URI[x86_64_v2_hunspell-mk.sha256sum] = "d791dd1b3c4f5ca8571a499f48f7255fa15677fb6c997b395e288ce351407ceb"

URI_aarch64_hunspell-mk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-mk-0.20051126-34.el10.noarch.rpm;name=aarch64_hunspell-mk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-mk}"
SRC_URI[aarch64_hunspell-mk.sha256sum] = "d791dd1b3c4f5ca8571a499f48f7255fa15677fb6c997b395e288ce351407ceb"

RDEPENDS:hunspell-mk = " \
 hunspell-filesystem \
 "
