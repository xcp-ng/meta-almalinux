# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-hourglass"
PV = "0.2.12"
PR = "27.el10_0"
PACKAGES = " \
 ghc-hourglass \
 ghc-hourglass-devel \
 ghc-hourglass-doc \
 ghc-hourglass-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-hourglass-0.2.12-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa74e30fbfd3f7d87b3fbf7863891edc955d7967195e2a130512bc01afe34dda"

URI_x86_64_v2_ghc-hourglass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hourglass-0.2.12-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hourglass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hourglass}"
SRC_URI[x86_64_v2_ghc-hourglass.sha256sum] = "41be9060f52994440528af14602d05fa6c51e5b82e3fc583efc842a80966e52f"

URI_x86_64_v2_ghc-hourglass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hourglass-devel-0.2.12-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hourglass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hourglass-devel}"
SRC_URI[x86_64_v2_ghc-hourglass-devel.sha256sum] = "19c6601cd91f8cf040a143cc1abf48adbf15e4e3105568b5db0182361f2358b6"

URI_x86_64_v2_ghc-hourglass-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hourglass-doc-0.2.12-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hourglass-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hourglass-doc}"
SRC_URI[x86_64_v2_ghc-hourglass-doc.sha256sum] = "fd85be8238914d75d4ed3f80640fb73ff3dd7d68e5a7ee4db0b9e0ba11fda18e"

URI_x86_64_v2_ghc-hourglass-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hourglass-prof-0.2.12-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hourglass-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hourglass-prof}"
SRC_URI[x86_64_v2_ghc-hourglass-prof.sha256sum] = "2da2764b4b4b5485e0448c02b124f7ea9956025383942d725547db395eb031e2"

URI_aarch64_ghc-hourglass = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hourglass-0.2.12-27.el10_0.aarch64.rpm;name=aarch64_ghc-hourglass;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hourglass}"
SRC_URI[aarch64_ghc-hourglass.sha256sum] = "451bf36582ec2bcca0bf416a41527f920a4cbd61783bda5e0283dad1b84d6ae3"

URI_aarch64_ghc-hourglass-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hourglass-devel-0.2.12-27.el10_0.aarch64.rpm;name=aarch64_ghc-hourglass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hourglass-devel}"
SRC_URI[aarch64_ghc-hourglass-devel.sha256sum] = "bec62099301003acfcad40f28a8ada7167fded2558c57440c9c1e6e5b6f0020e"

URI_aarch64_ghc-hourglass-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hourglass-doc-0.2.12-27.el10_0.noarch.rpm;name=aarch64_ghc-hourglass-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hourglass-doc}"
SRC_URI[aarch64_ghc-hourglass-doc.sha256sum] = "f9261c21fd6927886c3c65d48401859c7ae72f15ffdfff1e3f6e3e3cf8650d40"

URI_aarch64_ghc-hourglass-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hourglass-prof-0.2.12-27.el10_0.aarch64.rpm;name=aarch64_ghc-hourglass-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hourglass-prof}"
SRC_URI[aarch64_ghc-hourglass-prof.sha256sum] = "5b1b7ad96347236e369718d1629a813e12914dcb7f8ef1af52577e91edb7d5e9"

RDEPENDS:ghc-hourglass = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hourglass-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-hourglass \
 "
RDEPENDS:ghc-hourglass-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hourglass-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-hourglass-devel \
 "
