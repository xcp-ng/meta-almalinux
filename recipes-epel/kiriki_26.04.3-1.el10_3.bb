# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiriki"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kiriki \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiriki-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7a2651bf3ea2102ee82e20cf1fa4134340c8a84425d2e2b763ac2d419d40c0d"

URI_x86_64_v2_kiriki = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiriki-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiriki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiriki}"
SRC_URI[x86_64_v2_kiriki.sha256sum] = "afa7d2c215ac3a36fd6106066c417320ec0ec82c8e471edfec485fdbe0e7ff15"

URI_aarch64_kiriki = "${EPEL_MIRROR}/aarch64/Packages/k/kiriki-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kiriki;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiriki}"
SRC_URI[aarch64_kiriki.sha256sum] = "d313f2a7d1923a15cf796c8d9b22cc4bcb6b0d847e55af6791e68b5fece61eb7"

RDEPENDS:kiriki = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
