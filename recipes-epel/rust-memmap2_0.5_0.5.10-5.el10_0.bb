# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memmap2_0.5"
PV = "0.5.10"
PR = "5.el10_0"
PACKAGES = " \
 rust-memmap2_0.5+default-devel \
 rust-memmap2_0.5+stable_deref_trait-devel \
 rust-memmap2_0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memmap2_0.5-0.5.10-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3762f866f072ee28d2dae88b860c1b0a41c35dfd859825149fbba5c1cbda8fa6"

URI_x86_64_v2_rust-memmap2_0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2_0.5+default-devel-0.5.10-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2_0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2_0.5+default-devel}"
SRC_URI[x86_64_v2_rust-memmap2_0.5+default-devel.sha256sum] = "998ac43e85e01cdf762b427218f50737ae5e3028924ef21d3f6b147e99755d15"

URI_x86_64_v2_rust-memmap2_0.5+stable_deref_trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2_0.5+stable_deref_trait-devel-0.5.10-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2_0.5+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2_0.5+stable_deref_trait-devel}"
SRC_URI[x86_64_v2_rust-memmap2_0.5+stable_deref_trait-devel.sha256sum] = "ba8a6fb1a07a0bc0a426ab50e16367fdda0e508d6b3470df8e7243df059a9cc5"

URI_x86_64_v2_rust-memmap2_0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2_0.5-devel-0.5.10-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2_0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2_0.5-devel}"
SRC_URI[x86_64_v2_rust-memmap2_0.5-devel.sha256sum] = "5b1a370a7d3ef935757af209c776586e11646f05a745d0c914d3c02458f8e59c"

URI_aarch64_rust-memmap2_0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2_0.5+default-devel-0.5.10-5.el10_0.noarch.rpm;name=aarch64_rust-memmap2_0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2_0.5+default-devel}"
SRC_URI[aarch64_rust-memmap2_0.5+default-devel.sha256sum] = "7e7a71e29589e9aa741d81e227d7755cea65759a1afb26ff61fc760846991330"

URI_aarch64_rust-memmap2_0.5+stable_deref_trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2_0.5+stable_deref_trait-devel-0.5.10-5.el10_0.noarch.rpm;name=aarch64_rust-memmap2_0.5+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2_0.5+stable_deref_trait-devel}"
SRC_URI[aarch64_rust-memmap2_0.5+stable_deref_trait-devel.sha256sum] = "1a83ea2bcbd30fab46bde444853e40fead3b59a83ec4a999238e3ed4ad702a78"

URI_aarch64_rust-memmap2_0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2_0.5-devel-0.5.10-5.el10_0.noarch.rpm;name=aarch64_rust-memmap2_0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2_0.5-devel}"
SRC_URI[aarch64_rust-memmap2_0.5-devel.sha256sum] = "212fb9ab1de0570ce28132b5250232962fd99a7a2262d9c2b97243f2a92ae33b"

RDEPENDS:rust-memmap2_0.5+default-devel = " \
 cargo \
 rust-memmap2_0.5-devel \
 "
RDEPENDS:rust-memmap2_0.5+stable_deref_trait-devel = " \
 cargo \
 rust-memmap2_0.5-devel \
 rust-stable_deref_trait+default-devel \
 "
RDEPENDS:rust-memmap2_0.5-devel = " \
 cargo \
 rust-libc+default-devel \
 "
