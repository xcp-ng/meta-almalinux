# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-se"
PV = "1.0"
PR = "0.32.beta7.el10"
PACKAGES = " \
 hunspell-se \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-se-1.0-0.32.beta7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7bef15a5e5344c2e98c02867e1ace237f6a75737b04cc92076ba262c1cc4ad1"

URI_x86_64_v2_hunspell-se = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-se-1.0-0.32.beta7.el10.noarch.rpm;name=x86_64_v2_hunspell-se;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-se}"
SRC_URI[x86_64_v2_hunspell-se.sha256sum] = "d1a20b675b4a9ccb54795646f4ced3e864bc21c0e46f6cedacad35c65abf2513"

URI_aarch64_hunspell-se = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-se-1.0-0.32.beta7.el10.noarch.rpm;name=aarch64_hunspell-se;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-se}"
SRC_URI[aarch64_hunspell-se.sha256sum] = "d1a20b675b4a9ccb54795646f4ced3e864bc21c0e46f6cedacad35c65abf2513"

RDEPENDS:hunspell-se = " \
 hunspell \
 "
