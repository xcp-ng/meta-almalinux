# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-string_cache_codegen"
PV = "0.5.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-string_cache_codegen+default-devel \
 rust-string_cache_codegen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-string_cache_codegen-0.5.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f014ef3849ef0af5fcd9846d0656e57278ee39e66bb9c50ea0d0bf705d30379f"

URI_x86_64_v2_rust-string_cache_codegen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache_codegen+default-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache_codegen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache_codegen+default-devel}"
SRC_URI[x86_64_v2_rust-string_cache_codegen+default-devel.sha256sum] = "4e90b401311e074551eb44ab82308cba396ec7fb0da4015514c6899ed8bb7ebe"

URI_x86_64_v2_rust-string_cache_codegen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache_codegen-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache_codegen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache_codegen-devel}"
SRC_URI[x86_64_v2_rust-string_cache_codegen-devel.sha256sum] = "667a5a78dbf31b6b4a4dea652b4bc0991a4ef328088f61574a9da7bccb44cd41"

URI_aarch64_rust-string_cache_codegen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache_codegen+default-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-string_cache_codegen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache_codegen+default-devel}"
SRC_URI[aarch64_rust-string_cache_codegen+default-devel.sha256sum] = "9a17aac5bd4ac2f4b5d1860fa30c443366d582629c6ecab01d0f3074ea1d8f51"

URI_aarch64_rust-string_cache_codegen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache_codegen-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-string_cache_codegen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache_codegen-devel}"
SRC_URI[aarch64_rust-string_cache_codegen-devel.sha256sum] = "ae9a973e0b80828f2e4ddbe7d4a235432dcaa48bdd1c895096a03cbb4355b081"

RDEPENDS:rust-string_cache_codegen+default-devel = " \
 cargo \
 rust-string_cache_codegen-devel \
 "
RDEPENDS:rust-string_cache_codegen-devel = " \
 cargo \
 rust-phf_generator+default-devel \
 rust-phf_shared+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
