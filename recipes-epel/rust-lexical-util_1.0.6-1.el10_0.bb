# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexical-util"
PV = "1.0.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-lexical-util+compact-devel \
 rust-lexical-util+default-devel \
 rust-lexical-util+f128-devel \
 rust-lexical-util+f16-devel \
 rust-lexical-util+floats-devel \
 rust-lexical-util+format-devel \
 rust-lexical-util+integers-devel \
 rust-lexical-util+lint-devel \
 rust-lexical-util+parse-devel \
 rust-lexical-util+parse-floats-devel \
 rust-lexical-util+parse-integers-devel \
 rust-lexical-util+power-of-two-devel \
 rust-lexical-util+radix-devel \
 rust-lexical-util+std-devel \
 rust-lexical-util+write-devel \
 rust-lexical-util+write-floats-devel \
 rust-lexical-util+write-integers-devel \
 rust-lexical-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexical-util-1.0.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a708ea192fcc85820cdeb923d75eaa97fc406916688a1aa7b346d24d80a6c7e"

URI_x86_64_v2_rust-lexical-util+compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+compact-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+compact-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+compact-devel.sha256sum] = "be9568bde8b1b07f480bc01c1c57b8ad595270848040ef2d0189dbafb544f94b"

URI_x86_64_v2_rust-lexical-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+default-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+default-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+default-devel.sha256sum] = "2c8d76fe0946ab604b715658fd6e0057ffabb4fd691359df486e1556b5378002"

URI_x86_64_v2_rust-lexical-util+f128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+f128-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+f128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+f128-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+f128-devel.sha256sum] = "3c275f7873cd49d99601f08a83fa24d6409d5e421c6d418173f698e47251f52d"

URI_x86_64_v2_rust-lexical-util+f16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+f16-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+f16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+f16-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+f16-devel.sha256sum] = "f768b4f6ae3253d7bacdc6f332eb9512f562455f7498d3c4b3b1d01638e580cd"

URI_x86_64_v2_rust-lexical-util+floats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+floats-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+floats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+floats-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+floats-devel.sha256sum] = "6027af6443b3b3a4eb42a40e2434636b0bf022a43b119f2ba433faacee4f689d"

URI_x86_64_v2_rust-lexical-util+format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+format-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+format-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+format-devel.sha256sum] = "f56924852909f99a9d39db7d6566ed9b1e458b000a3ececc7c225776e1156bed"

URI_x86_64_v2_rust-lexical-util+integers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+integers-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+integers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+integers-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+integers-devel.sha256sum] = "b4652a3b28d665727e22a256650ce8b3c195c973e638c804fa194848435fe07b"

URI_x86_64_v2_rust-lexical-util+lint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+lint-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+lint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+lint-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+lint-devel.sha256sum] = "7c24600cbed35ba1bd4d8b83b99e1da8c0b5393dfaefc0a4dd50e0d9e21b69e8"

URI_x86_64_v2_rust-lexical-util+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+parse-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+parse-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+parse-devel.sha256sum] = "64110d3c8e942f32a7fcf9f9d39fa6e139ce8b08af9a74b794691d5eaa40671c"

URI_x86_64_v2_rust-lexical-util+parse-floats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+parse-floats-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+parse-floats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+parse-floats-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+parse-floats-devel.sha256sum] = "8d2be961047664cc4e2dca595b2d7dd6a8858841d5da39a38ef67ee72f1ee261"

URI_x86_64_v2_rust-lexical-util+parse-integers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+parse-integers-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+parse-integers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+parse-integers-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+parse-integers-devel.sha256sum] = "34fb8ce5c028e2fe27729ac5f533b978c7c9cd75992173e7abf1ad2f1024b3f5"

URI_x86_64_v2_rust-lexical-util+power-of-two-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+power-of-two-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+power-of-two-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+power-of-two-devel.sha256sum] = "9f78ae662e0677070eae0982361e8c0ac62bcbd7058c893125ef7363cd8a3a86"

URI_x86_64_v2_rust-lexical-util+radix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+radix-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+radix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+radix-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+radix-devel.sha256sum] = "6bde8accddff764113db9f76f3f15021ca6ef4c62b176eda23a5b28d6bb453b6"

URI_x86_64_v2_rust-lexical-util+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+std-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+std-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+std-devel.sha256sum] = "b764b1451a19256b0f816147a1bd6a0ec44f40cdf3510a23174a107847edad7e"

URI_x86_64_v2_rust-lexical-util+write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+write-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+write-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+write-devel.sha256sum] = "309cb6213f8016099530fb19d9bf8c9734f0a2dddc8f596119c860d31474a0aa"

URI_x86_64_v2_rust-lexical-util+write-floats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+write-floats-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+write-floats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+write-floats-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+write-floats-devel.sha256sum] = "2549a212aa221a1a3c5d90032a36b077b25b89cc23145d91cf728ac48d29e704"

URI_x86_64_v2_rust-lexical-util+write-integers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+write-integers-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+write-integers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util+write-integers-devel}"
SRC_URI[x86_64_v2_rust-lexical-util+write-integers-devel.sha256sum] = "a8461644cca488b3ab1e5df3156d1c2d53fc167a1d597eb0d7e7f6bde1b6ee8e"

URI_x86_64_v2_rust-lexical-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util-devel-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-util-devel}"
SRC_URI[x86_64_v2_rust-lexical-util-devel.sha256sum] = "feac8124fd9451ca7f78deff433e33a8437f64bc08e13064210078bcab367d54"

URI_aarch64_rust-lexical-util+compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+compact-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+compact-devel}"
SRC_URI[aarch64_rust-lexical-util+compact-devel.sha256sum] = "dea1bc5b9f80f4acb96a7d507497ff5893878c20134ae89ccd7a29461b9eef69"

URI_aarch64_rust-lexical-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+default-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+default-devel}"
SRC_URI[aarch64_rust-lexical-util+default-devel.sha256sum] = "bd9668d5778d78faf465c3fbecbd773b95f40d5a9bef524c9fc28e17c1c59856"

URI_aarch64_rust-lexical-util+f128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+f128-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+f128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+f128-devel}"
SRC_URI[aarch64_rust-lexical-util+f128-devel.sha256sum] = "7b051e2627a14ee2d6833c233d720066e66a8c6e79d8d66801c378bab853ad5b"

URI_aarch64_rust-lexical-util+f16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+f16-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+f16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+f16-devel}"
SRC_URI[aarch64_rust-lexical-util+f16-devel.sha256sum] = "baa87a528bba91be13866453ecf41e84a79ed4dd85e76e9370245fd9e7074cf8"

URI_aarch64_rust-lexical-util+floats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+floats-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+floats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+floats-devel}"
SRC_URI[aarch64_rust-lexical-util+floats-devel.sha256sum] = "3431b0c7d532046295fb0804ecb784b17475bbf1429ecba5a08d5b6256240961"

URI_aarch64_rust-lexical-util+format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+format-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+format-devel}"
SRC_URI[aarch64_rust-lexical-util+format-devel.sha256sum] = "7dd3ba8f00b9952a37d8f693c114afbf3cd3caf763c43a801adc96b3044b790f"

URI_aarch64_rust-lexical-util+integers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+integers-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+integers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+integers-devel}"
SRC_URI[aarch64_rust-lexical-util+integers-devel.sha256sum] = "a84959f3258f183e627b3756b09cd0b949f4dd633ea63f10325b7d40347b7891"

URI_aarch64_rust-lexical-util+lint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+lint-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+lint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+lint-devel}"
SRC_URI[aarch64_rust-lexical-util+lint-devel.sha256sum] = "963796506aea2c64ff926b10f49f7d0f0fa092b9d8cafa434333634ba75dcc5f"

URI_aarch64_rust-lexical-util+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+parse-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+parse-devel}"
SRC_URI[aarch64_rust-lexical-util+parse-devel.sha256sum] = "01f2ec22d12a4150f014cc7cf50a27373d4567e2574c307bea37e70a212b63b6"

URI_aarch64_rust-lexical-util+parse-floats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+parse-floats-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+parse-floats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+parse-floats-devel}"
SRC_URI[aarch64_rust-lexical-util+parse-floats-devel.sha256sum] = "2a27182f805ccccc609c0c554ece5812d1b417cf5803a1d22d64b37b1df3fe96"

URI_aarch64_rust-lexical-util+parse-integers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+parse-integers-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+parse-integers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+parse-integers-devel}"
SRC_URI[aarch64_rust-lexical-util+parse-integers-devel.sha256sum] = "34188f8aeebe5062424db31c6abe155625f2a6db60a778cde13e7360ea19e7d2"

URI_aarch64_rust-lexical-util+power-of-two-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+power-of-two-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+power-of-two-devel}"
SRC_URI[aarch64_rust-lexical-util+power-of-two-devel.sha256sum] = "7d32438cd564fd4c492f79656483567e8f294502dc2be766bf05353f8b456c52"

URI_aarch64_rust-lexical-util+radix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+radix-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+radix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+radix-devel}"
SRC_URI[aarch64_rust-lexical-util+radix-devel.sha256sum] = "43528600a6938b06412cbabb9930321b0c4ddb556356422f4041462d9852666e"

URI_aarch64_rust-lexical-util+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+std-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+std-devel}"
SRC_URI[aarch64_rust-lexical-util+std-devel.sha256sum] = "332d5b4d5befcfe57d6c0c3f0da73a76c737a5a02ae37e90d8e34acad3e704e2"

URI_aarch64_rust-lexical-util+write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+write-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+write-devel}"
SRC_URI[aarch64_rust-lexical-util+write-devel.sha256sum] = "b8d77ad7f8cbc1d5c8c8a8b3267bae4bda0e3d71d00fb32a7e52bc1236b4a18f"

URI_aarch64_rust-lexical-util+write-floats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+write-floats-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+write-floats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+write-floats-devel}"
SRC_URI[aarch64_rust-lexical-util+write-floats-devel.sha256sum] = "f1a736d500b76af544c5a04d0255383095150ef29441575aded5f1bd36ac8901"

URI_aarch64_rust-lexical-util+write-integers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+write-integers-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util+write-integers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util+write-integers-devel}"
SRC_URI[aarch64_rust-lexical-util+write-integers-devel.sha256sum] = "546567e7f32be692e5cb653c75c28b5c515eb996a97051a17e9d47ec0a6af89e"

URI_aarch64_rust-lexical-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util-devel-1.0.6-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-util-devel}"
SRC_URI[aarch64_rust-lexical-util-devel.sha256sum] = "c725acdd36997c09abe83a5ef757e6b8c15453003086366db35880f6dac8666f"

RDEPENDS:rust-lexical-util+compact-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+default-devel = " \
 cargo \
 rust-lexical-util+std-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+f128-devel = " \
 cargo \
 rust-lexical-util+parse-floats-devel \
 rust-lexical-util+write-floats-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+f16-devel = " \
 cargo \
 rust-lexical-util+parse-floats-devel \
 rust-lexical-util+write-floats-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+floats-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+format-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+integers-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+lint-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+parse-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+parse-floats-devel = " \
 cargo \
 rust-lexical-util+floats-devel \
 rust-lexical-util+parse-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+parse-integers-devel = " \
 cargo \
 rust-lexical-util+integers-devel \
 rust-lexical-util+parse-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+power-of-two-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+radix-devel = " \
 cargo \
 rust-lexical-util+power-of-two-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+std-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+write-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+write-floats-devel = " \
 cargo \
 rust-lexical-util+floats-devel \
 rust-lexical-util+write-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+write-integers-devel = " \
 cargo \
 rust-lexical-util+integers-devel \
 rust-lexical-util+write-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util-devel = " \
 cargo \
 rust \
 rust-static_assertions+default-devel \
 "
