# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libspiro"
PV = "20240903"
PR = "3.el10_2"
PACKAGES = " \
 libspiro \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libspiro-20240903-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "de976b924c2f852c578572956ddea302e950a935a2e561cba20fbf4eb96bf2b6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libspiro-20240903-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_libspiro;unpack=0"
SRC_URI[x86_64_v2_libspiro.sha256sum] = "29a5433c8ac0f018beab8adda2a828257279a0801b0a207b006149e30f49a90d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libspiro-20240903-3.el10_2.aarch64.rpm;name=aarch64_libspiro;unpack=0"
SRC_URI[aarch64_libspiro.sha256sum] = "2b326373d26c59c67c2a7dcc076793db5500b50b83d1548dc0a1d427080c5928"

RDEPENDS:libspiro = " \
 glibc \
 "
