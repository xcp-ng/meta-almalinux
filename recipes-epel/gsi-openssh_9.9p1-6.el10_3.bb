# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gsi-openssh"
PV = "9.9p1"
PR = "6.el10_3"
PACKAGES = " \
 gsi-openssh \
 gsi-openssh-clients \
 gsi-openssh-keysign \
 gsi-openssh-server \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gsi-openssh-9.9p1-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee587fe8ee7b93879296d760d0b8e82691567573d75a6dd0bfdca84554470fe7"

URI_x86_64_v2_gsi-openssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-9.9p1-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh}"
SRC_URI[x86_64_v2_gsi-openssh.sha256sum] = "9ac56838f940be6c38ca1bf73c9cc6660eb5dbd7fb96cf3d733240421ddfe989"

URI_x86_64_v2_gsi-openssh-clients = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-clients-9.9p1-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh-clients}"
SRC_URI[x86_64_v2_gsi-openssh-clients.sha256sum] = "f41543d2c387f5ab3d30162956e32cbfdc82955fda93c3c51e29cfaefeba960c"

URI_x86_64_v2_gsi-openssh-keysign = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-keysign-9.9p1-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh-keysign}"
SRC_URI[x86_64_v2_gsi-openssh-keysign.sha256sum] = "c734a24748ad575bf13384c7d576aec240b440737c8293c3157eeb8bdfe3e771"

URI_x86_64_v2_gsi-openssh-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-server-9.9p1-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh-server}"
SRC_URI[x86_64_v2_gsi-openssh-server.sha256sum] = "7314d52a285db5c2cc679ae9edc6cd609e5c7536156dfb7e52ffffa092575a95"

URI_aarch64_gsi-openssh = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-9.9p1-6.el10_3.aarch64.rpm;name=aarch64_gsi-openssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh}"
SRC_URI[aarch64_gsi-openssh.sha256sum] = "430aa4f3071fad3eabdd33223e858910d52e1285f1ca2c849fea984a6eb23125"

URI_aarch64_gsi-openssh-clients = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-clients-9.9p1-6.el10_3.aarch64.rpm;name=aarch64_gsi-openssh-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh-clients}"
SRC_URI[aarch64_gsi-openssh-clients.sha256sum] = "03d319db9e957fbaf391200b079f86853670fd20a6cd45050ee98e86bfe10fec"

URI_aarch64_gsi-openssh-keysign = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-keysign-9.9p1-6.el10_3.aarch64.rpm;name=aarch64_gsi-openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh-keysign}"
SRC_URI[aarch64_gsi-openssh-keysign.sha256sum] = "cc789cc9ddfd3587b0d0cf0973b6893ec7928fb5ecdad6734cecf88be38d225a"

URI_aarch64_gsi-openssh-server = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-server-9.9p1-6.el10_3.aarch64.rpm;name=aarch64_gsi-openssh-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh-server}"
SRC_URI[aarch64_gsi-openssh-server.sha256sum] = "86c564193a122b564830d5dab5555621afaf876c75909c866ed849c2d43ee017"

RDEPENDS:gsi-openssh = " \
 audit-libs \
 glibc \
 libgcc \
 libselinux \
 openssl-libs \
 util-linux \
 "
RDEPENDS:gsi-openssh-clients = " \
 crypto-policies \
 glibc \
 globus-gssapi-gsi \
 gsi-openssh \
 libedit \
 libfido2 \
 libgcc \
 libselinux \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gsi-openssh-keysign = " \
 glibc \
 gsi-openssh \
 libgcc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gsi-openssh-server = " \
 audit-libs \
 bash \
 crypto-policies \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 gsi-openssh \
 libgcc \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam \
 pam-libs \
 policycoreutils-python-utils \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
