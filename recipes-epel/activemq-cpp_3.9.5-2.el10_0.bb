# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "activemq-cpp"
PV = "3.9.5"
PR = "2.el10_0"
PACKAGES = " \
 activemq-cpp \
 activemq-cpp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/activemq-cpp-3.9.5-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52e38e98d4e0e6bf7f2462722ca10ba55e85470ba91df448b6d4846e646ffa50"

URI_x86_64_v2_activemq-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/activemq-cpp-3.9.5-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_activemq-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_activemq-cpp}"
SRC_URI[x86_64_v2_activemq-cpp.sha256sum] = "d786dea1f7d45889cccc9e86d0deb260e43250e476c7e118c9c1f24a044ef978"

URI_x86_64_v2_activemq-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/activemq-cpp-devel-3.9.5-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_activemq-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_activemq-cpp-devel}"
SRC_URI[x86_64_v2_activemq-cpp-devel.sha256sum] = "90893db3628459fc384add9a9765c523173b8a4ab996ed53389989624b6921ad"

URI_aarch64_activemq-cpp = "${EPEL_MIRROR}/aarch64/Packages/a/activemq-cpp-3.9.5-2.el10_0.aarch64.rpm;name=aarch64_activemq-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_activemq-cpp}"
SRC_URI[aarch64_activemq-cpp.sha256sum] = "3a60e07337c6eafcea1c35476025f5ea0a219f3e6ae84d5802dc7d0bd62554a2"

URI_aarch64_activemq-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/a/activemq-cpp-devel-3.9.5-2.el10_0.aarch64.rpm;name=aarch64_activemq-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_activemq-cpp-devel}"
SRC_URI[aarch64_activemq-cpp-devel.sha256sum] = "9a80d08dcad732c92a0ee8b262d0a33cec7d50e5d996e01cf282a300a5ace74d"

RDEPENDS:activemq-cpp = " \
 apr \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:activemq-cpp-devel = " \
 activemq-cpp \
 apr-devel \
 bash \
 libuuid-devel \
 pkgconf-pkg-config \
 "
