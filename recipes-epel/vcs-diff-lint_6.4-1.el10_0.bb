# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vcs-diff-lint"
PV = "6.4"
PR = "1.el10_0"
PACKAGES = " \
 vcs-diff-lint \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vcs-diff-lint-6.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44e0efd342f83c0cc03aa019b5915284382bb96f3a3ee5b9537a5cd02d17928b"

URI_x86_64_v2_vcs-diff-lint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vcs-diff-lint-6.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_vcs-diff-lint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vcs-diff-lint}"
SRC_URI[x86_64_v2_vcs-diff-lint.sha256sum] = "dca590cc0f830df4db06eab8fbf2e9d3a8a4d32ac094b7668c92d26c60395c89"

URI_aarch64_vcs-diff-lint = "${EPEL_MIRROR}/aarch64/Packages/v/vcs-diff-lint-6.4-1.el10_0.noarch.rpm;name=aarch64_vcs-diff-lint;unpack=0"
SRC_URI:append = " ${URI_aarch64_vcs-diff-lint}"
SRC_URI[aarch64_vcs-diff-lint.sha256sum] = "63f40498455b26d45abf3f3060262cb479bd46e2a5e968ef0896222e08e68a89"

RDEPENDS:vcs-diff-lint = " \
 csdiff \
 git \
 python3 \
 "
