# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scroll_derive0.12"
PV = "0.12.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-scroll_derive0.12+default-devel \
 rust-scroll_derive0.12-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scroll_derive0.12-0.12.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99e12735a5516e6f3493f91f7f86f95ad43151d25fad7933393c99ccf59c7b4f"

URI_x86_64_v2_rust-scroll_derive0.12+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll_derive0.12+default-devel-0.12.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll_derive0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll_derive0.12+default-devel}"
SRC_URI[x86_64_v2_rust-scroll_derive0.12+default-devel.sha256sum] = "0b393bfd742e708c8475df7dc99e9e38493f0224127c4a4ccb6657468a04c994"

URI_x86_64_v2_rust-scroll_derive0.12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll_derive0.12-devel-0.12.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll_derive0.12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll_derive0.12-devel}"
SRC_URI[x86_64_v2_rust-scroll_derive0.12-devel.sha256sum] = "56a5be2b18b46fa91add9be5c2b532cb19d83655c8c4b1429f4804611f1f77f4"

URI_aarch64_rust-scroll_derive0.12+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll_derive0.12+default-devel-0.12.1-1.el10_1.noarch.rpm;name=aarch64_rust-scroll_derive0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll_derive0.12+default-devel}"
SRC_URI[aarch64_rust-scroll_derive0.12+default-devel.sha256sum] = "bc58567e3701d95e3be7a0abc8f5fd5afa68c7a5af57e8efe2ba0c13a455880f"

URI_aarch64_rust-scroll_derive0.12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll_derive0.12-devel-0.12.1-1.el10_1.noarch.rpm;name=aarch64_rust-scroll_derive0.12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll_derive0.12-devel}"
SRC_URI[aarch64_rust-scroll_derive0.12-devel.sha256sum] = "205a028b4290ae398f321e3743246944612f644594f0bf7d02945789c46c0427"

RDEPENDS:rust-scroll_derive0.12+default-devel = " \
 cargo \
 rust-scroll_derive0.12-devel \
 "
RDEPENDS:rust-scroll_derive0.12-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
