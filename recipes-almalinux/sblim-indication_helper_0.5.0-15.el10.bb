# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sblim-indication_helper"
PV = "0.5.0"
PR = "15.el10"
PACKAGES = " \
 sblim-indication_helper \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sblim-indication_helper-0.5.0-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bc1221c117a0eefa17bd1155906a70a5c1d368cdae3cf37b617b01e533bed56"

URI_x86_64_v2_sblim-indication_helper = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sblim-indication_helper-0.5.0-15.el10.x86_64_v2.rpm;name=x86_64_v2_sblim-indication_helper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sblim-indication_helper}"
SRC_URI[x86_64_v2_sblim-indication_helper.sha256sum] = "6aa9955c3a0edc9ecf33e58dea5d7b660a0d75c8f61576eeb4f5d512ae32cd76"

URI_aarch64_sblim-indication_helper = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sblim-indication_helper-0.5.0-15.el10.aarch64.rpm;name=aarch64_sblim-indication_helper;unpack=0"
SRC_URI:append = " ${URI_aarch64_sblim-indication_helper}"
SRC_URI[aarch64_sblim-indication_helper.sha256sum] = "c4ab1bd23a34b87fd3a2ea8121550e30364f5430224f2e933c4f3fe3cfe8306e"

RDEPENDS:sblim-indication_helper = " \
 glibc \
 "
