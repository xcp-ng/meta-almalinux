# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ref-cast-impl"
PV = "1.0.25"
PR = "1.el10_2"
PACKAGES = " \
 rust-ref-cast-impl+default-devel \
 rust-ref-cast-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ref-cast-impl-1.0.25-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20a98c94e7d85f168cf57169d9196791285d1ed2dea8391576d7cf368de1642c"

URI_x86_64_v2_rust-ref-cast-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast-impl+default-devel-1.0.25-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ref-cast-impl+default-devel}"
SRC_URI[x86_64_v2_rust-ref-cast-impl+default-devel.sha256sum] = "8b89c6937e89b9975d72c736357abdb6cd27657e43ee45929c415eabd43eb959"

URI_x86_64_v2_rust-ref-cast-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast-impl-devel-1.0.25-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ref-cast-impl-devel}"
SRC_URI[x86_64_v2_rust-ref-cast-impl-devel.sha256sum] = "6ab09a60e397f6e35e254e0b2b85e5fa9556d9e83d774c5ceffd32805f3c9275"

URI_aarch64_rust-ref-cast-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast-impl+default-devel-1.0.25-1.el10_2.noarch.rpm;name=aarch64_rust-ref-cast-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ref-cast-impl+default-devel}"
SRC_URI[aarch64_rust-ref-cast-impl+default-devel.sha256sum] = "0eaf4279c7c8fca1abb5e36b5d97d231a42436975a7635a549cb7da2e707e1a2"

URI_aarch64_rust-ref-cast-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast-impl-devel-1.0.25-1.el10_2.noarch.rpm;name=aarch64_rust-ref-cast-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ref-cast-impl-devel}"
SRC_URI[aarch64_rust-ref-cast-impl-devel.sha256sum] = "90d592976241e5050e0b7672f1dcfce3d76727060b9cc6fba0cdd01ac7e88ae8"

RDEPENDS:rust-ref-cast-impl+default-devel = " \
 cargo \
 rust-ref-cast-impl-devel \
 "
RDEPENDS:rust-ref-cast-impl-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
