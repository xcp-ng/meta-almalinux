# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fido-device-onboard"
PV = "0.5.3"
PR = "2.el10"
PACKAGES = " \
 fdo-admin-cli \
 fdo-client \
 fdo-init \
 fdo-manufacturing-server \
 fdo-owner-cli \
 fdo-owner-onboarding-server \
 fdo-rendezvous-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fido-device-onboard-0.5.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afb8dc3d1925dbb050388052027a6aec287940a7602ea3536b0c3fcb109fd181"

URI_x86_64_v2_fdo-admin-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-admin-cli-0.5.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-admin-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-admin-cli}"
SRC_URI[x86_64_v2_fdo-admin-cli.sha256sum] = "1a4df67d781a6184b390d12dbcf6b5dee502e54e131e590a1e56820b7379bc08"

URI_x86_64_v2_fdo-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-client-0.5.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-client}"
SRC_URI[x86_64_v2_fdo-client.sha256sum] = "992c15c26032cfcdf09cc0ce5c5d2f82f36f7bb209fea70af8033182442d2f6e"

URI_x86_64_v2_fdo-init = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-init-0.5.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-init;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-init}"
SRC_URI[x86_64_v2_fdo-init.sha256sum] = "bdcded553e576da5693c94a604a6e97a35ec47bd706d381cbeac6f38daab6221"

URI_x86_64_v2_fdo-manufacturing-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-manufacturing-server-0.5.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-manufacturing-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-manufacturing-server}"
SRC_URI[x86_64_v2_fdo-manufacturing-server.sha256sum] = "f30bbf6340c603e663e41d4e746d461dbfc9cf5764145031da1f1c3646d72a6d"

URI_x86_64_v2_fdo-owner-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-owner-cli-0.5.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-owner-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-owner-cli}"
SRC_URI[x86_64_v2_fdo-owner-cli.sha256sum] = "d300d16c6719f82ab34e356e5bd6633ea799f66c64b1efd5886848748b76cdd0"

URI_x86_64_v2_fdo-owner-onboarding-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-owner-onboarding-server-0.5.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-owner-onboarding-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-owner-onboarding-server}"
SRC_URI[x86_64_v2_fdo-owner-onboarding-server.sha256sum] = "85912d97a885e6c4d7e9726470686317055b307202698729fb6ed940c43d9d33"

URI_x86_64_v2_fdo-rendezvous-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-rendezvous-server-0.5.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_fdo-rendezvous-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-rendezvous-server}"
SRC_URI[x86_64_v2_fdo-rendezvous-server.sha256sum] = "bc345792e0fdbb59eb30c001817701e2f9ed8903b7d723d0afd414c361934406"

URI_aarch64_fdo-admin-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-admin-cli-0.5.3-2.el10.aarch64.rpm;name=aarch64_fdo-admin-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_fdo-admin-cli}"
SRC_URI[aarch64_fdo-admin-cli.sha256sum] = "734cad8b3c89ebbd64816572eb7f30dde0149b56c56ba3c86284d7c71f212257"

URI_aarch64_fdo-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-client-0.5.3-2.el10.aarch64.rpm;name=aarch64_fdo-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_fdo-client}"
SRC_URI[aarch64_fdo-client.sha256sum] = "42e1cf7c6d0cd8ab9032cacac5494cda894a588bbbd7f94258034716ffdb5343"

URI_aarch64_fdo-init = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-init-0.5.3-2.el10.aarch64.rpm;name=aarch64_fdo-init;unpack=0"
SRC_URI:append = " ${URI_aarch64_fdo-init}"
SRC_URI[aarch64_fdo-init.sha256sum] = "baaf46619e4bce35210d4762a1746fb22c9dd0e5be549c95c3b014bf186c9a41"

URI_aarch64_fdo-manufacturing-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-manufacturing-server-0.5.3-2.el10.aarch64.rpm;name=aarch64_fdo-manufacturing-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_fdo-manufacturing-server}"
SRC_URI[aarch64_fdo-manufacturing-server.sha256sum] = "504eb6c848e030b69b5b8084c769f3bd5f6f7b6e91f7cdb3f151660b9a9bd280"

URI_aarch64_fdo-owner-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-owner-cli-0.5.3-2.el10.aarch64.rpm;name=aarch64_fdo-owner-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_fdo-owner-cli}"
SRC_URI[aarch64_fdo-owner-cli.sha256sum] = "0521b6f3e545575abb1ff595ff5b129492413c5d6a4a5888e895c59ffc13c2c2"

URI_aarch64_fdo-owner-onboarding-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-owner-onboarding-server-0.5.3-2.el10.aarch64.rpm;name=aarch64_fdo-owner-onboarding-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_fdo-owner-onboarding-server}"
SRC_URI[aarch64_fdo-owner-onboarding-server.sha256sum] = "186569cf3808ec65abb7c3b8f367ba158893beaba010df3de765acaea61f7e4a"

URI_aarch64_fdo-rendezvous-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdo-rendezvous-server-0.5.3-2.el10.aarch64.rpm;name=aarch64_fdo-rendezvous-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_fdo-rendezvous-server}"
SRC_URI[aarch64_fdo-rendezvous-server.sha256sum] = "586c75518d37f31000cbeaeba0f4f9b3e1598c3593808887a0b2a27e72169e6d"

RDEPENDS:fdo-admin-cli = " \
 bash \
 fdo-client \
 fdo-init \
 fdo-manufacturing-server \
 fdo-owner-cli \
 fdo-owner-onboarding-server \
 fdo-rendezvous-server \
 glibc \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-client = " \
 bash \
 clevis \
 clevis-luks \
 clevis-pin-tpm2 \
 cryptsetup \
 cryptsetup-libs \
 glibc \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-init = " \
 bash \
 dracut \
 glibc \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-manufacturing-server = " \
 bash \
 glibc \
 libgcc \
 libpq \
 openssl-libs \
 sqlite-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-owner-cli = " \
 glibc \
 libgcc \
 libpq \
 openssl-libs \
 sqlite-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-owner-onboarding-server = " \
 bash \
 glibc \
 libgcc \
 libpq \
 openssl-libs \
 sqlite-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-rendezvous-server = " \
 bash \
 glibc \
 libgcc \
 libpq \
 openssl-libs \
 sqlite-libs \
 tpm2-tss \
 "
