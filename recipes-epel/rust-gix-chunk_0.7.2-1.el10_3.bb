# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-chunk"
PV = "0.7.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-chunk+default-devel \
 rust-gix-chunk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-chunk-0.7.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ee7bb4573dde184bd205114c1ddfd9d218d1700b8d34b79ce12674c59ae4dca"

URI_x86_64_v2_rust-gix-chunk+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-chunk+default-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-chunk+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-chunk+default-devel}"
SRC_URI[x86_64_v2_rust-gix-chunk+default-devel.sha256sum] = "d6840e6a7e98fb0984c66d89eab1f451d853108ce67db76a0d85ffa42bce6540"

URI_x86_64_v2_rust-gix-chunk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-chunk-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-chunk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-chunk-devel}"
SRC_URI[x86_64_v2_rust-gix-chunk-devel.sha256sum] = "e5740d2153c89883324ef5eab77c9ca538d25f3f516d1871f535a7e350711d9c"

URI_aarch64_rust-gix-chunk+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-chunk+default-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-chunk+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-chunk+default-devel}"
SRC_URI[aarch64_rust-gix-chunk+default-devel.sha256sum] = "3be6a327b5e1d7595f485631eb43d4b344d0aa7070bd5b681a21871713ad99cf"

URI_aarch64_rust-gix-chunk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-chunk-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-chunk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-chunk-devel}"
SRC_URI[aarch64_rust-gix-chunk-devel.sha256sum] = "421b7c38f7dfdbe610b99cc6571e788ad187f87465feb08fb6a97a000e177bc3"

RDEPENDS:rust-gix-chunk+default-devel = " \
 cargo \
 rust-gix-chunk-devel \
 "
RDEPENDS:rust-gix-chunk-devel = " \
 cargo \
 rust \
 rust-gix-error+default-devel \
 "
