# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "happy"
PV = "1.20.1.1"
PR = "4.el10_0"
PACKAGES = " \
 happy \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/happy-1.20.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7d95ca37188ec065f1abfe5702b355abbcbd63dd7aa03e2d31a0b0a73da68e29"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/happy-1.20.1.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_happy;unpack=0"
SRC_URI[x86_64_v2_happy.sha256sum] = "718c6f78885e57498dffb7c86c21732a4b64ca5f5a92ee8d2d7acef2db413673"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/happy-1.20.1.1-4.el10_0.aarch64.rpm;name=aarch64_happy;unpack=0"
SRC_URI[aarch64_happy.sha256sum] = "5d1cc8d1ec17f3c4f5f5216ede07eaf8fa960e790b035f90adb06b72a6853d24"

RDEPENDS:happy = " \
 glibc \
 gmp \
 libffi \
 "
