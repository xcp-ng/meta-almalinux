# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-rpp"
PV = "7.1.0"
PR = "5.el10_2"
PACKAGES:x86_64_v2 = " \
 rocm-rpp \
 rocm-rpp-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-rpp-7.1.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a56f2a23dfbf270df90461d460a5ecc062267d3067e67999ace4eb803bb2fb6d"

URI_x86_64_v2_rocm-rpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-rpp-7.1.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-rpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-rpp}"
SRC_URI[x86_64_v2_rocm-rpp.sha256sum] = "f8e7cee2d50326c30be359c1c8e0af2f6e5761e94988d40c57d834d365142de7"

URI_x86_64_v2_rocm-rpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-rpp-devel-7.1.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-rpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-rpp-devel}"
SRC_URI[x86_64_v2_rocm-rpp-devel.sha256sum] = "5d3a8bbd11b2e51af7be13bfca9bb6513e4cac59cea0b459c5f2b57ed5dc9de1"

RDEPENDS:rocm-rpp = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 virtual/libomp.so_VERSION__64bit_ \
 virtual/libomp.so___64bit_ \
 "
RDEPENDS:rocm-rpp-devel = " \
 cmake-filesystem \
 rocm-rpp \
 "
