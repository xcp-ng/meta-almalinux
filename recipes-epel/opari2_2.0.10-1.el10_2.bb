# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opari2"
PV = "2.0.10"
PR = "1.el10_2"
PACKAGES = " \
 opari2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opari2-2.0.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e13b1741323e84f082ccd4181949c9364f1cc27e39e38582d59649bea87dd0b1"

URI_x86_64_v2_opari2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opari2-2.0.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opari2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opari2}"
SRC_URI[x86_64_v2_opari2.sha256sum] = "381d8b8adde43179d6eee73d50469a0a412199ddccd10500a339e26300c898be"

URI_aarch64_opari2 = "${EPEL_MIRROR}/aarch64/Packages/o/opari2-2.0.10-1.el10_2.aarch64.rpm;name=aarch64_opari2;unpack=0"
SRC_URI:append = " ${URI_aarch64_opari2}"
SRC_URI[aarch64_opari2.sha256sum] = "9ffd53fd93dff32221ae378e182f2b42118227c87493f321e7aadc67dfaa7afd"

RDEPENDS:opari2 = " \
 gawk \
 glibc \
 libgcc \
 libstdc++ \
 "
