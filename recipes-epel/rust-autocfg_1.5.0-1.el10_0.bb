# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-autocfg"
PV = "1.5.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-autocfg+default-devel \
 rust-autocfg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-autocfg-1.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4289b55afd200839ab6a1224e3611594e1246ea8948becc11700f3f5cd7459cc"

URI_x86_64_v2_rust-autocfg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-autocfg+default-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-autocfg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-autocfg+default-devel}"
SRC_URI[x86_64_v2_rust-autocfg+default-devel.sha256sum] = "0d214a6d9d220eb4906ba38fccbf741325147c51e6b8c1cd35e901e1236be5bf"

URI_x86_64_v2_rust-autocfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-autocfg-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-autocfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-autocfg-devel}"
SRC_URI[x86_64_v2_rust-autocfg-devel.sha256sum] = "567cd6dc1616f390fc9bf492e15c64cd8e9dba6bfabd2bc013905d6781b7d90d"

URI_aarch64_rust-autocfg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-autocfg+default-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-autocfg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-autocfg+default-devel}"
SRC_URI[aarch64_rust-autocfg+default-devel.sha256sum] = "41c20c4f2a208b396db76e0daf5ed6be1d18c98bd861ba98a6b3278cffb9ed3f"

URI_aarch64_rust-autocfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-autocfg-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-autocfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-autocfg-devel}"
SRC_URI[aarch64_rust-autocfg-devel.sha256sum] = "b90a9bc2a05013c395db4669d6dee84b60f18b07491c48e17bc07a447bcc5c7b"

RDEPENDS:rust-autocfg+default-devel = " \
 cargo \
 rust-autocfg-devel \
 "
RDEPENDS:rust-autocfg-devel = " \
 bash \
 cargo \
 rust \
 "
