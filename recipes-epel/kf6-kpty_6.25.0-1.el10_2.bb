# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpty"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kpty \
 kf6-kpty-devel \
 kf6-kpty-doc \
 kf6-kpty-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kpty-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1c106c1973770f39ddb031b387fe4dbac16b73497fc501e509aa7058a4e6591"

URI_x86_64_v2_kf6-kpty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpty}"
SRC_URI[x86_64_v2_kf6-kpty.sha256sum] = "1b939966343d7f21d08bf5965ef809ba943f6cb950ee50d8fdeb02f3dc7b5749"

URI_x86_64_v2_kf6-kpty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpty-devel}"
SRC_URI[x86_64_v2_kf6-kpty-devel.sha256sum] = "3a1985ecc42f94057f0853bf0e36685ace382ac5021467b77e04faa6bf6cbf8d"

URI_x86_64_v2_kf6-kpty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpty-doc}"
SRC_URI[x86_64_v2_kf6-kpty-doc.sha256sum] = "34f7e20ff3c8c213ba47be841c00b541cec9796f5ed1843d8bc9b4f3b1f3680e"

URI_x86_64_v2_kf6-kpty-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpty-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpty-html}"
SRC_URI[x86_64_v2_kf6-kpty-html.sha256sum] = "5efe5c03512b1e1f655325cc46c52f38790b527cd1f880749decca51c3237297"

URI_aarch64_kf6-kpty = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kpty;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpty}"
SRC_URI[aarch64_kf6-kpty.sha256sum] = "948d316b119fac9948f295f50bf8a65bbb0789aaa93e7fa50029d9a169958115"

URI_aarch64_kf6-kpty-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kpty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpty-devel}"
SRC_URI[aarch64_kf6-kpty-devel.sha256sum] = "297ecea4300894a588cd23c6413f10c9428258b20231f77c70f418592090d8d6"

URI_aarch64_kf6-kpty-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kpty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpty-doc}"
SRC_URI[aarch64_kf6-kpty-doc.sha256sum] = "9ee8eeaff5fa031b432d96619b5d6a28e786915a0749d593c8bcf4209c4e885e"

URI_aarch64_kf6-kpty-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kpty-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpty-html}"
SRC_URI[aarch64_kf6-kpty-html.sha256sum] = "2ddb3051de12332ae74ccc48eba711a5401f4f80f4774797d5564e96355c6414"

RDEPENDS:kf6-kpty = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 libutempter \
 qt6-qtbase \
 "
RDEPENDS:kf6-kpty-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kpty \
 "
RDEPENDS:kf6-kpty-doc = " \
 "
RDEPENDS:kf6-kpty-html = " \
 "
