# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro-error2"
PV = "2.0.1"
PR = "4.el10_2"
PACKAGES = " \
 rust-proc-macro-error2+default-devel \
 rust-proc-macro-error2+nightly-devel \
 rust-proc-macro-error2+syn-error-devel \
 rust-proc-macro-error2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro-error2-2.0.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1860235ffe135ffc4a9911b132cee5ac3d2b6dc419727b217d4366c48cd310ca"

URI_x86_64_v2_rust-proc-macro-error2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error2+default-devel-2.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-error2+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-error2+default-devel.sha256sum] = "7bb832811404ae87a1f49c3b67f94251aa00bea355d09728d15598b8ef077452"

URI_x86_64_v2_rust-proc-macro-error2+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error2+nightly-devel-2.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error2+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-error2+nightly-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-error2+nightly-devel.sha256sum] = "2a555c95953603440c7cfffdde005f1cc06245db7bc19c9cd319fe9d7945347a"

URI_x86_64_v2_rust-proc-macro-error2+syn-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error2+syn-error-devel-2.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error2+syn-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-error2+syn-error-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-error2+syn-error-devel.sha256sum] = "14a950483679b1289fc74ee918b0967404be685f7afef0bedd518b2da8d4c64e"

URI_x86_64_v2_rust-proc-macro-error2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error2-devel-2.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-error2-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-error2-devel.sha256sum] = "561505e4f5de92c5b0df6882521c38988eb4bdec3de7cfc67ca92fdb5e285a3e"

URI_aarch64_rust-proc-macro-error2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error2+default-devel-2.0.1-4.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-error2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-error2+default-devel}"
SRC_URI[aarch64_rust-proc-macro-error2+default-devel.sha256sum] = "fe1fdf5a404de6f967a62714c0144507145688a2098d071e172e5d1deac2ba5a"

URI_aarch64_rust-proc-macro-error2+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error2+nightly-devel-2.0.1-4.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-error2+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-error2+nightly-devel}"
SRC_URI[aarch64_rust-proc-macro-error2+nightly-devel.sha256sum] = "bcc4ecbf0f26199d674e6fa108e4925fca0abe36a2e07d802a51936cfe5315ac"

URI_aarch64_rust-proc-macro-error2+syn-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error2+syn-error-devel-2.0.1-4.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-error2+syn-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-error2+syn-error-devel}"
SRC_URI[aarch64_rust-proc-macro-error2+syn-error-devel.sha256sum] = "ffbf9d85c8ba8d468701b8b0689cea3946f0406de3b883cfe6359ea48a17b95e"

URI_aarch64_rust-proc-macro-error2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error2-devel-2.0.1-4.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-error2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-error2-devel}"
SRC_URI[aarch64_rust-proc-macro-error2-devel.sha256sum] = "67d564f43e0062b0efbf9cb09362d8b214dfa5fe43dd87bfd05fe2bf7409a999"

RDEPENDS:rust-proc-macro-error2+default-devel = " \
 cargo \
 rust-proc-macro-error2+syn-error-devel \
 rust-proc-macro-error2-devel \
 "
RDEPENDS:rust-proc-macro-error2+nightly-devel = " \
 cargo \
 rust-proc-macro-error2-devel \
 "
RDEPENDS:rust-proc-macro-error2+syn-error-devel = " \
 cargo \
 rust-proc-macro-error2-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-proc-macro-error2-devel = " \
 cargo \
 rust \
 rust-proc-macro-error-attr2+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
