# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pep508_rs"
PV = "0.9.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-pep508_rs+default-devel \
 rust-pep508_rs+non-pep508-extensions-devel \
 rust-pep508_rs+schemars-devel \
 rust-pep508_rs+tracing-devel \
 rust-pep508_rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pep508_rs-0.9.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d083b633fdfd19db598be769f4bac3a33d648b5449b6177036bfe51ea0245de3"

URI_x86_64_v2_rust-pep508_rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep508_rs+default-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep508_rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep508_rs+default-devel}"
SRC_URI[x86_64_v2_rust-pep508_rs+default-devel.sha256sum] = "01fb3e6aca10d6513d9a4a7b57ffcd57eb8eaeb91627fbb40e2865a4a3caf7e4"

URI_x86_64_v2_rust-pep508_rs+non-pep508-extensions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep508_rs+non-pep508-extensions-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep508_rs+non-pep508-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep508_rs+non-pep508-extensions-devel}"
SRC_URI[x86_64_v2_rust-pep508_rs+non-pep508-extensions-devel.sha256sum] = "8fddd217ce3871cc9bfeecd92f0d29021695993ff625b87a47151310a370b4c0"

URI_x86_64_v2_rust-pep508_rs+schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep508_rs+schemars-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep508_rs+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep508_rs+schemars-devel}"
SRC_URI[x86_64_v2_rust-pep508_rs+schemars-devel.sha256sum] = "d48521035dad46df32582fc9061701d3ecbb58a85ccaff0d9c3841822822e1bc"

URI_x86_64_v2_rust-pep508_rs+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep508_rs+tracing-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep508_rs+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep508_rs+tracing-devel}"
SRC_URI[x86_64_v2_rust-pep508_rs+tracing-devel.sha256sum] = "a367d7bdc25b51a9b4e3cc0082a915a00caa7eb771a16407cac886aae0f9b350"

URI_x86_64_v2_rust-pep508_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep508_rs-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep508_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep508_rs-devel}"
SRC_URI[x86_64_v2_rust-pep508_rs-devel.sha256sum] = "96985308fe9136e9c9926725bb993f895432553500205ce7d11161658908d9cc"

URI_aarch64_rust-pep508_rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep508_rs+default-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-pep508_rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep508_rs+default-devel}"
SRC_URI[aarch64_rust-pep508_rs+default-devel.sha256sum] = "2a38cbe5ed9af57efd51df037d07764cb0c4d86422c046d8b17cd59eab6a3f2c"

URI_aarch64_rust-pep508_rs+non-pep508-extensions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep508_rs+non-pep508-extensions-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-pep508_rs+non-pep508-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep508_rs+non-pep508-extensions-devel}"
SRC_URI[aarch64_rust-pep508_rs+non-pep508-extensions-devel.sha256sum] = "c15255a004331963097792ad17d6023efb8e770457e23ed94c8f75d594aec72d"

URI_aarch64_rust-pep508_rs+schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep508_rs+schemars-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-pep508_rs+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep508_rs+schemars-devel}"
SRC_URI[aarch64_rust-pep508_rs+schemars-devel.sha256sum] = "fbe5367df4cc7934362fe5c61c9f70b849bb3fbb9c69671d30ace27b2f61ac5a"

URI_aarch64_rust-pep508_rs+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep508_rs+tracing-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-pep508_rs+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep508_rs+tracing-devel}"
SRC_URI[aarch64_rust-pep508_rs+tracing-devel.sha256sum] = "15d0ef95e859d93f401e3df316de9c43ec99f5d6c738fca336cead3657644956"

URI_aarch64_rust-pep508_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep508_rs-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-pep508_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep508_rs-devel}"
SRC_URI[aarch64_rust-pep508_rs-devel.sha256sum] = "3e1b619ef7985d966ca267aabb9eccdda22aefad6df6bd677a6566c77eab9130"

RDEPENDS:rust-pep508_rs+default-devel = " \
 cargo \
 rust-pep508_rs-devel \
 "
RDEPENDS:rust-pep508_rs+non-pep508-extensions-devel = " \
 cargo \
 rust-pep508_rs-devel \
 "
RDEPENDS:rust-pep508_rs+schemars-devel = " \
 cargo \
 rust-pep508_rs-devel \
 rust-schemars+default-devel \
 "
RDEPENDS:rust-pep508_rs+tracing-devel = " \
 cargo \
 rust-pep440_rs+tracing-devel \
 rust-pep508_rs-devel \
 rust-tracing+default-devel \
 "
RDEPENDS:rust-pep508_rs-devel = " \
 cargo \
 rust-boxcar+default-devel \
 rust-indexmap+default-devel \
 rust-itertools0.13+default-devel \
 rust-once_cell+default-devel \
 rust-pep440_rs+default-devel \
 rust-pep440_rs+version-ranges-devel \
 rust-regex+default-devel \
 rust-rustc-hash+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-smallvec+default-devel \
 rust-thiserror1+default-devel \
 rust-unicode-width+default-devel \
 rust-url+default-devel \
 rust-url+serde-devel \
 rust-urlencoding+default-devel \
 rust-version-ranges+default-devel \
 "
