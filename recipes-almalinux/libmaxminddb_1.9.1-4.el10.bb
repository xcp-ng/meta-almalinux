# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmaxminddb"
PV = "1.9.1"
PR = "4.el10"
PACKAGES = " \
 libmaxminddb \
 libmaxminddb-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libmaxminddb-1.9.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff3a426e2680a43df92cc9712020f9c01068a56fc53e171a1291d3c10c3e3511"

URI_x86_64_v2_libmaxminddb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libmaxminddb-1.9.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libmaxminddb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmaxminddb}"
SRC_URI[x86_64_v2_libmaxminddb.sha256sum] = "72147648294e0117653e2ec24698dabf84b165eda3dd23b22321a8be3415dbba"

URI_x86_64_v2_libmaxminddb-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libmaxminddb-devel-1.9.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libmaxminddb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmaxminddb-devel}"
SRC_URI[x86_64_v2_libmaxminddb-devel.sha256sum] = "a1d358cca94bca5aa273407cce0f3d9663521b6398857e62bc8b7b7860d98c75"

URI_aarch64_libmaxminddb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libmaxminddb-1.9.1-4.el10.aarch64.rpm;name=aarch64_libmaxminddb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmaxminddb}"
SRC_URI[aarch64_libmaxminddb.sha256sum] = "2def1c448ec13c95a395cdfbffeab46a588122bb6bd06916fbf1517b05be5e05"

URI_aarch64_libmaxminddb-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libmaxminddb-devel-1.9.1-4.el10.aarch64.rpm;name=aarch64_libmaxminddb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmaxminddb-devel}"
SRC_URI[aarch64_libmaxminddb-devel.sha256sum] = "49636c9c78666ef7cac72c43f1189c4e3f23a3321f2b5fd52931b3b58775fcef"

RDEPENDS:libmaxminddb = " \
 glibc \
 "
RDEPENDS:libmaxminddb-devel = " \
 libmaxminddb \
 pkgconf-pkg-config \
 "
