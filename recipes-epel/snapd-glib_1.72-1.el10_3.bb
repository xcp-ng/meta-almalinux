# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snapd-glib"
PV = "1.72"
PR = "1.el10_3"
PACKAGES = " \
 snapd-glib \
 snapd-glib-devel \
 snapd-glib-tests \
 snapd-qt \
 snapd-qt-devel \
 snapd-qt-qml \
 snapd-qt-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/snapd-glib-1.72-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a56452b8880dd856eec959eb9e6cc3fe7036832108597f849d7d1bd0d5b585fb"

URI_x86_64_v2_snapd-glib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-glib-1.72-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-glib}"
SRC_URI[x86_64_v2_snapd-glib.sha256sum] = "f664e5b1fa814213aef0e035f0573339061aa3dc480ead73a8f1e578086aba7e"

URI_x86_64_v2_snapd-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-glib-devel-1.72-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-glib-devel}"
SRC_URI[x86_64_v2_snapd-glib-devel.sha256sum] = "63065eb554845e650131693f127baa111e329be306bff29f14189689c4155df2"

URI_x86_64_v2_snapd-glib-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-glib-tests-1.72-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-glib-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-glib-tests}"
SRC_URI[x86_64_v2_snapd-glib-tests.sha256sum] = "8dd1ebc5537954af5e7f63cc6cd26b738ca88764ea93165960e974a00b58e669"

URI_x86_64_v2_snapd-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-qt-1.72-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-qt}"
SRC_URI[x86_64_v2_snapd-qt.sha256sum] = "172c643879fb668f7a08aabf54f603dd73a050083be04586391bd1f2bc3ace4b"

URI_x86_64_v2_snapd-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-qt-devel-1.72-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-qt-devel}"
SRC_URI[x86_64_v2_snapd-qt-devel.sha256sum] = "0f44a264f04d5e56163b01300758d3b9ef01eb62535da54b932be1857c0a58bb"

URI_x86_64_v2_snapd-qt-qml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-qt-qml-1.72-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-qt-qml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-qt-qml}"
SRC_URI[x86_64_v2_snapd-qt-qml.sha256sum] = "67080f96432dbf61606c828514041aae468e19fac6703ab0a263fc195054ea97"

URI_x86_64_v2_snapd-qt-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-qt-tests-1.72-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-qt-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-qt-tests}"
SRC_URI[x86_64_v2_snapd-qt-tests.sha256sum] = "b907749ef5635667afa8043a9d93b4994486e3973e76f88ca9248fa9407376ac"

URI_aarch64_snapd-glib = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-glib-1.72-1.el10_3.aarch64.rpm;name=aarch64_snapd-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-glib}"
SRC_URI[aarch64_snapd-glib.sha256sum] = "9edb93e59bc1e9b72d21fc6fca48e798e1d889bf2c46518f11b33b2eda45cef6"

URI_aarch64_snapd-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-glib-devel-1.72-1.el10_3.aarch64.rpm;name=aarch64_snapd-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-glib-devel}"
SRC_URI[aarch64_snapd-glib-devel.sha256sum] = "5770d012a7c6bd91d496c8718515758a1bcbbe08e13e88e639aed22ab7ffb759"

URI_aarch64_snapd-glib-tests = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-glib-tests-1.72-1.el10_3.aarch64.rpm;name=aarch64_snapd-glib-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-glib-tests}"
SRC_URI[aarch64_snapd-glib-tests.sha256sum] = "ed70c9691b7b57a2057f65c6da3d6df37b162d3449f60cbc9219b26482605612"

URI_aarch64_snapd-qt = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-qt-1.72-1.el10_3.aarch64.rpm;name=aarch64_snapd-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-qt}"
SRC_URI[aarch64_snapd-qt.sha256sum] = "d5a6362d76fe6d89433c7555481d49ab0c08d29a9e5fbb253593a82a64a43dc4"

URI_aarch64_snapd-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-qt-devel-1.72-1.el10_3.aarch64.rpm;name=aarch64_snapd-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-qt-devel}"
SRC_URI[aarch64_snapd-qt-devel.sha256sum] = "6d6af8eebe31c043836ce180f37a433cfb5b4272a9d5158635535f7832782f1c"

URI_aarch64_snapd-qt-qml = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-qt-qml-1.72-1.el10_3.aarch64.rpm;name=aarch64_snapd-qt-qml;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-qt-qml}"
SRC_URI[aarch64_snapd-qt-qml.sha256sum] = "ee5b4937165942aab5ecb6828f97bf0fe0f7163caf463eaacc62463e6dda097f"

URI_aarch64_snapd-qt-tests = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-qt-tests-1.72-1.el10_3.aarch64.rpm;name=aarch64_snapd-qt-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-qt-tests}"
SRC_URI[aarch64_snapd-qt-tests.sha256sum] = "e61652b306db25e57128657338f9ef8fdef004bc27444fbb722a7f864dcd4675"

RDEPENDS:snapd-glib = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 libsoup3 \
 "
RDEPENDS:snapd-glib-devel = " \
 glib2-devel \
 json-glib-devel \
 libsoup3-devel \
 pkgconf-pkg-config \
 snapd-glib \
 "
RDEPENDS:snapd-glib-tests = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 libsoup3 \
 snapd-glib \
 "
RDEPENDS:snapd-qt = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 snapd-glib \
 "
RDEPENDS:snapd-qt-devel = " \
 cmake-filesystem \
 glib2-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 snapd-glib-devel \
 snapd-qt \
 "
RDEPENDS:snapd-qt-qml = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 snapd-qt \
 "
RDEPENDS:snapd-qt-tests = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 libsoup3 \
 libstdc++ \
 qt6-qtbase \
 snapd-glib-tests \
 snapd-qt \
 "
