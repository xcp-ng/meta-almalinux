# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc"
PV = "14.4.1"
PR = "3.el10.alma.2"
PACKAGES:x86_64_v2 = " \
 cpp \
 gcc \
 gcc-c++ \
 gcc-gfortran \
 gcc-offload-amdgcn \
 gcc-offload-nvptx \
 gcc-plugin-annobin \
 gcc-plugin-devel \
 libasan \
 libatomic \
 libgcc \
 libgccjit \
 libgccjit-devel \
 libgfortran \
 libgfortran-static \
 libgomp \
 libgomp-offload-amdgcn \
 libgomp-offload-nvptx \
 libhwasan \
 libitm \
 libitm-devel \
 liblsan \
 libquadmath \
 libquadmath-devel \
 libquadmath-static \
 libstdc++ \
 libstdc++-devel \
 libstdc++-docs \
 libstdc++-static \
 libtsan \
 libubsan \
"
PACKAGES:aarch64 = " \
 cpp \
 gcc \
 gcc-c++ \
 gcc-gfortran \
 gcc-plugin-annobin \
 gcc-plugin-devel \
 libasan \
 libatomic \
 libgcc \
 libgccjit \
 libgccjit-devel \
 libgfortran \
 libgfortran-static \
 libgomp \
 libhwasan \
 libitm \
 libitm-devel \
 liblsan \
 libstdc++ \
 libstdc++-devel \
 libstdc++-docs \
 libstdc++-static \
 libtsan \
 libubsan \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gcc-14.4.1-3.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b4b48a79e1eae9026662ef8538fda0b92ebc46568bf397827c57d9241b784023"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cpp-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_cpp;unpack=0"
SRC_URI[x86_64_v2_cpp.sha256sum] = "3521847cd31c6b1d3138f9bc451837d97c1d304089f4b8a94fc78346f02f8c6d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc;unpack=0"
SRC_URI[x86_64_v2_gcc.sha256sum] = "4fde42315819db9cebff8ac15876a65a115c8ed0f14e233f6aa65ba9dcc9a517"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-c++-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-c++;unpack=0"
SRC_URI[x86_64_v2_gcc-c++.sha256sum] = "4945ee212bcc5b085f4ce59504b9c3d51c9dc10f50abe1f4b0981c2317fef6c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-gfortran-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-gfortran;unpack=0"
SRC_URI[x86_64_v2_gcc-gfortran.sha256sum] = "0b16fb65301df123615f8733723d768f8d6d5a3b2e6a8ff59f4990d47b9b59d6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-offload-amdgcn-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-offload-amdgcn;unpack=0"
SRC_URI[x86_64_v2_gcc-offload-amdgcn.sha256sum] = "373e00fc2cefd174fe10d7f46a8cc04e94d2501b06290a3ffbdde86c9d9f9f38"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-offload-nvptx-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-offload-nvptx;unpack=0"
SRC_URI[x86_64_v2_gcc-offload-nvptx.sha256sum] = "2e1739206e6e27a0a13a944e0c405f7311b3877721303c02e69357926cad7211"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-plugin-annobin-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-plugin-annobin;unpack=0"
SRC_URI[x86_64_v2_gcc-plugin-annobin.sha256sum] = "9811ad5511ffe2912851f26577d2f9bb2c7a8f5e45476d14176c7178f741f7c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-plugin-devel-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-plugin-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-plugin-devel.sha256sum] = "61d352132883da29fdc28c1869770ea7bbedf3f42d2beb437016714d2f5677e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libasan-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libasan;unpack=0"
SRC_URI[x86_64_v2_libasan.sha256sum] = "54748618ddcfe88f27d09ed9c4dc66faa81a490f180fe8c16670eeda42d692f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libatomic-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libatomic;unpack=0"
SRC_URI[x86_64_v2_libatomic.sha256sum] = "dcac00119324f4f79e4814453f416432672a209553e1ed4fb1d176d6b21a74bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgcc-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgcc;unpack=0"
SRC_URI[x86_64_v2_libgcc.sha256sum] = "c63e5f22faf4e5ce922faa9c49f077bf367cab8306c22305eae0e68ef8d6a8fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgccjit-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgccjit;unpack=0"
SRC_URI[x86_64_v2_libgccjit.sha256sum] = "142ffb01fdce79f6eea0df37d792e847269dd590abda16873272160f50603956"
RPROVIDES:libgccjit:append:x86_64_v2 = " virtual/libgccjit.so.0___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgccjit-devel-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgccjit-devel;unpack=0"
SRC_URI[x86_64_v2_libgccjit-devel.sha256sum] = "a381de807ac355dcddaea069fc5e7623a0100f715e52520f504ca69e1ec4fe32"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgfortran-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgfortran;unpack=0"
SRC_URI[x86_64_v2_libgfortran.sha256sum] = "824db63ef2892d7f87c6ceea3a7c333a7a7a2172cdccd4f74646fe9852d09e0d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgfortran-static-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgfortran-static;unpack=0"
SRC_URI[x86_64_v2_libgfortran-static.sha256sum] = "38e91d987fd5f05dd0b3a5cd12fd17aa1fed6a96b3fedc0edd2862b3765274e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgomp-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgomp;unpack=0"
SRC_URI[x86_64_v2_libgomp.sha256sum] = "a7203420e2657d1cffc5b140353a0f2fc51274890b987844a385539209e29806"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgomp-offload-amdgcn-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgomp-offload-amdgcn;unpack=0"
SRC_URI[x86_64_v2_libgomp-offload-amdgcn.sha256sum] = "067f27cd74092e9cd8eb6a87288a00f0aad28288decd86f342ed7d8c5f083862"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgomp-offload-nvptx-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgomp-offload-nvptx;unpack=0"
SRC_URI[x86_64_v2_libgomp-offload-nvptx.sha256sum] = "590fa492acd56d652b1deb9e19f1e09f080b1de9e33acf012c76342e87a81b4a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libhwasan-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libhwasan;unpack=0"
SRC_URI[x86_64_v2_libhwasan.sha256sum] = "c86755d395d03c3736c68582c7c369cf6d2a0f63549e1c18ac6d70c58b489805"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libitm-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libitm;unpack=0"
SRC_URI[x86_64_v2_libitm.sha256sum] = "1739740300144e8d2e877a77d2e34bc2d6ec5161f293b3d0fa538a3fb60b87e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libitm-devel-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libitm-devel;unpack=0"
SRC_URI[x86_64_v2_libitm-devel.sha256sum] = "abba94a904f85958b8400e6698b705575e81f29d8ea882aa64a54c909fc8fa29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liblsan-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_liblsan;unpack=0"
SRC_URI[x86_64_v2_liblsan.sha256sum] = "75784252304bbe08c58753e5af88ba52717d68894d747173ddab529ee73eb789"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libquadmath-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libquadmath;unpack=0"
SRC_URI[x86_64_v2_libquadmath.sha256sum] = "a5177d8635ee1955d1f25d0410be92d00e26f48062d0b300e6faf543fa82568e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libquadmath-devel-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libquadmath-devel;unpack=0"
SRC_URI[x86_64_v2_libquadmath-devel.sha256sum] = "ad73dd62a9ef19c88e73bebf32742b07d1bf403999611841fdd5e59490a620bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libquadmath-static-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libquadmath-static;unpack=0"
SRC_URI[x86_64_v2_libquadmath-static.sha256sum] = "2897e0866da6019ab1e306ba24759330665558494da8d369b4e86be4cf5060e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libstdc++-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libstdc++;unpack=0"
SRC_URI[x86_64_v2_libstdc++.sha256sum] = "34a58aedb830e37152eae24f9c468f19e22ab0b39b81ecb89144427f7492cfe0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstdc++-devel-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libstdc++-devel;unpack=0"
SRC_URI[x86_64_v2_libstdc++-devel.sha256sum] = "3d47b679c231594a589f06adee13a74998909ff615df9ce1caa0dcf4949f794f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstdc++-docs-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libstdc++-docs;unpack=0"
SRC_URI[x86_64_v2_libstdc++-docs.sha256sum] = "2f1480a1e8d692c9e0242354b741fa83089df35668b965f165e4b269816f40e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libstdc++-static-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libstdc++-static;unpack=0"
SRC_URI[x86_64_v2_libstdc++-static.sha256sum] = "60a0f3cfa2d1ef2a2615298d01766077dd585a66f3cb60c7e7316893dafd2994"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtsan-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libtsan;unpack=0"
SRC_URI[x86_64_v2_libtsan.sha256sum] = "20f7ad8db64e11e83191f888bbafa43943845f436e41333524b03d543bb799e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libubsan-14.4.1-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libubsan;unpack=0"
SRC_URI[x86_64_v2_libubsan.sha256sum] = "49f2c13cc4be087dbb751e8b5caff3ba09cfd3285d531a51150d5fc2639ca813"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cpp-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_cpp;unpack=0"
SRC_URI[aarch64_cpp.sha256sum] = "8ea44bbe9511614560f70f63a62de3486ef33c4aaed5b29bb3bc65bb33ee765f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_gcc;unpack=0"
SRC_URI[aarch64_gcc.sha256sum] = "e2c6abb690da712db47b0dbf004526a517c0343b1ffdbf6247c205fe227127b8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-c++-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_gcc-c++;unpack=0"
SRC_URI[aarch64_gcc-c++.sha256sum] = "d32828358f8b951fc7e27bafb723ffdac48978b399c7aece357da45f4312d260"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-gfortran-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_gcc-gfortran;unpack=0"
SRC_URI[aarch64_gcc-gfortran.sha256sum] = "346d5775f5d128bcb4cb935ed0ff96651ab211997d9f46759abeb267a4ec980e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-plugin-annobin-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_gcc-plugin-annobin;unpack=0"
SRC_URI[aarch64_gcc-plugin-annobin.sha256sum] = "12e43ebc4a3e54e34e2435965b47ee07c65bcb8f3ba6f551a301785eb1ed8d0a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-plugin-devel-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_gcc-plugin-devel;unpack=0"
SRC_URI[aarch64_gcc-plugin-devel.sha256sum] = "6064fef83aed5a7c49c9375f22359568bf4e7211182971a2ef3ad74010ecae0f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libasan-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libasan;unpack=0"
SRC_URI[aarch64_libasan.sha256sum] = "8661e2bf11be3538c4bbf0a3c0b7c1d78ae24e6d3cec80d8a1a8ba49925d5dfc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libatomic-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libatomic;unpack=0"
SRC_URI[aarch64_libatomic.sha256sum] = "be843b24c3f041f996224c9099f32c54293983e3335b83b36bf833fa6dda516e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgcc-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libgcc;unpack=0"
SRC_URI[aarch64_libgcc.sha256sum] = "4bb0d7cb25e29e756939c5a0bc10b2d77a38b024a10359e7cd9cc3d93c8eb7ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgccjit-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libgccjit;unpack=0"
SRC_URI[aarch64_libgccjit.sha256sum] = "438bac29ead0f10c00ad22b0a767dd2e80a13da012932e824e53e3bfd4871d50"
RPROVIDES:libgccjit:append:aarch64 = " virtual/libgccjit.so.0___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgccjit-devel-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libgccjit-devel;unpack=0"
SRC_URI[aarch64_libgccjit-devel.sha256sum] = "8355e403fc0ba70d9a8be46d2aa8874f79d140ee9300c60caffe79ebbd02f68e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgfortran-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libgfortran;unpack=0"
SRC_URI[aarch64_libgfortran.sha256sum] = "5d7464d6ab257294c6ef54c4822ea4d4ebbcf83ada984afa60cf462394ab8f27"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgfortran-static-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libgfortran-static;unpack=0"
SRC_URI[aarch64_libgfortran-static.sha256sum] = "9333e181584b27463af068e95da6586e5f2742e055cf6a055605af0dfa91916c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgomp-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libgomp;unpack=0"
SRC_URI[aarch64_libgomp.sha256sum] = "cf54557741dcb9c02fb3b9188fbf6f7f733448b5e5386436b1fdab6123e9a8a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libhwasan-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libhwasan;unpack=0"
SRC_URI[aarch64_libhwasan.sha256sum] = "b3bf4da0891434ebfd58530665d283bebb615a393c0a4f7b904d08736d5a514f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libitm-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libitm;unpack=0"
SRC_URI[aarch64_libitm.sha256sum] = "e47d98652663c5b52c1a14a3882537e9b321316190af2b0a86b3466c2468f27b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libitm-devel-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libitm-devel;unpack=0"
SRC_URI[aarch64_libitm-devel.sha256sum] = "ce7c788ab3bc78f0d101fc2f0c5ba83f0ecf04c7ccb4e2df9bac5fe7aa22153e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liblsan-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_liblsan;unpack=0"
SRC_URI[aarch64_liblsan.sha256sum] = "ddd41a333b1dd98d45f6558d1fb19bab899d3a3ece02a465bb574489425f5114"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libstdc++-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libstdc++;unpack=0"
SRC_URI[aarch64_libstdc++.sha256sum] = "98c550868d078f8f929053094ac71b80a9f9ad4d360b7c8e17684dae8971bcf8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstdc++-devel-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libstdc++-devel;unpack=0"
SRC_URI[aarch64_libstdc++-devel.sha256sum] = "fef350922cf6d8256db760949aa024c7d7118a4c7a02a4518c5a1ec4f08cf6ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstdc++-docs-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libstdc++-docs;unpack=0"
SRC_URI[aarch64_libstdc++-docs.sha256sum] = "1221a938fabfe3e4eba7508367375780250876ac735a2ecdf5a484aaa5504194"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libstdc++-static-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libstdc++-static;unpack=0"
SRC_URI[aarch64_libstdc++-static.sha256sum] = "d365ac232474c3d8d0f6fc739962ceee11438b1fd43b24c65fe5dd4c6c5493ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtsan-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libtsan;unpack=0"
SRC_URI[aarch64_libtsan.sha256sum] = "fcc79feb73d2e1856e42dc320c8f5b30b229c1ca84a4f53ed33319e2f31a34e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libubsan-14.4.1-3.el10.alma.2.aarch64.rpm;name=aarch64_libubsan;unpack=0"
SRC_URI[aarch64_libubsan.sha256sum] = "1c552eaa07f354077d79ff0b7784a422496424c09974ada3d8fd3e41fb2a7e17"

RDEPENDS:cpp = " \
 filesystem \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc:x86_64_v2 = " \
 bash \
 binutils \
 cpp \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc:aarch64 = " \
 bash \
 binutils \
 cpp \
 glibc \
 glibc-devel \
 gmp \
 libasan \
 libatomic \
 libgcc \
 libgomp \
 libmpc \
 libubsan \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-c++ = " \
 gcc \
 glibc \
 gmp \
 libmpc \
 libstdc++ \
 libstdc++-devel \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-gfortran:x86_64_v2 = " \
 gcc \
 glibc \
 gmp \
 libgfortran \
 libmpc \
 libquadmath \
 libquadmath-devel \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-gfortran:aarch64 = " \
 gcc \
 glibc \
 gmp \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-offload-amdgcn = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-amdgcn \
 libmpc \
 libstdc++ \
 libzstd \
 lld \
 llvm \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-offload-nvptx = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-nvptx \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-plugin-annobin = " \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gcc-plugin-devel = " \
 gcc \
 glibc \
 gmp-devel \
 libmpc-devel \
 mpfr-devel \
 "
RDEPENDS:libasan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libatomic = " \
 glibc \
 "
RDEPENDS:libgcc = " \
 "
RDEPENDS:libgccjit = " \
 gcc \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:libgccjit-devel = " \
 libgccjit \
 virtual/libgccjit.so.0___64bit_ \
 "
RDEPENDS:libgfortran = " \
 glibc \
 libgcc \
 "
RDEPENDS:libgfortran-static:x86_64_v2 = " \
 gcc \
 libgfortran \
 libquadmath-static \
"
RDEPENDS:libgfortran-static:aarch64 = " \
 gcc \
 libgfortran \
"
RDEPENDS:libgomp = " \
 glibc \
 "
RDEPENDS:libgomp-offload-amdgcn = " \
 glibc \
 libgomp \
 "
RDEPENDS:libgomp-offload-nvptx = " \
 glibc \
 libgomp \
 "
RDEPENDS:libhwasan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libitm = " \
 glibc \
 "
RDEPENDS:libitm-devel = " \
 gcc \
 libitm \
 "
RDEPENDS:liblsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libquadmath = " \
 glibc \
 libgcc \
 "
RDEPENDS:libquadmath-devel = " \
 gcc \
 libquadmath \
 "
RDEPENDS:libquadmath-static = " \
 libquadmath-devel \
 "
RDEPENDS:libstdc++ = " \
 glibc \
 libgcc \
 "
RDEPENDS:libstdc++-devel = " \
 libstdc++ \
 "
RDEPENDS:libstdc++-docs = " \
 "
RDEPENDS:libstdc++-static = " \
 libstdc++-devel \
 "
RDEPENDS:libtsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libubsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
