# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "node-exporter"
PV = "1.11.1"
PR = "1.el10_1"
PACKAGES = " \
 node-exporter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/node-exporter-1.11.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e69411d36c14c4dbe2d56ee4ad875ab0d0dacea4d76e039261e814f46360bf5"

URI_x86_64_v2_node-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/node-exporter-1.11.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_node-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_node-exporter}"
SRC_URI[x86_64_v2_node-exporter.sha256sum] = "33cbd14964194a8a596c75f0a1187cac40f586bc30e6d3a75fbfef26b7ee10db"

URI_aarch64_node-exporter = "${EPEL_MIRROR}/aarch64/Packages/n/node-exporter-1.11.1-1.el10_1.aarch64.rpm;name=aarch64_node-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_node-exporter}"
SRC_URI[aarch64_node-exporter.sha256sum] = "273f6398ca5fc1aebdae74447e1d72a0bb354ed402814c66814677ee9ee79b2c"

RDEPENDS:node-exporter = " \
 bash \
 glibc \
 shadow-utils \
 "
