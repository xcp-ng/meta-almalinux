# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-requestsexceptions"
PV = "1.4.0"
PR = "29.el10_2"
PACKAGES = " \
 python3-requestsexceptions \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-requestsexceptions-1.4.0-29.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a1b82b4c6f719e6a967e53ca4988b5c8a3c10f0113ab91c26570fd8bdeaa1fc"

URI_x86_64_v2_python3-requestsexceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-requestsexceptions-1.4.0-29.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-requestsexceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-requestsexceptions}"
SRC_URI[x86_64_v2_python3-requestsexceptions.sha256sum] = "81a4b37437edeaebcf8236aec34aa5d92ebbbeb9433226177c56db3fcf2cdd68"

URI_aarch64_python3-requestsexceptions = "${EPEL_MIRROR}/aarch64/Packages/p/python3-requestsexceptions-1.4.0-29.el10_2.noarch.rpm;name=aarch64_python3-requestsexceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-requestsexceptions}"
SRC_URI[aarch64_python3-requestsexceptions.sha256sum] = "9240e2391c548a8502ebb69e2a107f2f10fb9878f867224c3f6df5881625505d"

RDEPENDS:python3-requestsexceptions = " \
 python3 \
 "
