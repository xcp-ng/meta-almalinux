# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "polkit"
PV = "125"
PR = "4.el10"
PACKAGES = " \
 polkit \
 polkit-devel \
 polkit-docs \
 polkit-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/polkit-125-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eff9037b93122e4a1246a6d9834441cbded674333977e53421610ebb6c2c6c8f"

URI_x86_64_v2_polkit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/polkit-125-4.el10.x86_64_v2.rpm;name=x86_64_v2_polkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit}"
SRC_URI[x86_64_v2_polkit.sha256sum] = "5494a205dda3b68e60d63f373f5abc69e4b6d82e03dc69862cab20319b3c0b29"

URI_x86_64_v2_polkit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/polkit-devel-125-4.el10.x86_64_v2.rpm;name=x86_64_v2_polkit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-devel}"
SRC_URI[x86_64_v2_polkit-devel.sha256sum] = "6d7d7265a64ecf66c93b5cca703e6d07f792ee5d54c1b7de632b75a657c1c296"

URI_x86_64_v2_polkit-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/polkit-docs-125-4.el10.noarch.rpm;name=x86_64_v2_polkit-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-docs}"
SRC_URI[x86_64_v2_polkit-docs.sha256sum] = "869ed040cabf1f8b7738a642f3e975afe74b22d611f8052944daf2138950de99"

URI_x86_64_v2_polkit-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/polkit-libs-125-4.el10.x86_64_v2.rpm;name=x86_64_v2_polkit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-libs}"
SRC_URI[x86_64_v2_polkit-libs.sha256sum] = "4f617e82a7ac01fdfb028573dc51dcdb17e38e318dd190212c3a6f3efe9a138b"

URI_aarch64_polkit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/polkit-125-4.el10.aarch64.rpm;name=aarch64_polkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit}"
SRC_URI[aarch64_polkit.sha256sum] = "f364df3587d7c85a4fdaa66cef3dc762a17047980dd421fdc052a096ae73d777"

URI_aarch64_polkit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/polkit-devel-125-4.el10.aarch64.rpm;name=aarch64_polkit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-devel}"
SRC_URI[aarch64_polkit-devel.sha256sum] = "f25cceca6a4c71060499a6cd8f8aa50f56c8f0fe07b464545e329373d1bf1320"

URI_aarch64_polkit-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/polkit-docs-125-4.el10.noarch.rpm;name=aarch64_polkit-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-docs}"
SRC_URI[aarch64_polkit-docs.sha256sum] = "869ed040cabf1f8b7738a642f3e975afe74b22d611f8052944daf2138950de99"

URI_aarch64_polkit-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/polkit-libs-125-4.el10.aarch64.rpm;name=aarch64_polkit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-libs}"
SRC_URI[aarch64_polkit-libs.sha256sum] = "f9a819b16e3c1e8ec8ccf9c2c78643fb6490cf05cbe4c79355c64d2256513b36"

RDEPENDS:polkit = " \
 bash \
 dbus \
 duktape \
 expat \
 glib2 \
 glibc \
 pam-libs \
 polkit-libs \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:polkit-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 polkit-devel \
 polkit-docs \
 polkit-libs \
 "
RDEPENDS:polkit-docs = " \
 polkit-devel \
 "
RDEPENDS:polkit-libs = " \
 glib2 \
 glibc \
 systemd-libs \
 "
