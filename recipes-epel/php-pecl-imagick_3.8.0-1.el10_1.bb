# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-imagick"
PV = "3.8.0"
PR = "1.el10_1"
PACKAGES = " \
 php-pecl-imagick \
 php-pecl-imagick-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-imagick-3.8.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04dbf71286fe6a7014e7533f84e19cef230f6ed65beb4a4dca096c6eb71180f5"

URI_x86_64_v2_php-pecl-imagick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-imagick-3.8.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-imagick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-imagick}"
SRC_URI[x86_64_v2_php-pecl-imagick.sha256sum] = "b7cb0548993146e27123aba56e062497cf3206c3c949b3a945a196ea491942c2"

URI_x86_64_v2_php-pecl-imagick-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-imagick-devel-3.8.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-imagick-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-imagick-devel}"
SRC_URI[x86_64_v2_php-pecl-imagick-devel.sha256sum] = "c98152f17985ef5677a09529ed39355309fe631653ff208ae1ecbbc6c1633852"

URI_aarch64_php-pecl-imagick = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-imagick-3.8.0-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-imagick;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-imagick}"
SRC_URI[aarch64_php-pecl-imagick.sha256sum] = "6c388bf7f0312d080cac1efc0bcd2b8bbe66cb3c6597bee4aa23426590c44121"

URI_aarch64_php-pecl-imagick-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-imagick-devel-3.8.0-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-imagick-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-imagick-devel}"
SRC_URI[aarch64_php-pecl-imagick-devel.sha256sum] = "7ab5f9e236ec38a531386b129e5badc1c289bf7fcb90b3af06c9521e2557c776"

RDEPENDS:php-pecl-imagick = " \
 ImageMagick-libs \
 glibc \
 libgomp \
 php-common \
 "
RDEPENDS:php-pecl-imagick-devel = " \
 php-devel \
 php-pecl-imagick \
 "
