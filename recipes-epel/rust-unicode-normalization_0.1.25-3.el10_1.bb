# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-normalization"
PV = "0.1.25"
PR = "3.el10_1"
PACKAGES = " \
 rust-unicode-normalization+default-devel \
 rust-unicode-normalization+std-devel \
 rust-unicode-normalization-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-normalization-0.1.25-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "299cf5d6475a1a9ff2c603178aa092aaa14265046a6a59eb82cb1a7997690d48"

URI_x86_64_v2_rust-unicode-normalization+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-normalization+default-devel-0.1.25-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-normalization+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-normalization+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-normalization+default-devel.sha256sum] = "8e9a94009e0059c4ef79153f42698c1427efdabf57ba0dc6869dfb87bd0767d7"

URI_x86_64_v2_rust-unicode-normalization+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-normalization+std-devel-0.1.25-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-normalization+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-normalization+std-devel}"
SRC_URI[x86_64_v2_rust-unicode-normalization+std-devel.sha256sum] = "654f1cd7c0dae2b795bf2d50fdd855a2173bf3de9e900ed1050700824042f959"

URI_x86_64_v2_rust-unicode-normalization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-normalization-devel-0.1.25-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-normalization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-normalization-devel}"
SRC_URI[x86_64_v2_rust-unicode-normalization-devel.sha256sum] = "9347f4374551a2badd5308f83fcfd624d8a587a03a8116766ea34d558a2da787"

URI_aarch64_rust-unicode-normalization+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-normalization+default-devel-0.1.25-3.el10_1.noarch.rpm;name=aarch64_rust-unicode-normalization+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-normalization+default-devel}"
SRC_URI[aarch64_rust-unicode-normalization+default-devel.sha256sum] = "9d352ba6b93da2819424138482f315d90b2cf728b6d5c110b22c2eeed83c485e"

URI_aarch64_rust-unicode-normalization+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-normalization+std-devel-0.1.25-3.el10_1.noarch.rpm;name=aarch64_rust-unicode-normalization+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-normalization+std-devel}"
SRC_URI[aarch64_rust-unicode-normalization+std-devel.sha256sum] = "23c02a747009472354f3144a90a4bfc2ef8ad75be104cc5c15f7b4c54936550d"

URI_aarch64_rust-unicode-normalization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-normalization-devel-0.1.25-3.el10_1.noarch.rpm;name=aarch64_rust-unicode-normalization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-normalization-devel}"
SRC_URI[aarch64_rust-unicode-normalization-devel.sha256sum] = "d6ac54dc65f754ebb3edf71cf1f5eed962d914c3c03323c27004aa7ec3881084"

RDEPENDS:rust-unicode-normalization+default-devel = " \
 cargo \
 rust-unicode-normalization+std-devel \
 rust-unicode-normalization-devel \
 "
RDEPENDS:rust-unicode-normalization+std-devel = " \
 cargo \
 rust-unicode-normalization-devel \
 "
RDEPENDS:rust-unicode-normalization-devel = " \
 cargo \
 rust \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+default-devel \
 "
