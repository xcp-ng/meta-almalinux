# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linux-sgx-enclaves-prebuilt"
PV = "2.25"
PR = "3.el10"
PACKAGES:x86_64_v2 = " \
 sgx-enclave-prebuilt-common \
 sgx-enclave-prebuilt-ide-signed \
 sgx-enclave-prebuilt-pce-signed \
 sgx-enclave-prebuilt-tdqe-signed \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/linux-sgx-enclaves-prebuilt-2.25-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "849cc7727a8949f36e06e2056f9a2264a30e7439a65847f51dab7cc1072447e8"

URI_x86_64_v2_sgx-enclave-prebuilt-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sgx-enclave-prebuilt-common-2.25-3.el10.x86_64_v2.rpm;name=x86_64_v2_sgx-enclave-prebuilt-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sgx-enclave-prebuilt-common}"
SRC_URI[x86_64_v2_sgx-enclave-prebuilt-common.sha256sum] = "775e4544f2450751705198ecfbd840768473b459489a21ffced058589f5942ec"

URI_x86_64_v2_sgx-enclave-prebuilt-ide-signed = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sgx-enclave-prebuilt-ide-signed-2.25-3.el10.x86_64_v2.rpm;name=x86_64_v2_sgx-enclave-prebuilt-ide-signed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sgx-enclave-prebuilt-ide-signed}"
SRC_URI[x86_64_v2_sgx-enclave-prebuilt-ide-signed.sha256sum] = "715e6e467fa30d0d2b808a72c62c081e191ac85f610fd6dc49c956376f28095d"

URI_x86_64_v2_sgx-enclave-prebuilt-pce-signed = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sgx-enclave-prebuilt-pce-signed-2.25-3.el10.x86_64_v2.rpm;name=x86_64_v2_sgx-enclave-prebuilt-pce-signed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sgx-enclave-prebuilt-pce-signed}"
SRC_URI[x86_64_v2_sgx-enclave-prebuilt-pce-signed.sha256sum] = "311d9dac4e6fc208c580b1ccc7ca8fad1c5d996508c4acaac29195243414ec84"

URI_x86_64_v2_sgx-enclave-prebuilt-tdqe-signed = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sgx-enclave-prebuilt-tdqe-signed-2.25-3.el10.x86_64_v2.rpm;name=x86_64_v2_sgx-enclave-prebuilt-tdqe-signed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sgx-enclave-prebuilt-tdqe-signed}"
SRC_URI[x86_64_v2_sgx-enclave-prebuilt-tdqe-signed.sha256sum] = "37a934d3a0076599df7578ea76435aee855851f13802b83044f8f184871bd6b3"

RDEPENDS:sgx-enclave-prebuilt-common = " \
 "
RDEPENDS:sgx-enclave-prebuilt-ide-signed = " \
 sgx-enclave-prebuilt-common \
 "
RDEPENDS:sgx-enclave-prebuilt-pce-signed = " \
 sgx-enclave-prebuilt-common \
 "
RDEPENDS:sgx-enclave-prebuilt-tdqe-signed = " \
 sgx-enclave-prebuilt-common \
 "
