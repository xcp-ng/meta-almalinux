# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-fdo-server"
PV = "1.0.1"
PR = "2.el10_2.3"
PACKAGES = " \
 go-fdo-server \
 go-fdo-server-manufacturer \
 go-fdo-server-owner \
 go-fdo-server-rendezvous \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/go-fdo-server-1.0.1-2.el10_2.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e715988ef0c5c5d48642b45e7320001c11a732d3cab6278f678575647b93d1bd"

URI_x86_64_v2_go-fdo-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-1.0.1-2.el10_2.3.x86_64_v2.rpm;name=x86_64_v2_go-fdo-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-fdo-server}"
SRC_URI[x86_64_v2_go-fdo-server.sha256sum] = "0f154c3ea758f81abc1c29ac3b9d352280d261a8147d0d163211ac37d905adfc"

URI_x86_64_v2_go-fdo-server-manufacturer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-manufacturer-1.0.1-2.el10_2.3.noarch.rpm;name=x86_64_v2_go-fdo-server-manufacturer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-fdo-server-manufacturer}"
SRC_URI[x86_64_v2_go-fdo-server-manufacturer.sha256sum] = "cb7c2a74215550a5f2ce3d4355be09b754b0e502285caecb7e0f536ef2a0011f"

URI_x86_64_v2_go-fdo-server-owner = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-owner-1.0.1-2.el10_2.3.noarch.rpm;name=x86_64_v2_go-fdo-server-owner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-fdo-server-owner}"
SRC_URI[x86_64_v2_go-fdo-server-owner.sha256sum] = "8a1f12fb60dd6f709e8d044b6d020d14de7e6afbde8dda5848544a5e669cff85"

URI_x86_64_v2_go-fdo-server-rendezvous = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-rendezvous-1.0.1-2.el10_2.3.noarch.rpm;name=x86_64_v2_go-fdo-server-rendezvous;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-fdo-server-rendezvous}"
SRC_URI[x86_64_v2_go-fdo-server-rendezvous.sha256sum] = "caf1db0da6a4940dc368733c9e45509fe9a782dd4331421e6ca8bcf1a5779321"

URI_aarch64_go-fdo-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-1.0.1-2.el10_2.3.aarch64.rpm;name=aarch64_go-fdo-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-fdo-server}"
SRC_URI[aarch64_go-fdo-server.sha256sum] = "68395fe2807056fe72d319477df0057f52c4b5f216e2c81b3a4e4afcbd1ef99e"

URI_aarch64_go-fdo-server-manufacturer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-manufacturer-1.0.1-2.el10_2.3.noarch.rpm;name=aarch64_go-fdo-server-manufacturer;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-fdo-server-manufacturer}"
SRC_URI[aarch64_go-fdo-server-manufacturer.sha256sum] = "cb7c2a74215550a5f2ce3d4355be09b754b0e502285caecb7e0f536ef2a0011f"

URI_aarch64_go-fdo-server-owner = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-owner-1.0.1-2.el10_2.3.noarch.rpm;name=aarch64_go-fdo-server-owner;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-fdo-server-owner}"
SRC_URI[aarch64_go-fdo-server-owner.sha256sum] = "8a1f12fb60dd6f709e8d044b6d020d14de7e6afbde8dda5848544a5e669cff85"

URI_aarch64_go-fdo-server-rendezvous = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-rendezvous-1.0.1-2.el10_2.3.noarch.rpm;name=aarch64_go-fdo-server-rendezvous;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-fdo-server-rendezvous}"
SRC_URI[aarch64_go-fdo-server-rendezvous.sha256sum] = "caf1db0da6a4940dc368733c9e45509fe9a782dd4331421e6ca8bcf1a5779321"

RDEPENDS:go-fdo-server = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:go-fdo-server-manufacturer = " \
 bash \
 go-fdo-server \
 openssl \
 "
RDEPENDS:go-fdo-server-owner = " \
 bash \
 go-fdo-server \
 "
RDEPENDS:go-fdo-server-rendezvous = " \
 bash \
 go-fdo-server \
 "
