# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ddrescue"
PV = "1.30"
PR = "1.el10_2"
PACKAGES = " \
 ddrescue \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/ddrescue-1.30-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0eed3fcb48a0e2ba57a172bf39a94590e3bcde101bbedd625ece60ddc9a64a56"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ddrescue-1.30-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ddrescue;unpack=0"
SRC_URI[x86_64_v2_ddrescue.sha256sum] = "25c66b775275e4cca2572d425255abe85964f908b538bad24f805dabfea920b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/ddrescue-1.30-1.el10_2.aarch64.rpm;name=aarch64_ddrescue;unpack=0"
SRC_URI[aarch64_ddrescue.sha256sum] = "19c5605ce8c8ba28b740d9dea30fc94dbbc04482327f7bfd96d03786d44045a2"

RDEPENDS:ddrescue = " \
 glibc \
 libgcc \
 libstdc++ \
 "
