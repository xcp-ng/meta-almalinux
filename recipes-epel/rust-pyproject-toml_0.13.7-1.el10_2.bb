# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyproject-toml"
PV = "0.13.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-pyproject-toml+default-devel \
 rust-pyproject-toml+glob-devel \
 rust-pyproject-toml+pep639-glob-devel \
 rust-pyproject-toml+tracing-devel \
 rust-pyproject-toml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyproject-toml-0.13.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da11ba24572bd93422d99e82474dc504b3520d37601a2d97cd018b217f36f093"

URI_x86_64_v2_rust-pyproject-toml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml+default-devel-0.13.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml+default-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml+default-devel.sha256sum] = "7a6a7e8d1e728c362b73e31508fa37913f9a889a450624ac2a3de366a64685dc"

URI_x86_64_v2_rust-pyproject-toml+glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml+glob-devel-0.13.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml+glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml+glob-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml+glob-devel.sha256sum] = "0e39fbdb64c479913a3e376155905409ab7385b2616efbbcb7dd21acfa059788"

URI_x86_64_v2_rust-pyproject-toml+pep639-glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml+pep639-glob-devel-0.13.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml+pep639-glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml+pep639-glob-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml+pep639-glob-devel.sha256sum] = "6001bde17b376fc864fc6f869a693e59eefd604a6c0663f5b13f1b58e2a743a0"

URI_x86_64_v2_rust-pyproject-toml+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml+tracing-devel-0.13.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml+tracing-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml+tracing-devel.sha256sum] = "a42ab942256197b7bef7c90ce2bbd27c401a618cd35ebcbfa4aa5f12e2bb3c48"

URI_x86_64_v2_rust-pyproject-toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyproject-toml-devel-0.13.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyproject-toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyproject-toml-devel}"
SRC_URI[x86_64_v2_rust-pyproject-toml-devel.sha256sum] = "29f4cb4c05c3aa9b7485c50ce62ad5a66e7643739e4b47b0ccc1551d87293679"

URI_aarch64_rust-pyproject-toml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml+default-devel-0.13.7-1.el10_2.noarch.rpm;name=aarch64_rust-pyproject-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml+default-devel}"
SRC_URI[aarch64_rust-pyproject-toml+default-devel.sha256sum] = "c6bf3f4c70cec9bba2f8d96154f16ee47bef058253fcacc07514046926d8a6c2"

URI_aarch64_rust-pyproject-toml+glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml+glob-devel-0.13.7-1.el10_2.noarch.rpm;name=aarch64_rust-pyproject-toml+glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml+glob-devel}"
SRC_URI[aarch64_rust-pyproject-toml+glob-devel.sha256sum] = "2c705a4100e5d6b6a491ffe7ed8b87951a67c8ef47a812ff856dd1307fb7b12d"

URI_aarch64_rust-pyproject-toml+pep639-glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml+pep639-glob-devel-0.13.7-1.el10_2.noarch.rpm;name=aarch64_rust-pyproject-toml+pep639-glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml+pep639-glob-devel}"
SRC_URI[aarch64_rust-pyproject-toml+pep639-glob-devel.sha256sum] = "4c39a27e3c4071e9624123e828bb73792ba3066029757759dfb83f868ce1fb44"

URI_aarch64_rust-pyproject-toml+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml+tracing-devel-0.13.7-1.el10_2.noarch.rpm;name=aarch64_rust-pyproject-toml+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml+tracing-devel}"
SRC_URI[aarch64_rust-pyproject-toml+tracing-devel.sha256sum] = "500a6ef153e2de016adbb10d087b4870dfdc6751f114bb0c3cb67ab30350abca"

URI_aarch64_rust-pyproject-toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyproject-toml-devel-0.13.7-1.el10_2.noarch.rpm;name=aarch64_rust-pyproject-toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyproject-toml-devel}"
SRC_URI[aarch64_rust-pyproject-toml-devel.sha256sum] = "63ab4f510819d41a8777da1dd9a5710233136401307dd0ff4139ee9ed252122e"

RDEPENDS:rust-pyproject-toml+default-devel = " \
 cargo \
 rust-pyproject-toml-devel \
 "
RDEPENDS:rust-pyproject-toml+glob-devel = " \
 cargo \
 rust-glob+default-devel \
 rust-pyproject-toml-devel \
 "
RDEPENDS:rust-pyproject-toml+pep639-glob-devel = " \
 cargo \
 rust-pyproject-toml+glob-devel \
 rust-pyproject-toml-devel \
 "
RDEPENDS:rust-pyproject-toml+tracing-devel = " \
 cargo \
 rust-pep440_rs+tracing-devel \
 rust-pep508_rs+tracing-devel \
 rust-pyproject-toml-devel \
 "
RDEPENDS:rust-pyproject-toml-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-indexmap+serde-devel \
 rust-pep440_rs+default-devel \
 rust-pep508_rs+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-thiserror+default-devel \
 rust-toml0.9+parse-devel \
 rust-toml0.9+serde-devel \
 rust-toml0.9+std-devel \
 rust-toml0.9-devel \
 "
