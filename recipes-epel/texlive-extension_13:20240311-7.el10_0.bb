# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "texlive-extension"
PE = "13"
PV = "20240311"
PR = "7.el10_0"
PACKAGES = " \
 texlive-adobemapping \
 texlive-ascmac \
 texlive-atenddvi \
 texlive-auto-pst-pdf \
 texlive-babel-french \
 texlive-babel-german \
 texlive-bibunits \
 texlive-boondox \
 texlive-chemformula \
 texlive-chemgreek \
 texlive-chktex \
 texlive-cjk \
 texlive-cjkpunct \
 texlive-convbkmk \
 texlive-ctex \
 texlive-ctie \
 texlive-cweb \
 texlive-emulateapj \
 texlive-everyhook \
 texlive-fandol \
 texlive-filemod \
 texlive-fltpoint \
 texlive-fontaxes \
 texlive-german \
 texlive-germbib \
 texlive-gincltex \
 texlive-glossaries-english \
 texlive-glossaries-french \
 texlive-glossaries-german \
 texlive-hyphen-german \
 texlive-ieeetran \
 texlive-ipaex \
 texlive-japanese-otf \
 texlive-kantlipsum \
 texlive-lacheck \
 texlive-latex-base-dev \
 texlive-latex-firstaid-dev \
 texlive-lipsum \
 texlive-listingsutf8 \
 texlive-luatexja \
 texlive-mdframed \
 texlive-media9 \
 texlive-mhchem \
 texlive-newtx \
 texlive-nomencl \
 texlive-ntheorem \
 texlive-ocgx2 \
 texlive-pgfplots \
 texlive-picinpar \
 texlive-picture \
 texlive-platex \
 texlive-platex-tools \
 texlive-ps2eps \
 texlive-ptex \
 texlive-ptex-base \
 texlive-ptex-fonts \
 texlive-revtex4 \
 texlive-selinput \
 texlive-sidecap \
 texlive-siunitx \
 texlive-standalone \
 texlive-sttools \
 texlive-supertabular \
 texlive-tcolorbox \
 texlive-tie \
 texlive-tikzfill \
 texlive-ttfutils \
 texlive-units \
 texlive-uplatex \
 texlive-uptex \
 texlive-uptex-base \
 texlive-uptex-fonts \
 texlive-web \
 texlive-xcjk2uni \
 texlive-xecjk \
 texlive-xpinyin \
 texlive-zhmetrics \
 texlive-zhmetrics-uptex \
 texlive-zhnumber \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/texlive-extension-20240311-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a46c84f3b1c8bf7833a5003e47c1843b6a12e683a15b9069496334cc6f35b0a5"

URI_x86_64_v2_texlive-adobemapping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-adobemapping-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-adobemapping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-adobemapping}"
SRC_URI[x86_64_v2_texlive-adobemapping.sha256sum] = "ce9b6fb3d33700e9a0dd17faed04e70f5b815712c41b8da6a719d86ad79c9e99"

URI_x86_64_v2_texlive-ascmac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ascmac-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ascmac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ascmac}"
SRC_URI[x86_64_v2_texlive-ascmac.sha256sum] = "cbc34d52106fbb0d5a47b2608cd36c0c99d2901428ef3aa8f71e4ccfa35fd600"

URI_x86_64_v2_texlive-atenddvi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-atenddvi-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-atenddvi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-atenddvi}"
SRC_URI[x86_64_v2_texlive-atenddvi.sha256sum] = "130951d6c2ec00ca191060daeeda6ddb9e1552be2b2b6d1db9caee270a10e54f"

URI_x86_64_v2_texlive-auto-pst-pdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-auto-pst-pdf-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-auto-pst-pdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-auto-pst-pdf}"
SRC_URI[x86_64_v2_texlive-auto-pst-pdf.sha256sum] = "cf8bea43b9f8d916b0c38d9f1aa56188727916bfa928d53814f1fb2826f26725"

URI_x86_64_v2_texlive-babel-french = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-babel-french-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-babel-french;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babel-french}"
SRC_URI[x86_64_v2_texlive-babel-french.sha256sum] = "7bfd9f856ab5b4e5895234818fcf75b337d53e4275a41d696273e1fca27eacc6"

URI_x86_64_v2_texlive-babel-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-babel-german-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-babel-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babel-german}"
SRC_URI[x86_64_v2_texlive-babel-german.sha256sum] = "cf859239f02e84e83abe381e8d695eb8056643a83d3a5e6866bbf2a556255987"

URI_x86_64_v2_texlive-bibunits = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-bibunits-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-bibunits;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bibunits}"
SRC_URI[x86_64_v2_texlive-bibunits.sha256sum] = "b037795d4a87bec12582526768c72377e75964c44f2f709fbbb8ff20ddfc190b"

URI_x86_64_v2_texlive-boondox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-boondox-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-boondox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-boondox}"
SRC_URI[x86_64_v2_texlive-boondox.sha256sum] = "bc59ac6744f0212206a3423b83ad9c73806905d0c44b70c9aba650e39d48c53e"

URI_x86_64_v2_texlive-chemformula = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-chemformula-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-chemformula;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chemformula}"
SRC_URI[x86_64_v2_texlive-chemformula.sha256sum] = "83572a99b1d677d63df1438840bf3c4851f684b22272f62f5d136aff1cafc2c1"

URI_x86_64_v2_texlive-chemgreek = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-chemgreek-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-chemgreek;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chemgreek}"
SRC_URI[x86_64_v2_texlive-chemgreek.sha256sum] = "720dc6e1442d549c0773f36c78d5c069f585abca4dfdadb4a8379866868e9b35"

URI_x86_64_v2_texlive-chktex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-chktex-20240311-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-chktex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chktex}"
SRC_URI[x86_64_v2_texlive-chktex.sha256sum] = "8e003fe957742cd4d5921feb9cb4c0fab502d29d156bbb7f0f8c257846a1a6ad"

URI_x86_64_v2_texlive-cjk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-cjk-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-cjk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cjk}"
SRC_URI[x86_64_v2_texlive-cjk.sha256sum] = "b2bf4b345eabf5c44ed2622f05cd0ba3eace0fd30e5bd3cfcaf04020a8ee8789"

URI_x86_64_v2_texlive-cjkpunct = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-cjkpunct-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-cjkpunct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cjkpunct}"
SRC_URI[x86_64_v2_texlive-cjkpunct.sha256sum] = "4a11856a2f4950cef1c399039435e63cd4e7339e8590655fa18728a48df8e6f3"

URI_x86_64_v2_texlive-convbkmk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-convbkmk-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-convbkmk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-convbkmk}"
SRC_URI[x86_64_v2_texlive-convbkmk.sha256sum] = "b0726024e8383693ded548a57087a88e25b73050ecabf88175152bebfc1169a5"

URI_x86_64_v2_texlive-ctex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ctex-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ctex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ctex}"
SRC_URI[x86_64_v2_texlive-ctex.sha256sum] = "6bd2bdc9871f0bcbb674ccb50e888b91423103f9b3ad1112492a3880f9377e1a"

URI_x86_64_v2_texlive-ctie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ctie-20240311-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ctie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ctie}"
SRC_URI[x86_64_v2_texlive-ctie.sha256sum] = "3b867b569c81c5acd1d40723158086652f9bc0358818fef3f349c635d8e41af2"

URI_x86_64_v2_texlive-cweb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-cweb-20240311-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-cweb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cweb}"
SRC_URI[x86_64_v2_texlive-cweb.sha256sum] = "170bef6567a546c0aaeb0383e6cd83327cb179c46dd11b3b8df539b0703346c1"

URI_x86_64_v2_texlive-emulateapj = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-emulateapj-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-emulateapj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-emulateapj}"
SRC_URI[x86_64_v2_texlive-emulateapj.sha256sum] = "3b7588f124665fa2251ae21d563d05cfd1c64a8b9cd529d52d5906513b98fafc"

URI_x86_64_v2_texlive-everyhook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-everyhook-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-everyhook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-everyhook}"
SRC_URI[x86_64_v2_texlive-everyhook.sha256sum] = "64a3079829421925b32c397fdc0fb3cd4c5d89a3f0767cd0006f2c2fffb598c0"

URI_x86_64_v2_texlive-fandol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-fandol-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-fandol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fandol}"
SRC_URI[x86_64_v2_texlive-fandol.sha256sum] = "630ae842f27dac2ddf4011d62515fa47886f4fb3cdae3a982a409392add4cc39"

URI_x86_64_v2_texlive-filemod = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-filemod-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-filemod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-filemod}"
SRC_URI[x86_64_v2_texlive-filemod.sha256sum] = "5108b711e02d4b43a7191441c332e3373e2d6b8ef13a043acccd4d07dc27a740"

URI_x86_64_v2_texlive-fltpoint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-fltpoint-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-fltpoint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fltpoint}"
SRC_URI[x86_64_v2_texlive-fltpoint.sha256sum] = "9f4884a81933eaad0408687e8503d44107696a51735246437237c06fb8f97c1b"

URI_x86_64_v2_texlive-fontaxes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-fontaxes-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-fontaxes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontaxes}"
SRC_URI[x86_64_v2_texlive-fontaxes.sha256sum] = "acf011f27fe90cc8f52c5037b667d77fc80c93dbbf5a65bd5aa7b3d1cb394c55"

URI_x86_64_v2_texlive-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-german-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-german}"
SRC_URI[x86_64_v2_texlive-german.sha256sum] = "3d6c69cc89f9099ab95f1f6c184848f723a345fc24b38323cebfc2266f9451a3"

URI_x86_64_v2_texlive-germbib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-germbib-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-germbib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-germbib}"
SRC_URI[x86_64_v2_texlive-germbib.sha256sum] = "b2b41df49f64aba10f12f47e8e2d8558b3cd25da03c1bbf9e3903c5d0804d7fb"

URI_x86_64_v2_texlive-gincltex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-gincltex-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-gincltex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-gincltex}"
SRC_URI[x86_64_v2_texlive-gincltex.sha256sum] = "cd06ff62f46c452d557f6ea347ddd7e67a92407b1546f8f801ab8b73c9237459"

URI_x86_64_v2_texlive-glossaries-english = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-glossaries-english-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-glossaries-english;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glossaries-english}"
SRC_URI[x86_64_v2_texlive-glossaries-english.sha256sum] = "f3e2922904cdd1073341bab84f5519611ce88f62d5c811358ebeb36abeb183fd"

URI_x86_64_v2_texlive-glossaries-french = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-glossaries-french-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-glossaries-french;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glossaries-french}"
SRC_URI[x86_64_v2_texlive-glossaries-french.sha256sum] = "3440f05d07146d8d5fb75dbb6ac0b1195d89ebaa17ebc871a9154a6e6fd08b5d"

URI_x86_64_v2_texlive-glossaries-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-glossaries-german-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-glossaries-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glossaries-german}"
SRC_URI[x86_64_v2_texlive-glossaries-german.sha256sum] = "c62db33abdeb4538bdee56b0897661c78735da1435f6fef88b42da6bfedc7b30"

URI_x86_64_v2_texlive-hyphen-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-hyphen-german-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-hyphen-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyphen-german}"
SRC_URI[x86_64_v2_texlive-hyphen-german.sha256sum] = "2bdcb2dc198e0f267965727207591a368866bc2f4616e88c0326ae8b7c97f7f4"

URI_x86_64_v2_texlive-ieeetran = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ieeetran-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ieeetran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ieeetran}"
SRC_URI[x86_64_v2_texlive-ieeetran.sha256sum] = "10ab807e389cb0174558eaeb3a75a93919587319eb472b806b701aa8c8df148a"

URI_x86_64_v2_texlive-ipaex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ipaex-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ipaex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ipaex}"
SRC_URI[x86_64_v2_texlive-ipaex.sha256sum] = "77ed9eae70918f1b298bbfbc8b71404c134e7389a3e81439db7dc4c7f61be769"

URI_x86_64_v2_texlive-japanese-otf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-japanese-otf-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-japanese-otf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-japanese-otf}"
SRC_URI[x86_64_v2_texlive-japanese-otf.sha256sum] = "0be99055a8c5a1747048d2e5ad9358c428a50154608d88519571732eaf45c7f9"

URI_x86_64_v2_texlive-kantlipsum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-kantlipsum-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-kantlipsum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kantlipsum}"
SRC_URI[x86_64_v2_texlive-kantlipsum.sha256sum] = "cf125a9983c6e4dadf96ae22fc6bbced5600d02fe8553f222e38c9cf6253a937"

URI_x86_64_v2_texlive-lacheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-lacheck-20240311-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-lacheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lacheck}"
SRC_URI[x86_64_v2_texlive-lacheck.sha256sum] = "fcb0d19b30221964c3e57135ca36dac9aede3225acc1727246753c1b6659cf8a"

URI_x86_64_v2_texlive-latex-base-dev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-latex-base-dev-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-latex-base-dev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex-base-dev}"
SRC_URI[x86_64_v2_texlive-latex-base-dev.sha256sum] = "60b15cec2eb3dcc84116959f230f5c7428b9e57f65c1645861aa352b1f40d920"
RPROVIDES:texlive-latex-base-dev:x86_64_v2 = "virtual/tex_alltt.sty_ virtual/tex_article.cls_ virtual/tex_doc.sty_ virtual/tex_exscale.sty_ virtual/tex_fix-cm.sty_ virtual/tex_fixltx2e.sty_ virtual/tex_flafter.sty_ virtual/tex_fontenc.sty_ virtual/tex_ifthen.sty_ virtual/tex_inputenc.sty_ virtual/tex_latexsym.sty_ virtual/tex_makeidx.sty_ virtual/tex_oldlfont.sty_ virtual/tex_shortvrb.sty_ virtual/tex_t1cmr.fd_ virtual/tex_textcomp.sty_"

URI_x86_64_v2_texlive-latex-firstaid-dev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-latex-firstaid-dev-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-latex-firstaid-dev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex-firstaid-dev}"
SRC_URI[x86_64_v2_texlive-latex-firstaid-dev.sha256sum] = "91c8e8c4c7088fb0dbee5ddaab61e2813b732e9875d6354e945ba54b1e938e23"

URI_x86_64_v2_texlive-lipsum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-lipsum-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-lipsum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lipsum}"
SRC_URI[x86_64_v2_texlive-lipsum.sha256sum] = "bf0d2e2ce79e115862299bda7454da044c0b4dfcad71c66f23bd8d5be3b3e500"

URI_x86_64_v2_texlive-listingsutf8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-listingsutf8-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-listingsutf8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-listingsutf8}"
SRC_URI[x86_64_v2_texlive-listingsutf8.sha256sum] = "0200cc0dbaa82c603e8869f40cbc0926405887c995c0c782cb92f476bc99e8f7"

URI_x86_64_v2_texlive-luatexja = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-luatexja-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-luatexja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luatexja}"
SRC_URI[x86_64_v2_texlive-luatexja.sha256sum] = "ab4a9a73fdaccce242fde7b1cc4446adc4919597db8014b772b1c42f5ad6f036"

URI_x86_64_v2_texlive-mdframed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-mdframed-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-mdframed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mdframed}"
SRC_URI[x86_64_v2_texlive-mdframed.sha256sum] = "648f5a24e83ba0596706f7ae3f01a1a8a7bb5b3bfa14e9b651f45f27f0d1d71e"

URI_x86_64_v2_texlive-media9 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-media9-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-media9;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-media9}"
SRC_URI[x86_64_v2_texlive-media9.sha256sum] = "dc3cffcff473626689110db90c5b7907444b7ecdaeb446a78d44d856972f6ac0"

URI_x86_64_v2_texlive-mhchem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-mhchem-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-mhchem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mhchem}"
SRC_URI[x86_64_v2_texlive-mhchem.sha256sum] = "1b4e704bd78777e37be186de93abdafd591be08dece6a9ff43eb6e9727e1576b"

URI_x86_64_v2_texlive-newtx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-newtx-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-newtx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-newtx}"
SRC_URI[x86_64_v2_texlive-newtx.sha256sum] = "802642e34fd54865e20a8f882c590bec772f42d39eb5171bfbb036c9dcc06039"

URI_x86_64_v2_texlive-nomencl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-nomencl-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-nomencl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-nomencl}"
SRC_URI[x86_64_v2_texlive-nomencl.sha256sum] = "ce9e910964cbda41ff0407ade87b9b942332e9695559c3dd255743d0b0457a58"

URI_x86_64_v2_texlive-ntheorem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ntheorem-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ntheorem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ntheorem}"
SRC_URI[x86_64_v2_texlive-ntheorem.sha256sum] = "195ae0d2f391e9c4491d06a1fc7222c352f598ba20dcfe6333063852df5900b1"

URI_x86_64_v2_texlive-ocgx2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ocgx2-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ocgx2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ocgx2}"
SRC_URI[x86_64_v2_texlive-ocgx2.sha256sum] = "4a76299891508d769f9764d27bc15b848a0b681e7b47280b071f79f0a6deb49b"

URI_x86_64_v2_texlive-pgfplots = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-pgfplots-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-pgfplots;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pgfplots}"
SRC_URI[x86_64_v2_texlive-pgfplots.sha256sum] = "9d698614d35a8972b45f2b5a6ab330fc8386d9d163082cb266177b3598d0268f"

URI_x86_64_v2_texlive-picinpar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-picinpar-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-picinpar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-picinpar}"
SRC_URI[x86_64_v2_texlive-picinpar.sha256sum] = "6b01021bdcf596df7e1d058ed5316190b98cd3aafb43805e41dfef3fdc3a7640"

URI_x86_64_v2_texlive-picture = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-picture-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-picture;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-picture}"
SRC_URI[x86_64_v2_texlive-picture.sha256sum] = "1e5c543b0e302a5350ef9486b7d22b90e87f02a5cde4a2baaef7482926b857af"

URI_x86_64_v2_texlive-platex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-platex-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-platex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-platex}"
SRC_URI[x86_64_v2_texlive-platex.sha256sum] = "52766995b6a0c0cdfcb47557a79cf7f0fd8e5cfa3b433a72513003f9250383a1"

URI_x86_64_v2_texlive-platex-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-platex-tools-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-platex-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-platex-tools}"
SRC_URI[x86_64_v2_texlive-platex-tools.sha256sum] = "7d22613c4762ee2e6492bb3135ed9f53abc8db058427edb3935a113545e2c3ac"

URI_x86_64_v2_texlive-ps2eps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ps2eps-20240311-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ps2eps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ps2eps}"
SRC_URI[x86_64_v2_texlive-ps2eps.sha256sum] = "b5cb519ddc6acc521f9343a7f2b6122b3c57b5bd2b28a99434870e552af2b22e"

URI_x86_64_v2_texlive-ptex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ptex-20240311-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ptex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptex}"
SRC_URI[x86_64_v2_texlive-ptex.sha256sum] = "89bd30e149e5e1276c8bd639bd0418fcac5154545667a320a24365192873ddb8"

URI_x86_64_v2_texlive-ptex-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ptex-base-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ptex-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptex-base}"
SRC_URI[x86_64_v2_texlive-ptex-base.sha256sum] = "05505da308c524581453a688c1cce73fbbe045b4da06327f32391005fb729360"

URI_x86_64_v2_texlive-ptex-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ptex-fonts-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ptex-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptex-fonts}"
SRC_URI[x86_64_v2_texlive-ptex-fonts.sha256sum] = "b62169bde4d421aceffa5f660a4716259714d1bac6d95102bcb3123f071c9d3e"

URI_x86_64_v2_texlive-revtex4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-revtex4-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-revtex4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-revtex4}"
SRC_URI[x86_64_v2_texlive-revtex4.sha256sum] = "254ae9e917c1e30149a784680740d04077da701017b51f828f391d27e20acb70"

URI_x86_64_v2_texlive-selinput = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-selinput-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-selinput;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-selinput}"
SRC_URI[x86_64_v2_texlive-selinput.sha256sum] = "02219dbfa00fe0ad93b3a011bb70d936a6f5f58b906b72f756c5c75ab89272c1"

URI_x86_64_v2_texlive-sidecap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-sidecap-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-sidecap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sidecap}"
SRC_URI[x86_64_v2_texlive-sidecap.sha256sum] = "4b2e51967a426b84682a515bcb5903ffdd74652a835b26e65f6258e834020c29"

URI_x86_64_v2_texlive-siunitx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-siunitx-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-siunitx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-siunitx}"
SRC_URI[x86_64_v2_texlive-siunitx.sha256sum] = "52adcd97caa252aee58a5e95db79e311218b59e27c660ea03f8b9a246ae8c9f9"

URI_x86_64_v2_texlive-standalone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-standalone-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-standalone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-standalone}"
SRC_URI[x86_64_v2_texlive-standalone.sha256sum] = "4930267a1d8f6971a6024098bec90d29bc7e31715fb130347bdef832a05509a5"

URI_x86_64_v2_texlive-sttools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-sttools-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-sttools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sttools}"
SRC_URI[x86_64_v2_texlive-sttools.sha256sum] = "7696f3244a20b3eeb05806b3f4f273b5ab38321c13aeb78ace0d157e33ca41a7"

URI_x86_64_v2_texlive-supertabular = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-supertabular-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-supertabular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-supertabular}"
SRC_URI[x86_64_v2_texlive-supertabular.sha256sum] = "be20f76c8d916c4a1b96379155cac3f442890f6c48d62506c88b22ecde2f1891"

URI_x86_64_v2_texlive-tcolorbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-tcolorbox-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-tcolorbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tcolorbox}"
SRC_URI[x86_64_v2_texlive-tcolorbox.sha256sum] = "f57253b75cd4e06ab7c3243fec6c7b3fea865d1df1e4b816fe283afc46412a34"

URI_x86_64_v2_texlive-tie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-tie-20240311-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-tie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tie}"
SRC_URI[x86_64_v2_texlive-tie.sha256sum] = "d279007f07cd2ec1dc191418a73a0aaa801875ac28e69ea13aaf5e6ce0f1f377"

URI_x86_64_v2_texlive-tikzfill = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-tikzfill-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-tikzfill;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tikzfill}"
SRC_URI[x86_64_v2_texlive-tikzfill.sha256sum] = "d807cbe1ebff7bdbe8c3ce964ffa5430c22dd9657c0fd3de4ba5160c35c8f983"

URI_x86_64_v2_texlive-ttfutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ttfutils-20240311-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ttfutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ttfutils}"
SRC_URI[x86_64_v2_texlive-ttfutils.sha256sum] = "96c07a5af5fe594c8eb1da1c87c38baad4088a24e9aad1207251bc4a36f4190a"

URI_x86_64_v2_texlive-units = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-units-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-units;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-units}"
SRC_URI[x86_64_v2_texlive-units.sha256sum] = "69f76e8941ddb4ac9186410062165ad2b27b50ac55ee09344b10c51c28719a50"

URI_x86_64_v2_texlive-uplatex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uplatex-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-uplatex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uplatex}"
SRC_URI[x86_64_v2_texlive-uplatex.sha256sum] = "8872c5a629043522e51bbf4f987b1b97c1880903a09fdba8982369d592c0c73a"

URI_x86_64_v2_texlive-uptex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uptex-20240311-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-uptex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uptex}"
SRC_URI[x86_64_v2_texlive-uptex.sha256sum] = "116883262f0bbce51ab715d07e96567d60103a2f5ece30fa06a129b5015d0621"

URI_x86_64_v2_texlive-uptex-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uptex-base-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-uptex-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uptex-base}"
SRC_URI[x86_64_v2_texlive-uptex-base.sha256sum] = "1a48b321cf4a7bede937c0f44991bfd2f7a3f7a1a9ef3be6703144e4091d30e2"

URI_x86_64_v2_texlive-uptex-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uptex-fonts-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-uptex-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uptex-fonts}"
SRC_URI[x86_64_v2_texlive-uptex-fonts.sha256sum] = "ff083675089ac3e935190f06eb4ef3f3558b39d048217d6054a18c211fd40458"

URI_x86_64_v2_texlive-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-web-20240311-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-web}"
SRC_URI[x86_64_v2_texlive-web.sha256sum] = "976f1a8ea69d8fb8941a6f28f5fb679b26624e17afb90e5d3b8eda00a7936719"

URI_x86_64_v2_texlive-xcjk2uni = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xcjk2uni-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-xcjk2uni;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xcjk2uni}"
SRC_URI[x86_64_v2_texlive-xcjk2uni.sha256sum] = "077410f85421a93ccd1ca9ff0ecfd94fba6c8fd3f8c2ab9b1ac10621769cba07"

URI_x86_64_v2_texlive-xecjk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xecjk-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-xecjk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xecjk}"
SRC_URI[x86_64_v2_texlive-xecjk.sha256sum] = "1a7a4ac30b495607cd7415b39bb22041ad6f33e8e749c6693ea3b0732fb47eb8"

URI_x86_64_v2_texlive-xpinyin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xpinyin-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-xpinyin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xpinyin}"
SRC_URI[x86_64_v2_texlive-xpinyin.sha256sum] = "de1e2d3acdfa1c92d3d19395a49f743466e2b9fdd5c3c28f4739414b40610972"

URI_x86_64_v2_texlive-zhmetrics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-zhmetrics-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-zhmetrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zhmetrics}"
SRC_URI[x86_64_v2_texlive-zhmetrics.sha256sum] = "b7257c26a516ea7f0f870d370a372b6cef9bd03408287d9d510ce53592fef71b"

URI_x86_64_v2_texlive-zhmetrics-uptex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-zhmetrics-uptex-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-zhmetrics-uptex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zhmetrics-uptex}"
SRC_URI[x86_64_v2_texlive-zhmetrics-uptex.sha256sum] = "42372fecccc7884f92719557825d3866a6962cb280ddddbcdb94ade915917e1f"

URI_x86_64_v2_texlive-zhnumber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-zhnumber-20240311-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-zhnumber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zhnumber}"
SRC_URI[x86_64_v2_texlive-zhnumber.sha256sum] = "080e47f2e1b075223fd55d2c57161d11b63e800dde635b3ddec5bce885793c38"

URI_aarch64_texlive-adobemapping = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-adobemapping-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-adobemapping;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-adobemapping}"
SRC_URI[aarch64_texlive-adobemapping.sha256sum] = "ab88ea54d79f176198ab960f2607f4d15c59f8ab8b6a643353beb2febadaff8f"

URI_aarch64_texlive-ascmac = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ascmac-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-ascmac;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ascmac}"
SRC_URI[aarch64_texlive-ascmac.sha256sum] = "094d0fa558d5f9ad73e107d21b2722d93c709183e0b98c69efa8212d6c910a1d"

URI_aarch64_texlive-atenddvi = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-atenddvi-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-atenddvi;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-atenddvi}"
SRC_URI[aarch64_texlive-atenddvi.sha256sum] = "5c984eb97533ae92601d03a4dabcac8614c50824a948efac8045d122de387f52"

URI_aarch64_texlive-auto-pst-pdf = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-auto-pst-pdf-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-auto-pst-pdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-auto-pst-pdf}"
SRC_URI[aarch64_texlive-auto-pst-pdf.sha256sum] = "25847d46b1ee7ff836691412faccd0f2dfefe5ed2f5da4bdf2452ffb3a5dee05"

URI_aarch64_texlive-babel-french = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-babel-french-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-babel-french;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babel-french}"
SRC_URI[aarch64_texlive-babel-french.sha256sum] = "1bb213c03f1b001d00ff8d283d0d61a29010662bf159a2599b4ecf91bfb866ea"

URI_aarch64_texlive-babel-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-babel-german-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-babel-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babel-german}"
SRC_URI[aarch64_texlive-babel-german.sha256sum] = "ed7c370c737e0ed70f5abdcc286d8cc45aede8a4a192ef41d7e8472865db1d3d"

URI_aarch64_texlive-bibunits = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-bibunits-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-bibunits;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bibunits}"
SRC_URI[aarch64_texlive-bibunits.sha256sum] = "a095b4acd89d07a0783993c0aef7018f39eba7f078c040d36cf22fd9bec72ef8"

URI_aarch64_texlive-boondox = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-boondox-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-boondox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-boondox}"
SRC_URI[aarch64_texlive-boondox.sha256sum] = "7d00e43e7a9a925f1080b87957a2c000cb8443b2e7ef9e7e5a468748d341be80"

URI_aarch64_texlive-chemformula = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-chemformula-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-chemformula;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chemformula}"
SRC_URI[aarch64_texlive-chemformula.sha256sum] = "1383db5e266ea8703db8550ba71762104c5931e2575561130b9dd94480fcf156"

URI_aarch64_texlive-chemgreek = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-chemgreek-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-chemgreek;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chemgreek}"
SRC_URI[aarch64_texlive-chemgreek.sha256sum] = "c62827a18e7e902186fc38c0ccd2af892f34d5f8c66167efc733ee129623ea55"

URI_aarch64_texlive-chktex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-chktex-20240311-7.el10_0.aarch64.rpm;name=aarch64_texlive-chktex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chktex}"
SRC_URI[aarch64_texlive-chktex.sha256sum] = "94b50bc002b5eb66f09dd4f861c9bf283d447de502328d68113a0b0951fa9555"

URI_aarch64_texlive-cjk = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-cjk-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-cjk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cjk}"
SRC_URI[aarch64_texlive-cjk.sha256sum] = "d64bce89caf8d928056c7ed875efdd1a38a894f0bfad180ba74d036e71094613"

URI_aarch64_texlive-cjkpunct = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-cjkpunct-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-cjkpunct;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cjkpunct}"
SRC_URI[aarch64_texlive-cjkpunct.sha256sum] = "414645dbf31cd30cf63386fb9c7f0dc3ff59b57b042826ef7450237bd8dab015"

URI_aarch64_texlive-convbkmk = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-convbkmk-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-convbkmk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-convbkmk}"
SRC_URI[aarch64_texlive-convbkmk.sha256sum] = "b6ada1bcc1905aa2ff3cfb76f5fbc41713caacc090793b1c214f387a4884f395"

URI_aarch64_texlive-ctex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ctex-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-ctex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ctex}"
SRC_URI[aarch64_texlive-ctex.sha256sum] = "88d0ad450593e5ef09253fd2bb4611159d6ed0659ca768f519d85f1556a56fb2"

URI_aarch64_texlive-ctie = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ctie-20240311-7.el10_0.aarch64.rpm;name=aarch64_texlive-ctie;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ctie}"
SRC_URI[aarch64_texlive-ctie.sha256sum] = "db0d26b461a77b751324665d0d201327d5393d29f57d9d42a9c6d6a6314b2e62"

URI_aarch64_texlive-cweb = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-cweb-20240311-7.el10_0.aarch64.rpm;name=aarch64_texlive-cweb;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cweb}"
SRC_URI[aarch64_texlive-cweb.sha256sum] = "abf441f4373ff86ba2bd9c9ba310837bb621074e193f4dba375a1ba3c9c5ef19"

URI_aarch64_texlive-emulateapj = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-emulateapj-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-emulateapj;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-emulateapj}"
SRC_URI[aarch64_texlive-emulateapj.sha256sum] = "0e29cb01106449838cb946af617781230010186907bcf489c929af63f5ab9b57"

URI_aarch64_texlive-everyhook = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-everyhook-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-everyhook;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-everyhook}"
SRC_URI[aarch64_texlive-everyhook.sha256sum] = "f18d2a083a50f87a87056809d39aa89582f43cee1a894c1d8627680ce5fbaaeb"

URI_aarch64_texlive-fandol = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-fandol-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-fandol;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fandol}"
SRC_URI[aarch64_texlive-fandol.sha256sum] = "942cb758bacefecbfe4041108a59bf376152c0b46770b055007e3dd6be4ba87f"

URI_aarch64_texlive-filemod = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-filemod-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-filemod;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-filemod}"
SRC_URI[aarch64_texlive-filemod.sha256sum] = "d358ef7c191600da597b9ccec8396aa747039d4035eb851f8e126d138efab4c6"

URI_aarch64_texlive-fltpoint = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-fltpoint-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-fltpoint;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fltpoint}"
SRC_URI[aarch64_texlive-fltpoint.sha256sum] = "0826cc96822405b36c06b5a1dad4f304ff45b7f7bb481f8d10fbc47c18315bb7"

URI_aarch64_texlive-fontaxes = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-fontaxes-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-fontaxes;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontaxes}"
SRC_URI[aarch64_texlive-fontaxes.sha256sum] = "797f2c71d65a2d4438564050578e93ebeae7cf61f9a0e86a9abf4f601a3ae0cd"

URI_aarch64_texlive-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-german-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-german}"
SRC_URI[aarch64_texlive-german.sha256sum] = "e0acb0b1e2712faa1695c5f3f519a512bdf10ab6a159fc97c24e2b0b080f9fd3"

URI_aarch64_texlive-germbib = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-germbib-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-germbib;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-germbib}"
SRC_URI[aarch64_texlive-germbib.sha256sum] = "d4f0efce54f988833e24da53b54f96acf555c8cde6d117cfef6206b04d20f269"

URI_aarch64_texlive-gincltex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-gincltex-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-gincltex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-gincltex}"
SRC_URI[aarch64_texlive-gincltex.sha256sum] = "3a5b11f5060da3015351cc44cf824d589c2b875a8b07e5bc1cb19baddcdbfe30"

URI_aarch64_texlive-glossaries-english = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-glossaries-english-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-glossaries-english;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glossaries-english}"
SRC_URI[aarch64_texlive-glossaries-english.sha256sum] = "f17f5150512c125811a961d455937d6fa80e6020b4c5ef0992cc3eaa0faa2728"

URI_aarch64_texlive-glossaries-french = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-glossaries-french-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-glossaries-french;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glossaries-french}"
SRC_URI[aarch64_texlive-glossaries-french.sha256sum] = "a946a6b380283bd08b7a53da41773139528c5b01f7230b0a95e044d43b9d846d"

URI_aarch64_texlive-glossaries-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-glossaries-german-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-glossaries-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glossaries-german}"
SRC_URI[aarch64_texlive-glossaries-german.sha256sum] = "af3205da5cc82997aee89986d5934dec5015effe74f6f9e060b774b5626aa570"

URI_aarch64_texlive-hyphen-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-hyphen-german-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-hyphen-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyphen-german}"
SRC_URI[aarch64_texlive-hyphen-german.sha256sum] = "54246a4a4efe544d4e79e31c69fc970d5c91d35803759427154e8d0f958a7f82"

URI_aarch64_texlive-ieeetran = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ieeetran-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-ieeetran;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ieeetran}"
SRC_URI[aarch64_texlive-ieeetran.sha256sum] = "c73e8a396e08178823d77599c51b6969c5da99ab30e889caa29ad43e09670aab"

URI_aarch64_texlive-ipaex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ipaex-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-ipaex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ipaex}"
SRC_URI[aarch64_texlive-ipaex.sha256sum] = "0a88e749e3e4999d0ef736baf249a9c152f5864f934f5d7fc40466c2732acc5b"

URI_aarch64_texlive-japanese-otf = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-japanese-otf-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-japanese-otf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-japanese-otf}"
SRC_URI[aarch64_texlive-japanese-otf.sha256sum] = "46ead8994d5e7fdbcd0f4540e9d877d02610f706c51b22f6bcf6dbb3c9eb077b"

URI_aarch64_texlive-kantlipsum = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-kantlipsum-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-kantlipsum;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kantlipsum}"
SRC_URI[aarch64_texlive-kantlipsum.sha256sum] = "c2e4e69894e6ea0ad3a1c8276bd7bfe1c4fd01d99978840d5a29aac6ce9678cd"

URI_aarch64_texlive-lacheck = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-lacheck-20240311-7.el10_0.aarch64.rpm;name=aarch64_texlive-lacheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lacheck}"
SRC_URI[aarch64_texlive-lacheck.sha256sum] = "718bd709f03208571bdc95c4c3f6eb84e7baaf63cb6957448f63a05fe28f1354"

URI_aarch64_texlive-latex-base-dev = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-latex-base-dev-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-latex-base-dev;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex-base-dev}"
SRC_URI[aarch64_texlive-latex-base-dev.sha256sum] = "549cf589940991ef82825f4aba0f7424e091b8c90b775b9b99cca5a47f1db8b7"
RPROVIDES:texlive-latex-base-dev:aarch64 = "virtual/tex_alltt.sty_ virtual/tex_article.cls_ virtual/tex_doc.sty_ virtual/tex_exscale.sty_ virtual/tex_fix-cm.sty_ virtual/tex_fixltx2e.sty_ virtual/tex_flafter.sty_ virtual/tex_fontenc.sty_ virtual/tex_ifthen.sty_ virtual/tex_inputenc.sty_ virtual/tex_latexsym.sty_ virtual/tex_makeidx.sty_ virtual/tex_oldlfont.sty_ virtual/tex_shortvrb.sty_ virtual/tex_t1cmr.fd_ virtual/tex_textcomp.sty_"

URI_aarch64_texlive-latex-firstaid-dev = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-latex-firstaid-dev-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-latex-firstaid-dev;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex-firstaid-dev}"
SRC_URI[aarch64_texlive-latex-firstaid-dev.sha256sum] = "0d99c07eda4aaaa7fe19d39a826883a6f3b304a4a68335cf3ed6d56121b8d0b2"

URI_aarch64_texlive-lipsum = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-lipsum-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-lipsum;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lipsum}"
SRC_URI[aarch64_texlive-lipsum.sha256sum] = "f87a15e8267373d64a2273d0ab55aa1c4b104624fd2aa7e5f58dd03e927da1a9"

URI_aarch64_texlive-listingsutf8 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-listingsutf8-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-listingsutf8;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-listingsutf8}"
SRC_URI[aarch64_texlive-listingsutf8.sha256sum] = "03de935d28f8bbf661543a364bc5c318fdca4f8e876d9e184e6162cf2fff98b0"

URI_aarch64_texlive-luatexja = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-luatexja-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-luatexja;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luatexja}"
SRC_URI[aarch64_texlive-luatexja.sha256sum] = "39d549647764cb31f3c1367e9aa2a6e45f80919de5bedfff0a2ab50bc1d59ff5"

URI_aarch64_texlive-mdframed = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-mdframed-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-mdframed;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mdframed}"
SRC_URI[aarch64_texlive-mdframed.sha256sum] = "954003c98988b02270bd80aef8cf2a1caf403939f6de5d407c73c2c715ab4b57"

URI_aarch64_texlive-media9 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-media9-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-media9;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-media9}"
SRC_URI[aarch64_texlive-media9.sha256sum] = "21cffb87601c35d91142e50b6a6f92d8949ee3596c89483fb3864f0de6474abc"

URI_aarch64_texlive-mhchem = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-mhchem-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-mhchem;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mhchem}"
SRC_URI[aarch64_texlive-mhchem.sha256sum] = "2ddc59419e10a83a55028e62de77f55d5f3fbc6af489b31d396af134933c0c8e"

URI_aarch64_texlive-newtx = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-newtx-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-newtx;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-newtx}"
SRC_URI[aarch64_texlive-newtx.sha256sum] = "30f2d70c75e975f55a7ea2b39b44604dc2066b5e0765708536a28ac418066661"

URI_aarch64_texlive-nomencl = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-nomencl-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-nomencl;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-nomencl}"
SRC_URI[aarch64_texlive-nomencl.sha256sum] = "4c39ffedb6460bc6872ced4498e792c5f285a85a7d0edaa9e014f1d1e0643f7c"

URI_aarch64_texlive-ntheorem = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ntheorem-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-ntheorem;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ntheorem}"
SRC_URI[aarch64_texlive-ntheorem.sha256sum] = "e4f030c681e68070bc6a5fdfc8ee9e45dfba6ac4b6ebe1cd39884888bf91f8a0"

URI_aarch64_texlive-ocgx2 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ocgx2-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-ocgx2;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ocgx2}"
SRC_URI[aarch64_texlive-ocgx2.sha256sum] = "dcf334618cfbf4ce8c4fce03e2745b28d6bbfcae080e23fdf1cd818278f24a0e"

URI_aarch64_texlive-pgfplots = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-pgfplots-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-pgfplots;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pgfplots}"
SRC_URI[aarch64_texlive-pgfplots.sha256sum] = "bc94ab88881a17123d451d29e351a987eba0ea5397658847beddb3fc09b0c155"

URI_aarch64_texlive-picinpar = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-picinpar-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-picinpar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-picinpar}"
SRC_URI[aarch64_texlive-picinpar.sha256sum] = "73e82e3caccb0ff5fda84c0e6458fbc37c1064cea6097c89462ace2a80a241c1"

URI_aarch64_texlive-picture = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-picture-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-picture;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-picture}"
SRC_URI[aarch64_texlive-picture.sha256sum] = "f75ec91cc1ba577c64c3ce14deb82ef790cd83e14ef1826489b2ae532b106bac"

URI_aarch64_texlive-platex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-platex-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-platex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-platex}"
SRC_URI[aarch64_texlive-platex.sha256sum] = "ab9f79f5dad8a7cd8a1e1fe70f1daff87b8e4258106c3f407dd2c171aa6991fe"

URI_aarch64_texlive-platex-tools = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-platex-tools-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-platex-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-platex-tools}"
SRC_URI[aarch64_texlive-platex-tools.sha256sum] = "a76026ec27dadd1536a7cee833427dba4080730db7b3839e022782255ebdf8a4"

URI_aarch64_texlive-ps2eps = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ps2eps-20240311-7.el10_0.aarch64.rpm;name=aarch64_texlive-ps2eps;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ps2eps}"
SRC_URI[aarch64_texlive-ps2eps.sha256sum] = "f63ac022bd8e9363237e719d21be119100022565cd2444d861088843c15e7160"

URI_aarch64_texlive-ptex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ptex-20240311-7.el10_0.aarch64.rpm;name=aarch64_texlive-ptex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptex}"
SRC_URI[aarch64_texlive-ptex.sha256sum] = "4c1906804ce716b8df4e26940f03de0dd5e6b75962214eb5b826f80a10c27694"

URI_aarch64_texlive-ptex-base = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ptex-base-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-ptex-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptex-base}"
SRC_URI[aarch64_texlive-ptex-base.sha256sum] = "8a4b13c12b47ace051ee5c038e2255d87f2a75d7af96cd5112c2fc65c6f40d2e"

URI_aarch64_texlive-ptex-fonts = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ptex-fonts-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-ptex-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptex-fonts}"
SRC_URI[aarch64_texlive-ptex-fonts.sha256sum] = "199d429b3e0ed04ad555f9a00bf1ecea9b125339466091eeafe17b6737ce8f2b"

URI_aarch64_texlive-revtex4 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-revtex4-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-revtex4;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-revtex4}"
SRC_URI[aarch64_texlive-revtex4.sha256sum] = "a8f1681104b21ba63cf1488a2e249e4a940cd199a3239326d2d731fa9040008f"

URI_aarch64_texlive-selinput = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-selinput-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-selinput;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-selinput}"
SRC_URI[aarch64_texlive-selinput.sha256sum] = "44aeb1b5d9405e7d29e277798c7eb437fef608cb12e96813ca619fec534784b3"

URI_aarch64_texlive-sidecap = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-sidecap-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-sidecap;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sidecap}"
SRC_URI[aarch64_texlive-sidecap.sha256sum] = "47c0657f2da9e1c3f9638eb8e445d90c28c8e698c34ae9c304106e44e25d2471"

URI_aarch64_texlive-siunitx = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-siunitx-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-siunitx;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-siunitx}"
SRC_URI[aarch64_texlive-siunitx.sha256sum] = "6da4c3aa72527c7160f75828f3c992ede7498a4c3643c327ed68e87efd24b26e"

URI_aarch64_texlive-standalone = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-standalone-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-standalone;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-standalone}"
SRC_URI[aarch64_texlive-standalone.sha256sum] = "8cb2ad581e5444e69f90ea116cd8b5209e8f1498845dae4cdfd88d14b070b792"

URI_aarch64_texlive-sttools = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-sttools-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-sttools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sttools}"
SRC_URI[aarch64_texlive-sttools.sha256sum] = "4c66d7812cccfde56068be630efe6499a64a0e6b0a3023ee044a917f96627a26"

URI_aarch64_texlive-supertabular = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-supertabular-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-supertabular;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-supertabular}"
SRC_URI[aarch64_texlive-supertabular.sha256sum] = "75f94a134480041ca2032ffe9527d823c74b3f07c3f1b4d91b31cf74c092b984"

URI_aarch64_texlive-tcolorbox = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-tcolorbox-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-tcolorbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tcolorbox}"
SRC_URI[aarch64_texlive-tcolorbox.sha256sum] = "3b4f423f923fd59aa69aab357a7fd5e0ed59ef08ed29986de9ce24a8a98c45a7"

URI_aarch64_texlive-tie = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-tie-20240311-7.el10_0.aarch64.rpm;name=aarch64_texlive-tie;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tie}"
SRC_URI[aarch64_texlive-tie.sha256sum] = "7f04bf4e4745e4554367ec4ed9a191f541af94fe68b195aec2049e0c836bcf66"

URI_aarch64_texlive-tikzfill = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-tikzfill-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-tikzfill;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tikzfill}"
SRC_URI[aarch64_texlive-tikzfill.sha256sum] = "501ce5d120bfef5eeaaa9e7b58577d9ad39dde793d728f773036f98c59c1ebd2"

URI_aarch64_texlive-ttfutils = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ttfutils-20240311-7.el10_0.aarch64.rpm;name=aarch64_texlive-ttfutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ttfutils}"
SRC_URI[aarch64_texlive-ttfutils.sha256sum] = "c31313164d51f874c28cb136baa9ebce7e7bd27de76a0d9e5c8290e2fc492616"

URI_aarch64_texlive-units = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-units-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-units;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-units}"
SRC_URI[aarch64_texlive-units.sha256sum] = "9c18efb72926bed8ba0ae2e63fb37e41749db14476a949958f42439459db6e52"

URI_aarch64_texlive-uplatex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uplatex-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-uplatex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uplatex}"
SRC_URI[aarch64_texlive-uplatex.sha256sum] = "2fca921f419b04656931bb0714ad62ca026328d3ae4d1560a9899288cdc629f9"

URI_aarch64_texlive-uptex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uptex-20240311-7.el10_0.aarch64.rpm;name=aarch64_texlive-uptex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uptex}"
SRC_URI[aarch64_texlive-uptex.sha256sum] = "d7e9f5c86d0181752cd5927dd2fba0f8d1f130d1cd693af0c2e60835de9322a6"

URI_aarch64_texlive-uptex-base = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uptex-base-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-uptex-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uptex-base}"
SRC_URI[aarch64_texlive-uptex-base.sha256sum] = "a75ae4a3eb67f6b25bd755d5e22ce33c203dbdf0696e961ac69c76362093c4ae"

URI_aarch64_texlive-uptex-fonts = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uptex-fonts-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-uptex-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uptex-fonts}"
SRC_URI[aarch64_texlive-uptex-fonts.sha256sum] = "4abd0d8b650a778e2680d218f7b92e292e466a2c27ca4a3af4651f1f76df9e23"

URI_aarch64_texlive-web = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-web-20240311-7.el10_0.aarch64.rpm;name=aarch64_texlive-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-web}"
SRC_URI[aarch64_texlive-web.sha256sum] = "9294486931feaf981e8dd73e7c154ab5089dee038191abdc2ca6971294797f64"

URI_aarch64_texlive-xcjk2uni = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xcjk2uni-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-xcjk2uni;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xcjk2uni}"
SRC_URI[aarch64_texlive-xcjk2uni.sha256sum] = "22535f396d79daaa6435a5b08082df72098c45c2035d4f68207cbd2160e273c7"

URI_aarch64_texlive-xecjk = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xecjk-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-xecjk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xecjk}"
SRC_URI[aarch64_texlive-xecjk.sha256sum] = "5978fdde380a2a569d05ffd9a14453c57d9757701c790715849443718ede136c"

URI_aarch64_texlive-xpinyin = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xpinyin-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-xpinyin;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xpinyin}"
SRC_URI[aarch64_texlive-xpinyin.sha256sum] = "a341f6f6513f63280c7f090f65a7bd09dfaffb9f1d902e5c83f2bd6da77afb04"

URI_aarch64_texlive-zhmetrics = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-zhmetrics-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-zhmetrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zhmetrics}"
SRC_URI[aarch64_texlive-zhmetrics.sha256sum] = "3c32547983d5117c3f2b7dd8ba120856719ed812265aa53aeeb67ea32eaab6b1"

URI_aarch64_texlive-zhmetrics-uptex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-zhmetrics-uptex-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-zhmetrics-uptex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zhmetrics-uptex}"
SRC_URI[aarch64_texlive-zhmetrics-uptex.sha256sum] = "087637abc5c1efc5a16e1a2230c91d9671cab18d230ad67e3680abd426e3ada6"

URI_aarch64_texlive-zhnumber = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-zhnumber-20240311-7.el10_0.noarch.rpm;name=aarch64_texlive-zhnumber;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zhnumber}"
SRC_URI[aarch64_texlive-zhnumber.sha256sum] = "ccb5bfac71f22518d67ea0089fbaae9e8c579afb5e5703b2d4d1efc847d0e135"

RDEPENDS:texlive-adobemapping = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ascmac = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-atenddvi = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-auto-pst-pdf = " \
 texlive-base \
 texlive-ifplatform \
 texlive-iftex \
 texlive-kpathsea \
 texlive-xkeyval \
 "
RDEPENDS:texlive-babel-french = " \
 texlive-base \
 texlive-carlisle \
 texlive-graphics \
 texlive-kpathsea \
 texlive-luatexbase \
 "
RDEPENDS:texlive-babel-german = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-bibunits = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-boondox = " \
 texlive-base \
 texlive-kpathsea \
 texlive-xkeyval \
 "
RDEPENDS:texlive-chemformula = " \
 texlive-amsmath \
 texlive-base \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-pgf \
 texlive-units \
 texlive-xfrac \
 "
RDEPENDS:texlive-chemgreek = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "
RDEPENDS:texlive-chktex = " \
 bash \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-cjk = " \
 texlive-arphic \
 texlive-base \
 texlive-cns \
 texlive-garuda-c90 \
 texlive-graphics \
 texlive-iftex \
 texlive-kpathsea \
 texlive-norasi-c90 \
 texlive-uhc \
 texlive-ulem \
 texlive-wadalab \
 virtual/tex_fontenc.sty_ \
 virtual/tex_inputenc.sty_ \
 "
RDEPENDS:texlive-cjkpunct = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-convbkmk = " \
 ruby \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-ctex = " \
 texlive-adobemapping \
 texlive-atbegshi \
 texlive-base \
 texlive-beamer \
 texlive-cjk \
 texlive-cjkpunct \
 texlive-count1to \
 texlive-ctex \
 texlive-ec \
 texlive-epstopdf-pkg \
 texlive-etoolbox \
 texlive-everyhook \
 texlive-everysel \
 texlive-fancyhdr \
 texlive-fandol \
 texlive-fontspec \
 texlive-hyperref \
 texlive-iftex \
 texlive-infwarerr \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex \
 texlive-ltxcmds \
 texlive-luatexja \
 texlive-mptopdf \
 texlive-multitoc \
 texlive-pdftexcmds \
 texlive-platex-tools \
 texlive-svn-prov \
 texlive-tipa \
 texlive-tools \
 texlive-ttfutils \
 texlive-ulem \
 texlive-uplatex \
 texlive-xcjk2uni \
 texlive-xecjk \
 texlive-xetex \
 texlive-xkeyval \
 texlive-xpinyin \
 texlive-xunicode \
 texlive-zhmetrics \
 texlive-zhmetrics-uptex \
 texlive-zhnumber \
 virtual/tex_fix-cm.sty_ \
 "
RDEPENDS:texlive-ctie = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-cweb = " \
 glibc \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-Pod-Usage \
 perl-libs \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-emulateapj = " \
 texlive-amsfonts \
 texlive-base \
 texlive-epsf \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tools \
 virtual/tex_latexsym.sty_ \
 "
RDEPENDS:texlive-everyhook = " \
 texlive-base \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-svn-prov \
 "
RDEPENDS:texlive-fandol = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-filemod = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pdftexcmds \
 "
RDEPENDS:texlive-fltpoint = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fontaxes = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-german = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-germbib = " \
 texlive-base \
 texlive-german \
 texlive-kpathsea \
 "
RDEPENDS:texlive-gincltex = " \
 texlive-adjustbox \
 texlive-base \
 texlive-kpathsea \
 texlive-svn-prov \
 "
RDEPENDS:texlive-glossaries-english = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-glossaries-french = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-glossaries-german = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hyphen-german = " \
 bash \
 texlive-base \
 texlive-dehyph \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-kpathsea \
 virtual/coreutils \
 "
RDEPENDS:texlive-ieeetran = " \
 texlive-base \
 texlive-kpathsea \
 texlive-newtx \
 "
RDEPENDS:texlive-ipaex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-japanese-otf = " \
 texlive-base \
 texlive-japanese-otf \
 texlive-kpathsea \
 "
RDEPENDS:texlive-kantlipsum = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "
RDEPENDS:texlive-lacheck = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latex-base-dev = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latex-firstaid-dev = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lipsum = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-listingsutf8 = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-luatexja = " \
 texlive-ascmac \
 texlive-atbegshi \
 texlive-base \
 texlive-everyhook \
 texlive-everysel \
 texlive-filehook \
 texlive-fontspec \
 texlive-footmisc \
 texlive-iftex \
 texlive-infwarerr \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-listings \
 texlive-ltxcmds \
 texlive-luaotfload \
 texlive-luatexbase \
 texlive-luatexja \
 texlive-pdftexcmds \
 texlive-sttools \
 texlive-unicode-math \
 texlive-xkeyval \
 texlive-xunicode \
 "
RDEPENDS:texlive-mdframed = " \
 texlive-amsmath \
 texlive-base \
 texlive-bera \
 texlive-booktabs \
 texlive-csquotes \
 texlive-enumitem \
 texlive-eso-pic \
 texlive-etoolbox \
 texlive-fontspec \
 texlive-geometry \
 texlive-graphics \
 texlive-hypdoc \
 texlive-iftex \
 texlive-kantlipsum \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-lipsum \
 texlive-listings \
 texlive-microtype \
 texlive-needspace \
 texlive-ntheorem \
 texlive-pgf \
 texlive-selinput \
 texlive-tools \
 texlive-xcolor \
 texlive-zref \
 virtual/tex_fontenc.sty_ \
 "
RDEPENDS:texlive-media9 = " \
 texlive-atbegshi \
 texlive-atenddvi \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-ocgx2 \
 texlive-pdftexcmds \
 texlive-pgf \
 "
RDEPENDS:texlive-mhchem = " \
 texlive-amsmath \
 texlive-babel \
 texlive-base \
 texlive-chemgreek \
 texlive-graphics \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-oberdiek \
 texlive-pgf \
 texlive-tools \
 virtual/tex_ifthen.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-newtx = " \
 texlive-amsmath \
 texlive-base \
 texlive-boondox \
 texlive-fontaxes \
 texlive-iftex \
 texlive-kastrup \
 texlive-kpathsea \
 texlive-xkeyval \
 virtual/tex_fontenc.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-nomencl = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ntheorem = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-ocgx2 = " \
 texlive-atenddvi \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-l3packages \
 texlive-media9 \
 texlive-pgf \
 "
RDEPENDS:texlive-pgfplots = " \
 bash \
 texlive-base \
 texlive-graphics \
 texlive-hyperref \
 texlive-kpathsea \
 texlive-listings \
 texlive-luatex \
 texlive-luatexbase \
 texlive-pgf \
 texlive-tools \
 "
RDEPENDS:texlive-picinpar = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-picture = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-platex = " \
 texlive-atbegshi \
 texlive-atveryend \
 texlive-babel \
 texlive-base \
 texlive-cm \
 texlive-everyshi \
 texlive-firstaid \
 texlive-hyphen-base \
 texlive-kpathsea \
 texlive-l3backend \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex-base-dev \
 texlive-latex-firstaid-dev \
 texlive-latex-fonts \
 texlive-ptex \
 texlive-ptex-fonts \
 texlive-tex-ini-files \
 texlive-unicode-data \
 virtual/texlive-latex \
 "
RDEPENDS:texlive-platex-tools = " \
 texlive-base \
 texlive-kpathsea \
 texlive-platex \
 "
RDEPENDS:texlive-ps2eps = " \
 glibc \
 perl-Getopt-Long \
 perl-POSIX \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-ptex = " \
 cairo \
 glibc \
 gmp \
 libpng \
 mpfr \
 pixman \
 texlive-adobemapping \
 texlive-base \
 texlive-cm \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-ipaex \
 texlive-japanese-otf \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-ptex-base \
 texlive-ptex-fonts \
 texlive-tex \
 virtual/coreutils \
 virtual/tex_oldlfont.sty_ \
 virtual/tex_shortvrb.sty_ \
 virtual/texlive-latex \
 zlib-ng-compat \
 "
RDEPENDS:texlive-ptex-base = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ptex-fonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-revtex4 = " \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 texlive-natbib \
 texlive-url \
 "
RDEPENDS:texlive-selinput = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sidecap = " \
 texlive-base \
 texlive-kpathsea \
 texlive-ragged2e \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-siunitx = " \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-tools \
 texlive-translator \
 "
RDEPENDS:texlive-standalone = " \
 texlive-adjustbox \
 texlive-base \
 texlive-currfile \
 texlive-filemod \
 texlive-gincltex \
 texlive-iftex \
 texlive-kpathsea \
 texlive-multido \
 texlive-pgf \
 texlive-pstricks \
 texlive-varwidth \
 texlive-xkeyval \
 "
RDEPENDS:texlive-sttools = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-supertabular = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-tcolorbox = " \
 texlive-base \
 texlive-environ \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-listingsutf8 \
 texlive-pdfcol \
 texlive-pgf \
 texlive-tikzfill \
 texlive-tools \
 "
RDEPENDS:texlive-tie = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-tikzfill = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ttfutils = " \
 freetype \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-units = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-uplatex = " \
 texlive-atbegshi \
 texlive-atveryend \
 texlive-babel \
 texlive-base \
 texlive-cm \
 texlive-everyshi \
 texlive-firstaid \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-kpathsea \
 texlive-l3backend \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex-base-dev \
 texlive-latex-firstaid-dev \
 texlive-latex-fonts \
 texlive-platex \
 texlive-tex-ini-files \
 texlive-unicode-data \
 texlive-uptex \
 texlive-uptex-fonts \
 virtual/texlive-latex \
 "
RDEPENDS:texlive-uptex = " \
 cairo \
 glibc \
 gmp \
 libicu \
 libpng \
 mpfr \
 pixman \
 texlive-base \
 texlive-convbkmk \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-ipaex \
 texlive-japanese-otf \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-ptex-base \
 texlive-uptex-base \
 texlive-uptex-fonts \
 zlib-ng-compat \
 "
RDEPENDS:texlive-uptex-base = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-uptex-fonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-web = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-xcjk2uni = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 "
RDEPENDS:texlive-xecjk = " \
 texlive-base \
 texlive-cjk \
 texlive-environ \
 texlive-fontspec \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-listings \
 texlive-tools \
 texlive-ulem \
 texlive-xunicode \
 "
RDEPENDS:texlive-xpinyin = " \
 texlive-base \
 texlive-cjk \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-xcjk2uni \
 texlive-xecjk \
 "
RDEPENDS:texlive-zhmetrics = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-zhmetrics-uptex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-zhnumber = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/tex_alltt.sty_ rpm/virtual/tex_article.cls_ rpm/virtual/tex_doc.sty_ rpm/virtual/tex_exscale.sty_ rpm/virtual/tex_fix-cm.sty_ rpm/virtual/tex_fixltx2e.sty_ rpm/virtual/tex_flafter.sty_ rpm/virtual/tex_fontenc.sty_ rpm/virtual/tex_ifthen.sty_ rpm/virtual/tex_inputenc.sty_ rpm/virtual/tex_latexsym.sty_ rpm/virtual/tex_makeidx.sty_ rpm/virtual/tex_oldlfont.sty_ rpm/virtual/tex_shortvrb.sty_ rpm/virtual/tex_t1cmr.fd_ rpm/virtual/tex_textcomp.sty_"

PROVIDES:append:aarch64 = " rpm/virtual/tex_alltt.sty_ rpm/virtual/tex_article.cls_ rpm/virtual/tex_doc.sty_ rpm/virtual/tex_exscale.sty_ rpm/virtual/tex_fix-cm.sty_ rpm/virtual/tex_fixltx2e.sty_ rpm/virtual/tex_flafter.sty_ rpm/virtual/tex_fontenc.sty_ rpm/virtual/tex_ifthen.sty_ rpm/virtual/tex_inputenc.sty_ rpm/virtual/tex_latexsym.sty_ rpm/virtual/tex_makeidx.sty_ rpm/virtual/tex_oldlfont.sty_ rpm/virtual/tex_shortvrb.sty_ rpm/virtual/tex_t1cmr.fd_ rpm/virtual/tex_textcomp.sty_"
