# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trycmd"
PV = "1.1.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-trycmd+color-auto-devel \
 rust-trycmd+color-devel \
 rust-trycmd+debug-devel \
 rust-trycmd+default-devel \
 rust-trycmd+diff-devel \
 rust-trycmd+escargot-devel \
 rust-trycmd+examples-devel \
 rust-trycmd+filesystem-devel \
 rust-trycmd+schema-devel \
 rust-trycmd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-trycmd-1.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26dca2c4a33497f7587cdceedd454b9226d74d95ffc033ece8203cfe387158f9"

URI_x86_64_v2_rust-trycmd+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+color-auto-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+color-auto-devel}"
SRC_URI[x86_64_v2_rust-trycmd+color-auto-devel.sha256sum] = "f2d93efa9aaae1ecae9dce8f0975c0fda9348e82c70578ec85bc50b3d512da06"

URI_x86_64_v2_rust-trycmd+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+color-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+color-devel}"
SRC_URI[x86_64_v2_rust-trycmd+color-devel.sha256sum] = "fc1be2b0da6796fe1bd839e67670cc3f7ac7afc8b9e69481581f5880b60e5b9b"

URI_x86_64_v2_rust-trycmd+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+debug-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+debug-devel}"
SRC_URI[x86_64_v2_rust-trycmd+debug-devel.sha256sum] = "8e7543c0185ace687fda4fc1c1c7000a87f0d323445df97e6c689d73b4046ac7"

URI_x86_64_v2_rust-trycmd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+default-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+default-devel}"
SRC_URI[x86_64_v2_rust-trycmd+default-devel.sha256sum] = "9d541140c0a4d53556391d915eba0eeedbf363fd299fd08bc91762d7343c083c"

URI_x86_64_v2_rust-trycmd+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+diff-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+diff-devel}"
SRC_URI[x86_64_v2_rust-trycmd+diff-devel.sha256sum] = "9300f611d14f3e36e16bf69ce56ae28539a4ee08a121b9a58c8f20e7f93b1dc8"

URI_x86_64_v2_rust-trycmd+escargot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+escargot-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+escargot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+escargot-devel}"
SRC_URI[x86_64_v2_rust-trycmd+escargot-devel.sha256sum] = "6ef21201d4b6d330b8eb066427b3088397eaa4850eb78f00f928ad598af2faac"

URI_x86_64_v2_rust-trycmd+examples-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+examples-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+examples-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+examples-devel}"
SRC_URI[x86_64_v2_rust-trycmd+examples-devel.sha256sum] = "57fd451cfdea722fb98246ce1bee5986544a6ea2b292b10d39947bb2d4f45284"

URI_x86_64_v2_rust-trycmd+filesystem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+filesystem-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+filesystem-devel}"
SRC_URI[x86_64_v2_rust-trycmd+filesystem-devel.sha256sum] = "bc2b5d9358fd364e2d76900ed1a00e148bebbac9461aa231d408e8aa973a41bd"

URI_x86_64_v2_rust-trycmd+schema-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+schema-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+schema-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+schema-devel}"
SRC_URI[x86_64_v2_rust-trycmd+schema-devel.sha256sum] = "6d7a883c878db21f4b8333b4de581f970029d61cea5150496286c7786cad58f4"

URI_x86_64_v2_rust-trycmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd-devel}"
SRC_URI[x86_64_v2_rust-trycmd-devel.sha256sum] = "81840a48d1b9106a43296e8abdabe6d6af9db8539b15799f7f43eb6397cae2bb"

URI_aarch64_rust-trycmd+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+color-auto-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+color-auto-devel}"
SRC_URI[aarch64_rust-trycmd+color-auto-devel.sha256sum] = "3bbf9f79584623dab1bbfffa0d4bc8fed8636110cd510e13ed70ced77f47d924"

URI_aarch64_rust-trycmd+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+color-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+color-devel}"
SRC_URI[aarch64_rust-trycmd+color-devel.sha256sum] = "b2a58dda6b873d45da8ab9b5da6e43e7eb6489a4f015abf77d3f75825413040e"

URI_aarch64_rust-trycmd+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+debug-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+debug-devel}"
SRC_URI[aarch64_rust-trycmd+debug-devel.sha256sum] = "043da0377ffaecbfaf8dff8d74bebecaac59fdb84d0241c36bba8777203b810d"

URI_aarch64_rust-trycmd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+default-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+default-devel}"
SRC_URI[aarch64_rust-trycmd+default-devel.sha256sum] = "68f1a867a75e042328cd97d4b143180d56c22f69c53dab86edfbb434aebf70eb"

URI_aarch64_rust-trycmd+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+diff-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+diff-devel}"
SRC_URI[aarch64_rust-trycmd+diff-devel.sha256sum] = "27014b65d2e70ef0e6c33efd2ff1aab4bdac732539170f52c21c03fd2e016bf1"

URI_aarch64_rust-trycmd+escargot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+escargot-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd+escargot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+escargot-devel}"
SRC_URI[aarch64_rust-trycmd+escargot-devel.sha256sum] = "e591d506cf6200bb45469290a0cb884737c409a61dd19943ca1062d8ddf7c626"

URI_aarch64_rust-trycmd+examples-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+examples-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd+examples-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+examples-devel}"
SRC_URI[aarch64_rust-trycmd+examples-devel.sha256sum] = "e7d9ce68baba6d50295ace95fc0e095847ddcb0c988139132dd3f579361bb82f"

URI_aarch64_rust-trycmd+filesystem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+filesystem-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd+filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+filesystem-devel}"
SRC_URI[aarch64_rust-trycmd+filesystem-devel.sha256sum] = "0929ac4f17bd90e5a451691a10c8b823ac9ead9b13bdc1a4759ce8de07d92023"

URI_aarch64_rust-trycmd+schema-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+schema-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd+schema-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+schema-devel}"
SRC_URI[aarch64_rust-trycmd+schema-devel.sha256sum] = "ebfc2253cd5cce1894d24a7106ea984336891ed870a486c2f298bd34525beb33"

URI_aarch64_rust-trycmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-trycmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd-devel}"
SRC_URI[aarch64_rust-trycmd-devel.sha256sum] = "b270498251cefedf7c3975c9cdbf6d0202f517020401eaf1d41ffc2245b9f512"

RDEPENDS:rust-trycmd+color-auto-devel = " \
 cargo \
 rust-snapbox+color-auto-devel \
 rust-trycmd+color-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-snapbox+color-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+debug-devel = " \
 cargo \
 rust-snapbox+debug-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+default-devel = " \
 cargo \
 rust-trycmd+color-auto-devel \
 rust-trycmd+diff-devel \
 rust-trycmd+filesystem-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+diff-devel = " \
 cargo \
 rust-snapbox+diff-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+escargot-devel = " \
 cargo \
 rust-escargot+default-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+examples-devel = " \
 cargo \
 rust-snapbox+examples-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+filesystem-devel = " \
 cargo \
 rust-snapbox+dir-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+schema-devel = " \
 cargo \
 rust-schemars0.8+default-devel \
 rust-schemars0.8+preserve_order-devel \
 rust-serde_json+default-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd-devel = " \
 cargo \
 rust \
 rust-automod+default-devel \
 rust-glob+default-devel \
 rust-humantime+default-devel \
 rust-humantime-serde+default-devel \
 rust-rayon+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-shlex+default-devel \
 rust-snapbox+cmd-devel \
 rust-snapbox-devel \
 virtual/crate_toml_edit/default__ge_0.23.5_with_crate_toml_edit/default__lt_0.25.0~ \
 virtual/crate_toml_edit/serde__ge_0.23.5_with_crate_toml_edit/serde__lt_0.25.0~ \
 "
