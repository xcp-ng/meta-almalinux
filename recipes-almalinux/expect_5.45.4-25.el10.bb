# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "expect"
PV = "5.45.4"
PR = "25.el10"
PACKAGES = " \
 expect \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/expect-5.45.4-25.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "566537e993f0603a013e20fe709ab6c30f0a88e090b00540cb756c4ed7d1e377"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/expect-5.45.4-25.el10.x86_64_v2.rpm;name=x86_64_v2_expect;unpack=0"
SRC_URI[x86_64_v2_expect.sha256sum] = "d606f0bd7b28984e132562971f0f29a094ade44b34be401820da2c8f19cbbc25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/expect-5.45.4-25.el10.aarch64.rpm;name=aarch64_expect;unpack=0"
SRC_URI[aarch64_expect.sha256sum] = "5ebec9c28f8bfb9f008b053ea65e08d8a73420f1e5968fea368d07cfb0199ade"

RDEPENDS:expect = " \
 bash \
 glibc \
 tcl \
 "
