# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "valkey"
PV = "8.0.6"
PR = "1.el10_0"
PACKAGES = " \
 valkey \
 valkey-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/valkey-8.0.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dff164439671cf0b111b915001b7132f35f844a0d79eecaed47c09412805cb86"

URI_x86_64_v2_valkey = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valkey-8.0.6-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_valkey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valkey}"
SRC_URI[x86_64_v2_valkey.sha256sum] = "4f7d942d44cfa0799193559473d58149a80d3e3f97992503a6648c6d99ffafcf"

URI_x86_64_v2_valkey-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valkey-devel-8.0.6-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_valkey-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valkey-devel}"
SRC_URI[x86_64_v2_valkey-devel.sha256sum] = "8110b906fee8f14466c9769da98e752c3f7b8d67a40cc0051d3d9a08f476ec80"

URI_aarch64_valkey = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valkey-8.0.6-1.el10_0.aarch64.rpm;name=aarch64_valkey;unpack=0"
SRC_URI:append = " ${URI_aarch64_valkey}"
SRC_URI[aarch64_valkey.sha256sum] = "92d19310a4487f749dae02adab74d79a0239b20ab4ca9b38e5d78faee9b870d4"

URI_aarch64_valkey-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valkey-devel-8.0.6-1.el10_0.aarch64.rpm;name=aarch64_valkey-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_valkey-devel}"
SRC_URI[aarch64_valkey-devel.sha256sum] = "268b81e3f3d583359f6127d0eb36d86eca1255867eb283f77da8f09f92cda2aa"

RDEPENDS:valkey = " \
 bash \
 glibc \
 logrotate \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:valkey-devel = " \
 "
