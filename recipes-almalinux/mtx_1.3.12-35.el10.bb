# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mtx"
PV = "1.3.12"
PR = "35.el10"
PACKAGES = " \
 mtx \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mtx-1.3.12-35.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "93d2d652128f432a7c0338f0132865b235bc193e8dcc83bf5a61c6c8c1064fa6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mtx-1.3.12-35.el10.x86_64_v2.rpm;name=x86_64_v2_mtx;unpack=0"
SRC_URI[x86_64_v2_mtx.sha256sum] = "a6dde685c291580c334908fe006160a69fd668d770254a52d07fe53a2f9a5a36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mtx-1.3.12-35.el10.aarch64.rpm;name=aarch64_mtx;unpack=0"
SRC_URI[aarch64_mtx.sha256sum] = "9a6f0ece329fc2f684dc0ee960e54c5e0e45c3bcca118c5769de1fc5eddd8f5c"

RDEPENDS:mtx = " \
 glibc \
 "
