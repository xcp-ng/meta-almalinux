# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-SVGPDF"
PV = "0.090"
PR = "2.el10_0"
PACKAGES = " \
 perl-SVGPDF \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-SVGPDF-0.090-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6dac73adf578d189e552f58e62fd6d4044ba1415245f79aa3a2e3a575d54b3ae"

URI_x86_64_v2_perl-SVGPDF = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SVGPDF-0.090-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SVGPDF;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SVGPDF}"
SRC_URI[x86_64_v2_perl-SVGPDF.sha256sum] = "718be73278723fc8504996ca16f5aadc5c5ad2033c53c6ea7730ded626685f1b"

URI_aarch64_perl-SVGPDF = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SVGPDF-0.090-2.el10_0.noarch.rpm;name=aarch64_perl-SVGPDF;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SVGPDF}"
SRC_URI[aarch64_perl-SVGPDF.sha256sum] = "605647fe3eac18c52fe8c6e6c96623d118a755187fadbe9b8e926b1e02efcc3f"

RDEPENDS:perl-SVGPDF = " \
 perl-Carp \
 perl-Exporter \
 perl-File-LoadLines \
 perl-File-Temp \
 perl-MIME-Base64 \
 perl-Math-Complex \
 perl-Object-Pad \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Text-ParseWords \
 perl-libs \
 "
