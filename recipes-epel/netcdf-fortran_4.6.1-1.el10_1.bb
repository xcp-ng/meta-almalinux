# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netcdf-fortran"
PV = "4.6.1"
PR = "1.el10_1"
PACKAGES = " \
 netcdf-fortran \
 netcdf-fortran-devel \
 netcdf-fortran-mpich \
 netcdf-fortran-mpich-devel \
 netcdf-fortran-mpich-static \
 netcdf-fortran-openmpi \
 netcdf-fortran-openmpi-devel \
 netcdf-fortran-openmpi-static \
 netcdf-fortran-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netcdf-fortran-4.6.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cf9fc82a91614914e0f79e737327ae3f0a8b0d48d6a7f24fa5450fcf9c15f4b"

URI_x86_64_v2_netcdf-fortran = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-4.6.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran}"
SRC_URI[x86_64_v2_netcdf-fortran.sha256sum] = "e673045f691dc8ac18bc6faae5e8f00bfeb21c2b5839fd12a60f138b81cc54b2"

URI_x86_64_v2_netcdf-fortran-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-devel-4.6.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-devel}"
SRC_URI[x86_64_v2_netcdf-fortran-devel.sha256sum] = "921e8517d87374dee35a28f8beb44eb5651f694e78640079b26352c176475ce2"

URI_x86_64_v2_netcdf-fortran-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-mpich-4.6.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-mpich}"
SRC_URI[x86_64_v2_netcdf-fortran-mpich.sha256sum] = "d5b2a5c624ab7972a3b05f7757d3ab38e7cded8fd9f763abdc29496054899270"

URI_x86_64_v2_netcdf-fortran-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-mpich-devel-4.6.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-mpich-devel}"
SRC_URI[x86_64_v2_netcdf-fortran-mpich-devel.sha256sum] = "2125ba0e8fe8cfea4ce5ffe97002d194acc8e611a03e49163160c078e8321a58"

URI_x86_64_v2_netcdf-fortran-mpich-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-mpich-static-4.6.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-mpich-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-mpich-static}"
SRC_URI[x86_64_v2_netcdf-fortran-mpich-static.sha256sum] = "59e59077a5e539627a300fae693848f4b3636b89f5a6ee1815714ef443f7604e"

URI_x86_64_v2_netcdf-fortran-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-openmpi-4.6.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-openmpi}"
SRC_URI[x86_64_v2_netcdf-fortran-openmpi.sha256sum] = "bed2d882fadbd3fb6db7c4d6985fa652c874c53450913e27d0c989eb5bf21008"

URI_x86_64_v2_netcdf-fortran-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-openmpi-devel-4.6.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-openmpi-devel}"
SRC_URI[x86_64_v2_netcdf-fortran-openmpi-devel.sha256sum] = "d1120ab7cf0d63f300a518d470b11413538395b58261b284524a02078c44c538"

URI_x86_64_v2_netcdf-fortran-openmpi-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-openmpi-static-4.6.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-openmpi-static}"
SRC_URI[x86_64_v2_netcdf-fortran-openmpi-static.sha256sum] = "40f250b2d18a2c9b654b681078a33482aea6dbe105b015806d11c3d0419d4a65"

URI_x86_64_v2_netcdf-fortran-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-static-4.6.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-static}"
SRC_URI[x86_64_v2_netcdf-fortran-static.sha256sum] = "ecc18930ac95f6d800823ce9f950abbaeda26f5cc1727f4113d6128234d1a632"

URI_aarch64_netcdf-fortran = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-4.6.1-1.el10_1.aarch64.rpm;name=aarch64_netcdf-fortran;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran}"
SRC_URI[aarch64_netcdf-fortran.sha256sum] = "50d6eea56332fc7cb48f51a5f8569f31fcdc355a6dca15ab9d7b3bf94694c216"

URI_aarch64_netcdf-fortran-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-devel-4.6.1-1.el10_1.aarch64.rpm;name=aarch64_netcdf-fortran-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-devel}"
SRC_URI[aarch64_netcdf-fortran-devel.sha256sum] = "cab7cbbf74cd26bda2202a45db51e55ae83bb191b2d9e746c43eae9322e4189b"

URI_aarch64_netcdf-fortran-mpich = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-mpich-4.6.1-1.el10_1.aarch64.rpm;name=aarch64_netcdf-fortran-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-mpich}"
SRC_URI[aarch64_netcdf-fortran-mpich.sha256sum] = "381cee2f1fdb8444178691b6b9383605ded8d0fd2fd10ee509a5a2e42e3444e0"

URI_aarch64_netcdf-fortran-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-mpich-devel-4.6.1-1.el10_1.aarch64.rpm;name=aarch64_netcdf-fortran-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-mpich-devel}"
SRC_URI[aarch64_netcdf-fortran-mpich-devel.sha256sum] = "062e639b992a9d9d54075c3374469bc71f1228925d4337bb903f6e0d064c8f39"

URI_aarch64_netcdf-fortran-mpich-static = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-mpich-static-4.6.1-1.el10_1.aarch64.rpm;name=aarch64_netcdf-fortran-mpich-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-mpich-static}"
SRC_URI[aarch64_netcdf-fortran-mpich-static.sha256sum] = "57bcbde01029fa1fd4340c9112cd25346294043ea2fba1c332efe046024fd03c"

URI_aarch64_netcdf-fortran-openmpi = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-openmpi-4.6.1-1.el10_1.aarch64.rpm;name=aarch64_netcdf-fortran-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-openmpi}"
SRC_URI[aarch64_netcdf-fortran-openmpi.sha256sum] = "3aeee9d9a936d3e0c93475ce9f4d04da750a0010d119d471fd8e87b3336ba5d9"

URI_aarch64_netcdf-fortran-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-openmpi-devel-4.6.1-1.el10_1.aarch64.rpm;name=aarch64_netcdf-fortran-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-openmpi-devel}"
SRC_URI[aarch64_netcdf-fortran-openmpi-devel.sha256sum] = "36b9734c7dd284a8833637547ded13ecf2d869d0144c8f2bde0cecabd07a211c"

URI_aarch64_netcdf-fortran-openmpi-static = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-openmpi-static-4.6.1-1.el10_1.aarch64.rpm;name=aarch64_netcdf-fortran-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-openmpi-static}"
SRC_URI[aarch64_netcdf-fortran-openmpi-static.sha256sum] = "ca8915cd15f81ec7c57240c49da549e7d02f7a5fd0ce8ffdcebd4db0d4b2fabc"

URI_aarch64_netcdf-fortran-static = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-static-4.6.1-1.el10_1.aarch64.rpm;name=aarch64_netcdf-fortran-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-static}"
SRC_URI[aarch64_netcdf-fortran-static.sha256sum] = "936f9e8f6877896a8cb917e31c1aa636259300e01b6f460a331dd4982c31a3ea"

RDEPENDS:netcdf-fortran:x86_64_v2 = " \
 glibc \
 libgcc \
 libgfortran \
 netcdf \
"
RDEPENDS:netcdf-fortran:aarch64 = " \
 glibc \
 libgfortran \
 netcdf \
"
RDEPENDS:netcdf-fortran-devel = " \
 bash \
 gcc-gfortran \
 netcdf-devel \
 netcdf-fortran \
 pkgconf-pkg-config \
 "
RDEPENDS:netcdf-fortran-mpich:x86_64_v2 = " \
 glibc \
 libgcc \
 libgfortran \
 netcdf-mpich \
"
RDEPENDS:netcdf-fortran-mpich:aarch64 = " \
 glibc \
 libgfortran \
 netcdf-mpich \
"
RDEPENDS:netcdf-fortran-mpich-devel = " \
 bash \
 gcc-gfortran \
 libcurl-devel \
 netcdf-fortran-mpich \
 netcdf-mpich-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:netcdf-fortran-mpich-static = " \
 netcdf-fortran-mpich-devel \
 "
RDEPENDS:netcdf-fortran-openmpi:x86_64_v2 = " \
 glibc \
 libgcc \
 libgfortran \
 netcdf-openmpi \
"
RDEPENDS:netcdf-fortran-openmpi:aarch64 = " \
 glibc \
 libgfortran \
 netcdf-openmpi \
"
RDEPENDS:netcdf-fortran-openmpi-devel = " \
 bash \
 gcc-gfortran \
 libcurl-devel \
 netcdf-fortran-openmpi \
 netcdf-openmpi-devel \
 openmpi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:netcdf-fortran-openmpi-static = " \
 netcdf-fortran-openmpi-devel \
 "
RDEPENDS:netcdf-fortran-static = " \
 netcdf-fortran-devel \
 "
