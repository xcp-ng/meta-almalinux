# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "migraphx"
PV = "7.1.1"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 migraphx \
 migraphx-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/m/migraphx-7.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8d496b0555848afee6bbdfbe6871329b12e8afa3e0f12843893fa096bc0ed04"

URI_x86_64_v2_migraphx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/migraphx-7.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_migraphx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_migraphx}"
SRC_URI[x86_64_v2_migraphx.sha256sum] = "f61fd8b70345fa9246aeec85a4f649b7c38d8eec442a84334ae4f9d4f30e7ece"

URI_x86_64_v2_migraphx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/migraphx-devel-7.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_migraphx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_migraphx-devel}"
SRC_URI[x86_64_v2_migraphx-devel.sha256sum] = "c47478b089a2318f4b06e1124585a85a93460abf7dca7a739082249698c608c8"

RDEPENDS:migraphx = " \
 glibc \
 libgcc \
 libstdc++ \
 miopen \
 protobuf \
 rocblas \
 rocm-hip \
 sqlite-libs \
 "
RDEPENDS:migraphx-devel = " \
 cmake-filesystem \
 migraphx \
 "
