# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap"
PV = "4.6.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+debug-devel \
 rust-clap+default-devel \
 rust-clap+deprecated-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+error-context-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+string-devel \
 rust-clap+suggestions-devel \
 rust-clap+unicode-devel \
 rust-clap+unstable-doc-devel \
 rust-clap+unstable-ext-devel \
 rust-clap+unstable-markdown-devel \
 rust-clap+unstable-styles-devel \
 rust-clap+unstable-v5-devel \
 rust-clap+usage-devel \
 rust-clap+wrap_help-devel \
 rust-clap-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-clap-4.6.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "832a8e976c3fa5fe9936e6df05d60d0f4823d229baa5cf5c0fd5b0b2d518ea95"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+cargo-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+cargo-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+cargo-devel.sha256sum] = "204637f28485d1a81b30589fa12e352e0f3fd71e6ea728fdb23006192d89fd3e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+color-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+color-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+color-devel.sha256sum] = "daa939a8f222065c7fd5eb89c1a7168c486ef20b79d26d5c3fb1abce6ea55f01"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+debug-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+debug-devel.sha256sum] = "817521d76e07880c3237faff98817a44d12046e0c03fd8288f528f22eb5d0608"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+default-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+default-devel.sha256sum] = "ad93509d98446a98e0d3327081355d704d23965f8f43675704d444d85833f492"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+deprecated-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+deprecated-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+deprecated-devel.sha256sum] = "ac9d0c872ae15c8d29a2f3e7b7d46a8979d9ad6d39038ec482b3138df1dede4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+derive-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+derive-devel.sha256sum] = "6ac49c0a55408186b044b973e4ba69c2254092056e127b06a5e28073e94c53c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+env-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+env-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+env-devel.sha256sum] = "1c5fe1c31bd498df89231cf1f09b788196878f4e802cf3b4fda08b2a38cff5c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+error-context-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+error-context-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+error-context-devel.sha256sum] = "538b989816492ae74b81d71e49637a9845511b1cbe0ea9bcfaafb71837a01f8f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+help-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+help-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+help-devel.sha256sum] = "d1eb7cc152e57e5d70356f4e666e626e6e2615ed04ac1315f30a8597d9462877"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+std-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+std-devel.sha256sum] = "d75a1232127b328f12fb7853bf3ac25d39c7fffc3c1d3bf0b3616a5ce72e2e7e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+string-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+string-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+string-devel.sha256sum] = "7838c54fa5de6d35cd6b3a1d2419c906fc2c9291ef27cdb15473bbb6947858a4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+suggestions-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+suggestions-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+suggestions-devel.sha256sum] = "75800e0241331a1e22fa401ed76f8cf3c638b7c50fcb09026e9986b12506dbea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unicode-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unicode-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+unicode-devel.sha256sum] = "936b5afc2dddc1da9caa9b2f3d0402534d8dcc2de3c16df7f1ed30ac405e5406"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-doc-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-doc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+unstable-doc-devel.sha256sum] = "ffbe7ac1de63ec7dc96e09c54256ba00ab1170e75c78cd5095b0fea95a2f2d95"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-ext-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-ext-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+unstable-ext-devel.sha256sum] = "822a8a3c537ab15f40ff7cf1fd490dce3ef57fe8e000825666dde3604e145802"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-markdown-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-markdown-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+unstable-markdown-devel.sha256sum] = "4e9df3a38a9a11c69209275be17a6f82c2b1e8f5744853b02222c771b185518e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-styles-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-styles-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+unstable-styles-devel.sha256sum] = "1bc2360e1ae34078e65d8288b016ede4a670e0775f68d32e24d555d537bab2b9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-v5-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-v5-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+unstable-v5-devel.sha256sum] = "64c619cc4dc9f0b2ec44ba16d8bcf91ec0643dc378c59993031dc111af8f9be5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+usage-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+usage-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+usage-devel.sha256sum] = "867ad0e4a8cae5ae20f26def271624a348f033ed6c885d89203fa936f4a0b993"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+wrap_help-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+wrap_help-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap+wrap_help-devel.sha256sum] = "16ee8de5f0eca6ed21053bb74054583b9c61d7336f69b3324c373305b8dd048b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap-devel.sha256sum] = "1b27a2623f4291ccc788ea0aadad0052e089e4ac09b550b29016d32c4efec730"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+cargo-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+cargo-devel;unpack=0"
SRC_URI[aarch64_rust-clap+cargo-devel.sha256sum] = "af09704fc62c48e213d033f4bdba7fb72f3981b62ac62687048822f33c41037d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+color-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+color-devel;unpack=0"
SRC_URI[aarch64_rust-clap+color-devel.sha256sum] = "3c4af3cb5148a403646b1c01cbb6edce5deef67b94e87efc8571f22ea942396c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+debug-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+debug-devel;unpack=0"
SRC_URI[aarch64_rust-clap+debug-devel.sha256sum] = "6c6eb0ecbeb2f3f06bfd50bf5d8b1d96bd28ec01b5eae4ebe62c7a87f58e0aeb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+default-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+default-devel;unpack=0"
SRC_URI[aarch64_rust-clap+default-devel.sha256sum] = "4d012ba71c3b65df79ecb8b706df55590cee595992918df868bb1e391685c513"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+deprecated-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+deprecated-devel;unpack=0"
SRC_URI[aarch64_rust-clap+deprecated-devel.sha256sum] = "39ef5cd642e9741637bed81d35b150c7ff133cb71095432c6f0c701e6554b28f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+derive-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+derive-devel;unpack=0"
SRC_URI[aarch64_rust-clap+derive-devel.sha256sum] = "e640548b93a29a5acbc400849603aef81850c9d92bfc5700ed88ea880718a79b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+env-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+env-devel;unpack=0"
SRC_URI[aarch64_rust-clap+env-devel.sha256sum] = "76c7bf54ee170580671f35080cc4676a61d7a2607edd60acd71b64cf9c711a7d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+error-context-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+error-context-devel;unpack=0"
SRC_URI[aarch64_rust-clap+error-context-devel.sha256sum] = "b2b551cd4e5be65c95f70001bd1d31176755e27fbe10c235721c58fb276f6b4d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+help-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+help-devel;unpack=0"
SRC_URI[aarch64_rust-clap+help-devel.sha256sum] = "32b9c66d288fc1934707040a51bed96f65b3b39b30d673f7438208c48656295b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+std-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+std-devel;unpack=0"
SRC_URI[aarch64_rust-clap+std-devel.sha256sum] = "d17aacf6b8c214fe8796f71547cb8c1d49c6d85ee4e68b0af50d5fd2fc735c6c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+string-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+string-devel;unpack=0"
SRC_URI[aarch64_rust-clap+string-devel.sha256sum] = "bae20d6e02d521ee7c3aad8cf030298118e97ef4ccfaa81501a92ab360e06b1b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+suggestions-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+suggestions-devel;unpack=0"
SRC_URI[aarch64_rust-clap+suggestions-devel.sha256sum] = "ba92466c376e5b94f2ee1adf52186cf3592c9e0c828414fbfd1ad3f19ac287ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unicode-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+unicode-devel;unpack=0"
SRC_URI[aarch64_rust-clap+unicode-devel.sha256sum] = "7c518be2460ba405279cfb43d2cd69c87cf6b0741f968c752f5cc8482d9d638d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-doc-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+unstable-doc-devel;unpack=0"
SRC_URI[aarch64_rust-clap+unstable-doc-devel.sha256sum] = "e5ab457e13d3a4042c28e40c2686be9cb9f84f139840b69c1820d54a7bc403bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-ext-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+unstable-ext-devel;unpack=0"
SRC_URI[aarch64_rust-clap+unstable-ext-devel.sha256sum] = "8e30d78132122029e2a72e4a855cc67cd74e32070739600056270722e9fab3f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-markdown-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+unstable-markdown-devel;unpack=0"
SRC_URI[aarch64_rust-clap+unstable-markdown-devel.sha256sum] = "4a5436e1c20825af899bc5b13224032a750552d6008a0a900db5a3b8259e98ee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-styles-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+unstable-styles-devel;unpack=0"
SRC_URI[aarch64_rust-clap+unstable-styles-devel.sha256sum] = "5e6c5dd0275497c83839e553306ce4b9966f8c83c3dfff9cba3748e815a9a7ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-v5-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+unstable-v5-devel;unpack=0"
SRC_URI[aarch64_rust-clap+unstable-v5-devel.sha256sum] = "19b5f019fa7fb39cdebb33dbb2b70c82b7b2ba5b973e4f60802ad76a58bf8d63"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+usage-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+usage-devel;unpack=0"
SRC_URI[aarch64_rust-clap+usage-devel.sha256sum] = "8bc52bab16629b9fc252c4b8732a2dce6eda907dbec8492b4c3caa3b6b675937"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+wrap_help-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap+wrap_help-devel;unpack=0"
SRC_URI[aarch64_rust-clap+wrap_help-devel.sha256sum] = "5cf5f9e532ef5c52f12d6eec3eae49a81bd4c830e0a65edd95dad73e71e9cfce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap-devel;unpack=0"
SRC_URI[aarch64_rust-clap-devel.sha256sum] = "8e9029b827b2754c03ce43a9619b4c215d602c82063f63d833b4e28a835682d5"

RDEPENDS:rust-clap+cargo-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+cargo-devel \
 "
RDEPENDS:rust-clap+color-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+color-devel \
 "
RDEPENDS:rust-clap+debug-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+debug-devel \
 rust-clap_derive+debug-devel \
 rust-clap_derive+default-devel \
 "
RDEPENDS:rust-clap+default-devel = " \
 cargo \
 rust-clap+color-devel \
 rust-clap+error-context-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+suggestions-devel \
 rust-clap+usage-devel \
 rust-clap-devel \
 "
RDEPENDS:rust-clap+deprecated-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+deprecated-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+deprecated-devel \
 "
RDEPENDS:rust-clap+derive-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_derive+default-devel \
 "
RDEPENDS:rust-clap+env-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+env-devel \
 "
RDEPENDS:rust-clap+error-context-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+error-context-devel \
 "
RDEPENDS:rust-clap+help-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+help-devel \
 "
RDEPENDS:rust-clap+std-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+std-devel \
 "
RDEPENDS:rust-clap+string-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+string-devel \
 "
RDEPENDS:rust-clap+suggestions-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+suggestions-devel \
 "
RDEPENDS:rust-clap+unicode-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unicode-devel \
 "
RDEPENDS:rust-clap+unstable-doc-devel = " \
 cargo \
 rust-clap+derive-devel \
 rust-clap-devel \
 rust-clap_builder+unstable-doc-devel \
 "
RDEPENDS:rust-clap+unstable-ext-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unstable-ext-devel \
 "
RDEPENDS:rust-clap+unstable-markdown-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+unstable-markdown-devel \
 "
RDEPENDS:rust-clap+unstable-styles-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unstable-styles-devel \
 "
RDEPENDS:rust-clap+unstable-v5-devel = " \
 cargo \
 rust-clap+deprecated-devel \
 rust-clap-devel \
 rust-clap_builder+unstable-v5-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+unstable-v5-devel \
 "
RDEPENDS:rust-clap+usage-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+usage-devel \
 "
RDEPENDS:rust-clap+wrap_help-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+wrap_help-devel \
 "
RDEPENDS:rust-clap-devel = " \
 cargo \
 rust \
 rust-clap_builder-devel \
 "
