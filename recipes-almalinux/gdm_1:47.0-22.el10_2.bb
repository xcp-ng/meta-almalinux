# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdm"
PE = "1"
PV = "47.0"
PR = "22.el10_2"
PACKAGES = " \
 gdm \
 gdm-devel \
 gdm-pam-extensions-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdm-47.0-22.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "557050e5ff4ce0ca91741e10b79110a764d13db7429b1d6f88578f223cdf73dc"

URI_x86_64_v2_gdm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdm-47.0-22.el10_2.x86_64_v2.rpm;name=x86_64_v2_gdm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdm}"
SRC_URI[x86_64_v2_gdm.sha256sum] = "d201d375e64ad4123e7c44aa9138b9a32b04c152f2e70c934c08a6ddce87ef84"

URI_x86_64_v2_gdm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdm-devel-47.0-22.el10_2.x86_64_v2.rpm;name=x86_64_v2_gdm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdm-devel}"
SRC_URI[x86_64_v2_gdm-devel.sha256sum] = "86bf6592d352a5a22d7c66bd08f556185ba39dfdb6fb7e3321d74e9f048b5170"

URI_x86_64_v2_gdm-pam-extensions-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdm-pam-extensions-devel-47.0-22.el10_2.x86_64_v2.rpm;name=x86_64_v2_gdm-pam-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdm-pam-extensions-devel}"
SRC_URI[x86_64_v2_gdm-pam-extensions-devel.sha256sum] = "9d1550fa8c967f3a20336004afd184c4433895a0c2ed69d0c3520c40fe0c7866"

URI_aarch64_gdm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdm-47.0-22.el10_2.aarch64.rpm;name=aarch64_gdm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdm}"
SRC_URI[aarch64_gdm.sha256sum] = "bb399c96f90b826dceeb8896087e2b28beef9d9dae39f50052f7fcd0d9cbd56d"

URI_aarch64_gdm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdm-devel-47.0-22.el10_2.aarch64.rpm;name=aarch64_gdm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdm-devel}"
SRC_URI[aarch64_gdm-devel.sha256sum] = "36aaa328472019eabfe6152449641a414b6b8d8c643c70866c38d32738592a77"

URI_aarch64_gdm-pam-extensions-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdm-pam-extensions-devel-47.0-22.el10_2.aarch64.rpm;name=aarch64_gdm-pam-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdm-pam-extensions-devel}"
SRC_URI[aarch64_gdm-pam-extensions-devel.sha256sum] = "ab1ab5c96f4effef86e312f6885c8b9c36135e19a836415090ea284688657a53"

RDEPENDS:gdm = " \
 accountsservice \
 accountsservice-libs \
 almalinux-logos \
 audit-libs \
 bash \
 dbus-daemon \
 dconf \
 glib2 \
 glibc \
 gnome-keyring-pam \
 gnome-session \
 gnome-session-wayland-session \
 gnome-settings-daemon \
 gnome-shell \
 iso-codes \
 json-glib \
 keyutils-libs \
 libXau \
 libgcc \
 libgudev \
 libselinux \
 pam \
 pam-libs \
 polkit-libs \
 python3-pam \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 "
RDEPENDS:gdm-devel = " \
 gdm \
 gdm-pam-extensions-devel \
 glib2-devel \
 libselinux-devel \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:gdm-pam-extensions-devel = " \
 pam-devel \
 pkgconf-pkg-config \
 "
