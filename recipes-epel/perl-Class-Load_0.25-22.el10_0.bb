# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Load"
PV = "0.25"
PR = "22.el10_0"
PACKAGES = " \
 perl-Class-Load \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Load-0.25-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d31af6da53b7b49afa1ab59c9ec646ddd67a0c8a90ad0425676bd8e48c09839b"

URI_x86_64_v2_perl-Class-Load = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Load-0.25-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Load;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Load}"
SRC_URI[x86_64_v2_perl-Class-Load.sha256sum] = "500e65d8c13b89e5912bac610fca523f0287aea3077d9e12abf9a5d0e8493bc6"

URI_aarch64_perl-Class-Load = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Load-0.25-22.el10_0.noarch.rpm;name=aarch64_perl-Class-Load;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Load}"
SRC_URI[aarch64_perl-Class-Load.sha256sum] = "c58604ac1f43e304d1187d4ea28ebb5255f1db432d75a7ac7152c50c710f0b45"

RDEPENDS:perl-Class-Load = " \
 perl-Data-OptList \
 perl-Exporter \
 perl-Module-Implementation \
 perl-Module-Runtime \
 perl-Package-Stash \
 perl-Scalar-List-Utils \
 perl-Try-Tiny \
 perl-base \
 perl-libs \
 "
