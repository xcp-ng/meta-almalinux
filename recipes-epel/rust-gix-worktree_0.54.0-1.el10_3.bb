# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-worktree"
PV = "0.54.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree+default-devel \
 rust-gix-worktree+document-features-devel \
 rust-gix-worktree+gix-features-devel \
 rust-gix-worktree+parallel-devel \
 rust-gix-worktree+serde-devel \
 rust-gix-worktree+sha1-devel \
 rust-gix-worktree+sha256-devel \
 rust-gix-worktree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-worktree-0.54.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c916be5ccd96e072acaee18e316efdfc9cf27aafa80a9fb6accdef3a741be515"

URI_x86_64_v2_rust-gix-worktree+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+attributes-devel-0.54.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+attributes-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+attributes-devel.sha256sum] = "cf3a4d79dc35983787a1304483e18bc80e6cc72a79eb2aba237ac351daf706d2"

URI_x86_64_v2_rust-gix-worktree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+default-devel-0.54.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+default-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+default-devel.sha256sum] = "3b4e4ce395d05d264d0b8936ce932c709c94c81a2904663609cd32983b506855"

URI_x86_64_v2_rust-gix-worktree+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+document-features-devel-0.54.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+document-features-devel.sha256sum] = "28a7a3162cc9dff4da3a45aed8c9b597fd66152aea2ffe9c65df0008d5abd59f"

URI_x86_64_v2_rust-gix-worktree+gix-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+gix-features-devel-0.54.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+gix-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+gix-features-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+gix-features-devel.sha256sum] = "040e046af2a7c386feeb238e673c1e6e6e5871c5ac9efe9c7b2f2c7559242a01"

URI_x86_64_v2_rust-gix-worktree+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+parallel-devel-0.54.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+parallel-devel.sha256sum] = "bf5bd7de4d50144a25c914542a10d1317922356d591bc9caa5768f541d0bb823"

URI_x86_64_v2_rust-gix-worktree+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+serde-devel-0.54.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+serde-devel.sha256sum] = "0a3b046bb4e88f7a40c5d8c680c06415a39889b20e615277b0dc5dd0f19637cb"

URI_x86_64_v2_rust-gix-worktree+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+sha1-devel-0.54.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+sha1-devel.sha256sum] = "0d13432d85017c6f6a4ba5288f1f0f6983a69fb0bab1792448c20cf995b8063f"

URI_x86_64_v2_rust-gix-worktree+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+sha256-devel-0.54.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+sha256-devel.sha256sum] = "f008100df53220c1089aca8e7160fb6778605e7744b9b9f3edeb98bb021f77e8"

URI_x86_64_v2_rust-gix-worktree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-devel-0.54.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-devel.sha256sum] = "de8e631b10d879e480da9ca35ddf2e282713e3fea1a8f517dbfef962588521a0"

URI_aarch64_rust-gix-worktree+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+attributes-devel-0.54.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+attributes-devel}"
SRC_URI[aarch64_rust-gix-worktree+attributes-devel.sha256sum] = "be610e198ef62f5ec130937aaee6028ac03776b2b8a4fe6ffe5854ff8db5498c"

URI_aarch64_rust-gix-worktree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+default-devel-0.54.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+default-devel}"
SRC_URI[aarch64_rust-gix-worktree+default-devel.sha256sum] = "21adc6a75a1ee35a495a2cfd48b0aaa991bc757670a0f34057ba7e2a9513ce90"

URI_aarch64_rust-gix-worktree+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+document-features-devel-0.54.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+document-features-devel}"
SRC_URI[aarch64_rust-gix-worktree+document-features-devel.sha256sum] = "98eb77d6d49b87910d95cfb0d85266a622b328de6262004cb0110e75261cb585"

URI_aarch64_rust-gix-worktree+gix-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+gix-features-devel-0.54.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree+gix-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+gix-features-devel}"
SRC_URI[aarch64_rust-gix-worktree+gix-features-devel.sha256sum] = "a79122b384f9dbd359cf7b2e92b422b5a3b8b74ab542252bc0c456418a4c344a"

URI_aarch64_rust-gix-worktree+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+parallel-devel-0.54.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+parallel-devel}"
SRC_URI[aarch64_rust-gix-worktree+parallel-devel.sha256sum] = "212edb84995d668396a195bc42fd7b20e712397a5b8ae1d583ad1f8a45a848f6"

URI_aarch64_rust-gix-worktree+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+serde-devel-0.54.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+serde-devel}"
SRC_URI[aarch64_rust-gix-worktree+serde-devel.sha256sum] = "39fcdb880d57209065342e251d62d33b7bd827bb9cc59ea06ce26dd68dc97a3a"

URI_aarch64_rust-gix-worktree+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+sha1-devel-0.54.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+sha1-devel}"
SRC_URI[aarch64_rust-gix-worktree+sha1-devel.sha256sum] = "0afc52db0fc7cfb51066395cf54184df4b891bb6581a6564253952d2956ad18f"

URI_aarch64_rust-gix-worktree+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+sha256-devel-0.54.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+sha256-devel}"
SRC_URI[aarch64_rust-gix-worktree+sha256-devel.sha256sum] = "90bedf3354dc5aaf89f6d865d97fd95eb9bcd1f6f2ecd2c362d7808e8d8242cd"

URI_aarch64_rust-gix-worktree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-devel-0.54.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-devel}"
SRC_URI[aarch64_rust-gix-worktree-devel.sha256sum] = "7af2aca4e96f2cc8fbf6e4a446da8fe3eac5b1fbc571364c131997ad9ffa129c"

RDEPENDS:rust-gix-worktree+attributes-devel = " \
 cargo \
 rust-gix-attributes+default-devel \
 rust-gix-validate+default-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+default-devel = " \
 cargo \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+gix-features-devel = " \
 cargo \
 rust-gix-features+default-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+parallel-devel = " \
 cargo \
 rust-gix-features+default-devel \
 rust-gix-features+parallel-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-attributes+default-devel \
 rust-gix-attributes+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-ignore+serde-devel \
 rust-gix-index+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-worktree-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-worktree+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-fs+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-ignore+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 "
