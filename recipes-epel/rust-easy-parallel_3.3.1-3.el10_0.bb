# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-easy-parallel"
PV = "3.3.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-easy-parallel+default-devel \
 rust-easy-parallel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-easy-parallel-3.3.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9dd5635d5a1b6e163690cda440430cb892bbb50281d59b364664b87ea0feaff"

URI_x86_64_v2_rust-easy-parallel+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-easy-parallel+default-devel-3.3.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-easy-parallel+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-easy-parallel+default-devel}"
SRC_URI[x86_64_v2_rust-easy-parallel+default-devel.sha256sum] = "11dbe5940c5a35b3c204329f200e12145d0449fbcdfd053b3e5ae3b96b00d58c"

URI_x86_64_v2_rust-easy-parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-easy-parallel-devel-3.3.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-easy-parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-easy-parallel-devel}"
SRC_URI[x86_64_v2_rust-easy-parallel-devel.sha256sum] = "e8f6883d30819c08889ad22d955a3eff406625a23d5c1930fee9d3a4e0204a36"

URI_aarch64_rust-easy-parallel+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-easy-parallel+default-devel-3.3.1-3.el10_0.noarch.rpm;name=aarch64_rust-easy-parallel+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-easy-parallel+default-devel}"
SRC_URI[aarch64_rust-easy-parallel+default-devel.sha256sum] = "06f37e3b696b6018607753ff5f66eabdc3203e3bfaf98beaab3a888449bd55b2"

URI_aarch64_rust-easy-parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-easy-parallel-devel-3.3.1-3.el10_0.noarch.rpm;name=aarch64_rust-easy-parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-easy-parallel-devel}"
SRC_URI[aarch64_rust-easy-parallel-devel.sha256sum] = "93e6ef6207bb70515f5edeab1baebda873f5db76afb2d24047aba05fd1d08a68"

RDEPENDS:rust-easy-parallel+default-devel = " \
 cargo \
 rust-easy-parallel-devel \
 "
RDEPENDS:rust-easy-parallel-devel = " \
 cargo \
 rust \
 "
