# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcue"
PV = "2.3.0"
PR = "10.el10_0"
PACKAGES = " \
 libcue \
 libcue-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcue-2.3.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9cef70ab5ca9301afd8f96eec4e75846604a1b583eb8de43451db6360a1fb97"

URI_x86_64_v2_libcue = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcue-2.3.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcue}"
SRC_URI[x86_64_v2_libcue.sha256sum] = "f43b08dd1d8877ed48136c29e21e70cf771e1431bfad4e356fd5124b729e8eea"

URI_x86_64_v2_libcue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcue-devel-2.3.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcue-devel}"
SRC_URI[x86_64_v2_libcue-devel.sha256sum] = "4475242f42eb47d682497f100e7bb8a400786d37c21696b34e62417d2a02f58e"

URI_aarch64_libcue = "${EPEL_MIRROR}/aarch64/Packages/l/libcue-2.3.0-10.el10_0.aarch64.rpm;name=aarch64_libcue;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcue}"
SRC_URI[aarch64_libcue.sha256sum] = "ac700b10a904308a2fee4cde6e94b86dc78b31c6aa528be0c1d0aed03f7caa02"

URI_aarch64_libcue-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcue-devel-2.3.0-10.el10_0.aarch64.rpm;name=aarch64_libcue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcue-devel}"
SRC_URI[aarch64_libcue-devel.sha256sum] = "97fdab6e08320c88e53280f5f721e5a7055837dffae5220d4eb1dc364e93ed57"

RDEPENDS:libcue = " \
 glibc \
 "
RDEPENDS:libcue-devel = " \
 libcue \
 pkgconf-pkg-config \
 "
