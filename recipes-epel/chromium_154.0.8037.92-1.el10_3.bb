# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chromium"
PV = "154.0.8037.92"
PR = "1.el10_3"
PACKAGES = " \
 chromedriver \
 chromium \
 chromium-common \
 chromium-headless \
 chromium-qt5-ui \
 chromium-qt6-ui \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/chromium-154.0.8037.92-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1d03d2079f8e629a30e2a390a52635ce3d1469637539fcf26e94c0beef602e70"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromedriver-154.0.8037.92-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromedriver;unpack=0"
SRC_URI[x86_64_v2_chromedriver.sha256sum] = "8d4e2562e38d1bd957ccd4864e34e94dca61e56d0a49cfb491f00cfd9ed8e3fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-154.0.8037.92-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium;unpack=0"
SRC_URI[x86_64_v2_chromium.sha256sum] = "57bf5b57b5d1fe85f1202e61e3f7421c39eeff640930c1c9e4fb7c4a5a16495d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-common-154.0.8037.92-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-common;unpack=0"
SRC_URI[x86_64_v2_chromium-common.sha256sum] = "dd5314d0073bc2bf82caa7e5a1ff15ae5792c5cdde88e4a96941bb5c99e2b503"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-headless-154.0.8037.92-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-headless;unpack=0"
SRC_URI[x86_64_v2_chromium-headless.sha256sum] = "3aec239f779e5658d113418c2087416d09ec6caa7e7ae6c6f3cc269f2e16d29e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-qt5-ui-154.0.8037.92-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-qt5-ui;unpack=0"
SRC_URI[x86_64_v2_chromium-qt5-ui.sha256sum] = "6786fe49744c41def7eb90f7291acdb2daabc5f04bcee842bd214fb0cb4743e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-qt6-ui-154.0.8037.92-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-qt6-ui;unpack=0"
SRC_URI[x86_64_v2_chromium-qt6-ui.sha256sum] = "4f59ce61716259e304325b1523ffb1930ab533f99904820a9d0c9daeebec4741"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromedriver-154.0.8037.92-1.el10_3.aarch64.rpm;name=aarch64_chromedriver;unpack=0"
SRC_URI[aarch64_chromedriver.sha256sum] = "e3ab00ce647e250b48a38ccec415d3426629ee90a3d9b3c44e4b35d0b31c0c71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-154.0.8037.92-1.el10_3.aarch64.rpm;name=aarch64_chromium;unpack=0"
SRC_URI[aarch64_chromium.sha256sum] = "cdd21f6bc77edd489d3218da7b308c08acd115db897a234bdad5eff47dd78495"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-common-154.0.8037.92-1.el10_3.aarch64.rpm;name=aarch64_chromium-common;unpack=0"
SRC_URI[aarch64_chromium-common.sha256sum] = "96ebffdd8327a5239ec26b71f2366b0fcbe0d468b9904730bf6e89df9febd680"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-headless-154.0.8037.92-1.el10_3.aarch64.rpm;name=aarch64_chromium-headless;unpack=0"
SRC_URI[aarch64_chromium-headless.sha256sum] = "c92bb576c54b4d73a91c10aecf5e7a4439a2bb1a00891da1dcf561eb112d52e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt5-ui-154.0.8037.92-1.el10_3.aarch64.rpm;name=aarch64_chromium-qt5-ui;unpack=0"
SRC_URI[aarch64_chromium-qt5-ui.sha256sum] = "29de7c5db475a3859efb71666b221c2c3799787ba4718cd2734ae073dd28229a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt6-ui-154.0.8037.92-1.el10_3.aarch64.rpm;name=aarch64_chromium-qt6-ui;unpack=0"
SRC_URI[aarch64_chromium-qt6-ui.sha256sum] = "aca7e639958fac1eed78ce90a62601a82e5413a6c20ca8615da31692b561c7bd"

RDEPENDS:chromedriver = " \
 chromium-common \
 double-conversion \
 glib2 \
 glibc \
 libbrotli \
 libgcc \
 libxcb \
 libzstd \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:chromium = " \
 alsa-lib \
 at-spi2-atk \
 at-spi2-core \
 atk \
 bash \
 cairo \
 chromium-common \
 cups-libs \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gtk4 \
 harfbuzz \
 lcms2 \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libusb1 \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-mdns \
 nss-util \
 openjpeg2 \
 opus \
 pango \
 pipewire-libs \
 policycoreutils \
 policycoreutils-python-utils \
 systemd-libs \
 "
RDEPENDS:chromium-common = " \
 glibc \
 libgcc \
 "
RDEPENDS:chromium-headless = " \
 alsa-lib \
 at-spi2-core \
 atk \
 chromium-common \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-util \
 opus \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:chromium-qt5-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:chromium-qt6-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
