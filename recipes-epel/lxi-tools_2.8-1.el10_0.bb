# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lxi-tools"
PV = "2.8"
PR = "1.el10_0"
PACKAGES = " \
 lxi-tools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lxi-tools-2.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e34da0864fc0be6e4b743e4b4b265efe83056045c5044d1ca5d5af40ca234b63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxi-tools-2.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxi-tools;unpack=0"
SRC_URI[x86_64_v2_lxi-tools.sha256sum] = "6c9f767c8fc59e93e287dd76b9625507972fb241d0b76b9d42ea374f208df3bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lxi-tools-2.8-1.el10_0.aarch64.rpm;name=aarch64_lxi-tools;unpack=0"
SRC_URI[aarch64_lxi-tools.sha256sum] = "b4c4c6d40a5288a6dd770f6cd84b2a89f4d31ecef28bf3fb5a014fcdfd70b92b"

RDEPENDS:lxi-tools = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk4 \
 gtksourceview5 \
 json-glib \
 libadwaita \
 libgcc \
 liblxi \
 lua-libs \
 readline \
 "
