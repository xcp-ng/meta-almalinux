# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lvm2"
PE = "10"
PV = "2.03.32"
PR = "3.el10"
PACKAGES = " \
 device-mapper \
 device-mapper-devel \
 device-mapper-event \
 device-mapper-event-devel \
 device-mapper-event-libs \
 device-mapper-libs \
 lvm2 \
 lvm2-dbusd \
 lvm2-devel \
 lvm2-libs \
 lvm2-lockd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lvm2-2.03.32-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "116275fdb2813eacaad7934470f14e39118f60a85d1d56d931c2d5a843b62a7a"

URI_x86_64_v2_device-mapper = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-1.02.206-3.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper}"
SRC_URI[x86_64_v2_device-mapper.sha256sum] = "cca5c56bcdb7b306ebcf8ecb7af060eb509207d6ee001aefcfc2d6fe43bad2b4"

URI_x86_64_v2_device-mapper-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/device-mapper-devel-1.02.206-3.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-devel}"
SRC_URI[x86_64_v2_device-mapper-devel.sha256sum] = "178129032134243f6f8fd0d86d4e89891e3953f2ea106e38cefe3d90f26fd373"

URI_x86_64_v2_device-mapper-event = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-event-1.02.206-3.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-event;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-event}"
SRC_URI[x86_64_v2_device-mapper-event.sha256sum] = "7b8acff270dbb9e55a9067008cdd3c040f04c87015b41b9134e1e3377f13c1a9"

URI_x86_64_v2_device-mapper-event-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/device-mapper-event-devel-1.02.206-3.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-event-devel}"
SRC_URI[x86_64_v2_device-mapper-event-devel.sha256sum] = "e5541c43f07073f805734c436092bf0cf2159626733d87420f47124b37ee2359"

URI_x86_64_v2_device-mapper-event-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-event-libs-1.02.206-3.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-event-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-event-libs}"
SRC_URI[x86_64_v2_device-mapper-event-libs.sha256sum] = "2ce5ce5b0142587a3c85de29e741c6d9c4eb3530f7ae03387944aea4d3631746"

URI_x86_64_v2_device-mapper-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-libs-1.02.206-3.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-libs}"
SRC_URI[x86_64_v2_device-mapper-libs.sha256sum] = "8bc000f066fcb909b3dfe66293d0423bdd32539107c979b46d6a8211e142849b"

URI_x86_64_v2_lvm2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lvm2-2.03.32-3.el10.x86_64_v2.rpm;name=x86_64_v2_lvm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2}"
SRC_URI[x86_64_v2_lvm2.sha256sum] = "ec39ffdf51eb55a4f27af9ee98d665da8c3f9cb8eebf1853835403e5249670e8"

URI_x86_64_v2_lvm2-dbusd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lvm2-dbusd-2.03.32-3.el10.noarch.rpm;name=x86_64_v2_lvm2-dbusd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2-dbusd}"
SRC_URI[x86_64_v2_lvm2-dbusd.sha256sum] = "8821eae906fb93b577dd6c258315e63881267486417a2ef452bfa88af8078808"

URI_x86_64_v2_lvm2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/lvm2-devel-2.03.32-3.el10.x86_64_v2.rpm;name=x86_64_v2_lvm2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2-devel}"
SRC_URI[x86_64_v2_lvm2-devel.sha256sum] = "209fdbfec01e6b6e6b780c492b10aae82011df69cbb85282217bfac51411d4fe"

URI_x86_64_v2_lvm2-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lvm2-libs-2.03.32-3.el10.x86_64_v2.rpm;name=x86_64_v2_lvm2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2-libs}"
SRC_URI[x86_64_v2_lvm2-libs.sha256sum] = "51cc5ef6b20503f8ddb0ee397ea1543736d2ab5137b8b60c33b7fa5e32098092"

URI_x86_64_v2_lvm2-lockd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lvm2-lockd-2.03.32-3.el10.x86_64_v2.rpm;name=x86_64_v2_lvm2-lockd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2-lockd}"
SRC_URI[x86_64_v2_lvm2-lockd.sha256sum] = "f847d1c80debdd6a54b8f37434a2ba566dd4a977c966b566dd2653c48b9fa620"

URI_aarch64_device-mapper = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-1.02.206-3.el10.aarch64.rpm;name=aarch64_device-mapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper}"
SRC_URI[aarch64_device-mapper.sha256sum] = "0b83c61ed492ff84955fa32ff738e74aad542a241cb99958c95633982e552762"

URI_aarch64_device-mapper-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/device-mapper-devel-1.02.206-3.el10.aarch64.rpm;name=aarch64_device-mapper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-devel}"
SRC_URI[aarch64_device-mapper-devel.sha256sum] = "7dbc20d3ade3380cd5661e0047e0d19f9ad8fe14c2683c98847291a91452cfdf"

URI_aarch64_device-mapper-event = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-event-1.02.206-3.el10.aarch64.rpm;name=aarch64_device-mapper-event;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-event}"
SRC_URI[aarch64_device-mapper-event.sha256sum] = "0e21d0323343c0e7c111c6e04b226c6addb8b696872e59e0b76b2c29a97d64f2"

URI_aarch64_device-mapper-event-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/device-mapper-event-devel-1.02.206-3.el10.aarch64.rpm;name=aarch64_device-mapper-event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-event-devel}"
SRC_URI[aarch64_device-mapper-event-devel.sha256sum] = "e06927602a08f43c65bd67da6332fe93dd5f356d5ea0a7645874b5f3bae6c862"

URI_aarch64_device-mapper-event-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-event-libs-1.02.206-3.el10.aarch64.rpm;name=aarch64_device-mapper-event-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-event-libs}"
SRC_URI[aarch64_device-mapper-event-libs.sha256sum] = "a3d49977dbeda40ae23c0f40cc44b4ea1d2468eba6ce01f70d5b68b2ec55eced"

URI_aarch64_device-mapper-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-libs-1.02.206-3.el10.aarch64.rpm;name=aarch64_device-mapper-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-libs}"
SRC_URI[aarch64_device-mapper-libs.sha256sum] = "fd0c716719837d0574c52199bc560a2edbf30e664351c6fc4cf15d96e18ada86"

URI_aarch64_lvm2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lvm2-2.03.32-3.el10.aarch64.rpm;name=aarch64_lvm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2}"
SRC_URI[aarch64_lvm2.sha256sum] = "d3d271c532436346c026bf51e60ceef3209f5f9191aac7f63ff785bd1900e5a8"

URI_aarch64_lvm2-dbusd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lvm2-dbusd-2.03.32-3.el10.noarch.rpm;name=aarch64_lvm2-dbusd;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2-dbusd}"
SRC_URI[aarch64_lvm2-dbusd.sha256sum] = "8821eae906fb93b577dd6c258315e63881267486417a2ef452bfa88af8078808"

URI_aarch64_lvm2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/lvm2-devel-2.03.32-3.el10.aarch64.rpm;name=aarch64_lvm2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2-devel}"
SRC_URI[aarch64_lvm2-devel.sha256sum] = "d6ed18e1ed110f248f190eceb2812aa7a87c7bf2c9dbd9d4a3d3850805fa1e1f"

URI_aarch64_lvm2-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lvm2-libs-2.03.32-3.el10.aarch64.rpm;name=aarch64_lvm2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2-libs}"
SRC_URI[aarch64_lvm2-libs.sha256sum] = "55ae93cdd6aa1593c8510ffee9eac2848f30ca12233ca8e536d10363a4aaeb5f"

URI_aarch64_lvm2-lockd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lvm2-lockd-2.03.32-3.el10.aarch64.rpm;name=aarch64_lvm2-lockd;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2-lockd}"
SRC_URI[aarch64_lvm2-lockd.sha256sum] = "9046685f2ec4b169cdbb2bcb64285090bc1f654f40454bfc5c06c8aa0e6b30d6"

RDEPENDS:device-mapper = " \
 bash \
 device-mapper-libs \
 glibc \
 systemd \
 util-linux-core \
 "
RDEPENDS:device-mapper-devel = " \
 device-mapper \
 device-mapper-libs \
 libselinux-devel \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:device-mapper-event = " \
 bash \
 device-mapper \
 device-mapper-event-libs \
 device-mapper-libs \
 glibc \
 libgcc \
 systemd \
 "
RDEPENDS:device-mapper-event-devel = " \
 device-mapper-event \
 device-mapper-event-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:device-mapper-event-libs = " \
 device-mapper-libs \
 glibc \
 "
RDEPENDS:device-mapper-libs = " \
 device-mapper \
 glibc \
 libselinux \
 systemd-libs \
 "
RDEPENDS:lvm2 = " \
 bash \
 device-mapper-event-libs \
 device-mapper-persistent-data \
 glibc \
 kmod \
 libaio \
 libblkid \
 libedit \
 libnvme \
 libselinux \
 lvm2-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:lvm2-dbusd = " \
 bash \
 dbus \
 lvm2 \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-pyudev \
 systemd \
 "
RDEPENDS:lvm2-devel = " \
 device-mapper-devel \
 device-mapper-event-devel \
 lvm2 \
 lvm2-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:lvm2-libs = " \
 device-mapper-event \
 device-mapper-event-libs \
 device-mapper-libs \
 glibc \
 libaio \
 libblkid \
 libnvme \
 libselinux \
 systemd-libs \
 "
RDEPENDS:lvm2-lockd = " \
 bash \
 glibc \
 libselinux \
 lvm2 \
 sanlock-lib \
 systemd \
 systemd-libs \
 "
