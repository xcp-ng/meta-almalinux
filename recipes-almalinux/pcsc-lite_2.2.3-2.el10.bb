# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcsc-lite"
PV = "2.2.3"
PR = "2.el10"
PACKAGES = " \
 pcsc-lite \
 pcsc-lite-devel \
 pcsc-lite-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/pcsc-lite-2.2.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6abec551968b13371ca15aa7deeff150504348f32b58d0b6edf984842abf3e4"

URI_x86_64_v2_pcsc-lite = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pcsc-lite-2.2.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcsc-lite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcsc-lite}"
SRC_URI[x86_64_v2_pcsc-lite.sha256sum] = "8d77fee332b223fe7fc43093104fd14023697083a2741e237c95ead7e2b8ced2"

URI_x86_64_v2_pcsc-lite-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcsc-lite-devel-2.2.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcsc-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcsc-lite-devel}"
SRC_URI[x86_64_v2_pcsc-lite-devel.sha256sum] = "ca997f50f4c5008af0939b2911485e1ee02d83e617b7329695fd02f2284f6f1f"

URI_x86_64_v2_pcsc-lite-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pcsc-lite-libs-2.2.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_pcsc-lite-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcsc-lite-libs}"
SRC_URI[x86_64_v2_pcsc-lite-libs.sha256sum] = "8543123b85bae86bf1d3a811edfbbf26a23bd63714a2c4013c99eef0e0cd68e3"

URI_aarch64_pcsc-lite = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pcsc-lite-2.2.3-2.el10.aarch64.rpm;name=aarch64_pcsc-lite;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcsc-lite}"
SRC_URI[aarch64_pcsc-lite.sha256sum] = "44200858dbde954d7be1126b107ecb9f28c1122e2c4e54b041ba49c0077384df"

URI_aarch64_pcsc-lite-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcsc-lite-devel-2.2.3-2.el10.aarch64.rpm;name=aarch64_pcsc-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcsc-lite-devel}"
SRC_URI[aarch64_pcsc-lite-devel.sha256sum] = "f0cb8920f6c3eef409059ec55ba0d3488a4311cd4f1b3c1ddd762b68afa802cc"

URI_aarch64_pcsc-lite-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pcsc-lite-libs-2.2.3-2.el10.aarch64.rpm;name=aarch64_pcsc-lite-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcsc-lite-libs}"
SRC_URI[aarch64_pcsc-lite-libs.sha256sum] = "9e55181c97e37c8978c0685be303f784a9a574a9db5ed95945af3797246ce92b"

RDEPENDS:pcsc-lite = " \
 bash \
 glib2 \
 glibc \
 pcsc-lite-ccid \
 pcsc-lite-libs \
 polkit \
 polkit-libs \
 python3 \
 systemd \
 systemd-libs \
 "
RDEPENDS:pcsc-lite-devel = " \
 glibc \
 pcsc-lite-libs \
 pkgconf-pkg-config \
 python3 \
 "
RDEPENDS:pcsc-lite-libs = " \
 glibc \
 "
