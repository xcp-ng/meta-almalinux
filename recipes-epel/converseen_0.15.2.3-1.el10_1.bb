# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "converseen"
PV = "0.15.2.3"
PR = "1.el10_1"
PACKAGES = " \
 converseen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/converseen-0.15.2.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb469c3c77b293d3d0688355867cd49e74da9b024b9d6e580be496fc8bbfbfea"

URI_x86_64_v2_converseen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/converseen-0.15.2.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_converseen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_converseen}"
SRC_URI[x86_64_v2_converseen.sha256sum] = "dcb98d56ea379e71946cbce125a7815d8ddda0a3f1202da116b390c116eb20fd"

URI_aarch64_converseen = "${EPEL_MIRROR}/aarch64/Packages/c/converseen-0.15.2.3-1.el10_1.aarch64.rpm;name=aarch64_converseen;unpack=0"
SRC_URI:append = " ${URI_aarch64_converseen}"
SRC_URI[aarch64_converseen.sha256sum] = "5304a4b8f83331ed55fc5722df04e1cc2449c99637da5e94251a1b6f8669b7eb"

RDEPENDS:converseen = " \
 ImageMagick-c++ \
 ImageMagick-libs \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
