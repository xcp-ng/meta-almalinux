# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pcap"
PV = "1.3.0"
PR = "5.el10_1"
PACKAGES = " \
 rust-pcap+all-features-devel \
 rust-pcap+capture-stream-devel \
 rust-pcap+default-devel \
 rust-pcap+futures-devel \
 rust-pcap+tokio-devel \
 rust-pcap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pcap-1.3.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d12bb980431b56acaf43921f394521e61ef6fb650c0fffd7e2caa99341b2b54"

URI_x86_64_v2_rust-pcap+all-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcap+all-features-devel-1.3.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcap+all-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcap+all-features-devel}"
SRC_URI[x86_64_v2_rust-pcap+all-features-devel.sha256sum] = "eb1df8a83725eca6bd8fd1b6a2264d8a5d45f9e7143f17f2e28bc64e1c5343d4"

URI_x86_64_v2_rust-pcap+capture-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcap+capture-stream-devel-1.3.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcap+capture-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcap+capture-stream-devel}"
SRC_URI[x86_64_v2_rust-pcap+capture-stream-devel.sha256sum] = "6b69536929784a889deb3eb20e0c09b54ff4035ed22ba2de7c558b5c74c8fbb4"

URI_x86_64_v2_rust-pcap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcap+default-devel-1.3.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcap+default-devel}"
SRC_URI[x86_64_v2_rust-pcap+default-devel.sha256sum] = "18e51fcf8d38501bfd05eb2bdfc93b46777648e90180cfb09b25fe9ede4d4e2e"

URI_x86_64_v2_rust-pcap+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcap+futures-devel-1.3.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcap+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcap+futures-devel}"
SRC_URI[x86_64_v2_rust-pcap+futures-devel.sha256sum] = "853322466b71b319eeabfb120f4516f9c8e1ee9bf8f85988c89e04e6c59b78b1"

URI_x86_64_v2_rust-pcap+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcap+tokio-devel-1.3.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcap+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcap+tokio-devel}"
SRC_URI[x86_64_v2_rust-pcap+tokio-devel.sha256sum] = "fce893d03d2f4a5e0b55c16a501164260a9559be56aed9928d0b397865efbdcd"

URI_x86_64_v2_rust-pcap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcap-devel-1.3.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcap-devel}"
SRC_URI[x86_64_v2_rust-pcap-devel.sha256sum] = "36653538e398b5958237ead7c4f7902e20b6c030207cc22629afa2a511ac6e6b"

URI_aarch64_rust-pcap+all-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcap+all-features-devel-1.3.0-5.el10_1.noarch.rpm;name=aarch64_rust-pcap+all-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcap+all-features-devel}"
SRC_URI[aarch64_rust-pcap+all-features-devel.sha256sum] = "c4411a18672458a1f916227c72ed8c1e8b98e74a1de61223ced7765dc049a7c9"

URI_aarch64_rust-pcap+capture-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcap+capture-stream-devel-1.3.0-5.el10_1.noarch.rpm;name=aarch64_rust-pcap+capture-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcap+capture-stream-devel}"
SRC_URI[aarch64_rust-pcap+capture-stream-devel.sha256sum] = "98fce18dc82d984386f740d2a06eda1c28808e2caef9e6d04c53d69e37edc3f5"

URI_aarch64_rust-pcap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcap+default-devel-1.3.0-5.el10_1.noarch.rpm;name=aarch64_rust-pcap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcap+default-devel}"
SRC_URI[aarch64_rust-pcap+default-devel.sha256sum] = "d2772dcae3e793fc5e39b030843b67f8b2ee413e8dc04523f083f067f896e51e"

URI_aarch64_rust-pcap+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcap+futures-devel-1.3.0-5.el10_1.noarch.rpm;name=aarch64_rust-pcap+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcap+futures-devel}"
SRC_URI[aarch64_rust-pcap+futures-devel.sha256sum] = "16cb47e899b123886c00eb7b7ca67519c234453b1bab058b289d1050f0152568"

URI_aarch64_rust-pcap+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcap+tokio-devel-1.3.0-5.el10_1.noarch.rpm;name=aarch64_rust-pcap+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcap+tokio-devel}"
SRC_URI[aarch64_rust-pcap+tokio-devel.sha256sum] = "99e5dc0c57eac5a80c50fa801fdfd44e7eae1b1f5baedc6625943797d90cf11a"

URI_aarch64_rust-pcap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcap-devel-1.3.0-5.el10_1.noarch.rpm;name=aarch64_rust-pcap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcap-devel}"
SRC_URI[aarch64_rust-pcap-devel.sha256sum] = "69a00295d29622158b94c7bcb96333ebb6399f463dbd75b09e493c33bd13fb30"

RDEPENDS:rust-pcap+all-features-devel = " \
 cargo \
 rust-pcap-devel \
 "
RDEPENDS:rust-pcap+capture-stream-devel = " \
 cargo \
 rust-pcap+futures-devel \
 rust-pcap+tokio-devel \
 rust-pcap-devel \
 "
RDEPENDS:rust-pcap+default-devel = " \
 cargo \
 rust-pcap-devel \
 "
RDEPENDS:rust-pcap+futures-devel = " \
 cargo \
 rust-futures+default-devel \
 rust-pcap-devel \
 "
RDEPENDS:rust-pcap+tokio-devel = " \
 cargo \
 rust-pcap-devel \
 rust-tokio+default-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 "
RDEPENDS:rust-pcap-devel = " \
 cargo \
 libpcap-devel \
 rust-bitflags1+default-devel \
 rust-errno0.2+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 rust-regex+default-devel \
 "
