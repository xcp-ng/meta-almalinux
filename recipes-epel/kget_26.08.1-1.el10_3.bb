# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kget"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kget \
 kget-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kget-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "130a88a69b14acbc68f8b8b8348844590c1f1092df9f13fb25cd2beacba75eda"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kget-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kget;unpack=0"
SRC_URI[x86_64_v2_kget.sha256sum] = "c9fdcda8d9ebfad66e204b5baa858cdaf727a68ef3f3cb197e56c7d0cab29645"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kget-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kget-libs;unpack=0"
SRC_URI[x86_64_v2_kget-libs.sha256sum] = "f1253d28ac9eb3d48452a278ca08a6ea0222969fde8080339884174866133461"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kget-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kget;unpack=0"
SRC_URI[aarch64_kget.sha256sum] = "d54a5c5402c799128be582f2b49acc6790cc6dd4000bc3bfdf5aa51a3e0cecb7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kget-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kget-libs;unpack=0"
SRC_URI[aarch64_kget-libs.sha256sum] = "356b0d36768b6ac5cb13f1390439501bf4275c4283573dfd86dd277cf792f2a7"

RDEPENDS:kget = " \
 glibc \
 gpgme2pp \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kget-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kget-libs = " \
 glibc \
 gpgme2pp \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kget \
 libgcc \
 libktorrent \
 libmms \
 libstdc++ \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
