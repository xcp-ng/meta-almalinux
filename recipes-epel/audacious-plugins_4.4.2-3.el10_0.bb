# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audacious-plugins"
PV = "4.4.2"
PR = "3.el10_0"
PACKAGES = " \
 audacious-plugins \
 audacious-plugins-amidi \
 audacious-plugins-exotic \
 audacious-plugins-ffaudio \
 audacious-plugins-jack \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/audacious-plugins-4.4.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7de4ede78935c1362a6bf95f0fd9f948bff764e366a6fd5663c4970e9686b675"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - audacious-plugins-ffaudio: libavcodec.so.61()(64bit)
# - audacious-plugins-ffaudio: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - audacious-plugins-ffaudio: libavformat.so.61()(64bit)
# - audacious-plugins-ffaudio: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - audacious-plugins-ffaudio: libavutil.so.59()(64bit)
# - audacious-plugins-ffaudio: libavutil.so.59(LIBAVUTIL_59)(64bit)

URI_x86_64_v2_audacious-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audacious-plugins-4.4.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audacious-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audacious-plugins}"
SRC_URI[x86_64_v2_audacious-plugins.sha256sum] = "12f03a144c89e66b0838cb872631cfbb12b36ae070d926af6431f425de9493d8"

URI_x86_64_v2_audacious-plugins-amidi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audacious-plugins-amidi-4.4.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audacious-plugins-amidi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audacious-plugins-amidi}"
SRC_URI[x86_64_v2_audacious-plugins-amidi.sha256sum] = "b3c7a69aa9f64e037317a172f506e3944c1f0b9339ea0345091cf198535db8e6"

URI_x86_64_v2_audacious-plugins-exotic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audacious-plugins-exotic-4.4.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audacious-plugins-exotic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audacious-plugins-exotic}"
SRC_URI[x86_64_v2_audacious-plugins-exotic.sha256sum] = "33cc6559d280044b6bc483a6b49f660b8fa40caedc67f518950a291cdf62006e"

URI_x86_64_v2_audacious-plugins-ffaudio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audacious-plugins-ffaudio-4.4.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audacious-plugins-ffaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audacious-plugins-ffaudio}"
SRC_URI[x86_64_v2_audacious-plugins-ffaudio.sha256sum] = "73dd304ebfc8a37d6afdc8b45d2a1003601a595b2f8c639017ffc0857e21f94e"

URI_x86_64_v2_audacious-plugins-jack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audacious-plugins-jack-4.4.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audacious-plugins-jack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audacious-plugins-jack}"
SRC_URI[x86_64_v2_audacious-plugins-jack.sha256sum] = "e6424c57ba8ffa61ba2bd6fc939c95f30d010fa3154fe45ecbab7e0277b3e47d"

URI_aarch64_audacious-plugins = "${EPEL_MIRROR}/aarch64/Packages/a/audacious-plugins-4.4.2-3.el10_0.aarch64.rpm;name=aarch64_audacious-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_audacious-plugins}"
SRC_URI[aarch64_audacious-plugins.sha256sum] = "29bb8b8daeda2be932d0f5c2db75e11a82dcf0f3938287e6feae0fd43dfa9914"

URI_aarch64_audacious-plugins-amidi = "${EPEL_MIRROR}/aarch64/Packages/a/audacious-plugins-amidi-4.4.2-3.el10_0.aarch64.rpm;name=aarch64_audacious-plugins-amidi;unpack=0"
SRC_URI:append = " ${URI_aarch64_audacious-plugins-amidi}"
SRC_URI[aarch64_audacious-plugins-amidi.sha256sum] = "9178c5f21a8d6427705d9c0b97f14700728cc9f07a5f946fcf678ebbabe80799"

URI_aarch64_audacious-plugins-exotic = "${EPEL_MIRROR}/aarch64/Packages/a/audacious-plugins-exotic-4.4.2-3.el10_0.aarch64.rpm;name=aarch64_audacious-plugins-exotic;unpack=0"
SRC_URI:append = " ${URI_aarch64_audacious-plugins-exotic}"
SRC_URI[aarch64_audacious-plugins-exotic.sha256sum] = "57d6f85fe38bab27a6d866198aeda19294d8d51cf82e06ac1803a78d9181a842"

URI_aarch64_audacious-plugins-ffaudio = "${EPEL_MIRROR}/aarch64/Packages/a/audacious-plugins-ffaudio-4.4.2-3.el10_0.aarch64.rpm;name=aarch64_audacious-plugins-ffaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_audacious-plugins-ffaudio}"
SRC_URI[aarch64_audacious-plugins-ffaudio.sha256sum] = "33444cee1799019dd97d4f63fa26d67bf03c843f9047da36f3a526fafcafa2da"

URI_aarch64_audacious-plugins-jack = "${EPEL_MIRROR}/aarch64/Packages/a/audacious-plugins-jack-4.4.2-3.el10_0.aarch64.rpm;name=aarch64_audacious-plugins-jack;unpack=0"
SRC_URI:append = " ${URI_aarch64_audacious-plugins-jack}"
SRC_URI[aarch64_audacious-plugins-jack.sha256sum] = "fc919a0131aff0012465a763279214a340ebaba0fc96be89f3ff1964f28c63da"

RDEPENDS:audacious-plugins = " \
 alsa-lib \
 ampache_browser \
 audacious \
 audacious-libs \
 cairo \
 flac-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 json-glib \
 lame-libs \
 libX11 \
 libXcomposite \
 libXrender \
 libbs2b \
 libcddb \
 libcdio \
 libcdio-paranoia \
 libcue \
 libgcc \
 libglvnd-glx \
 libmms \
 libmodplug \
 libnotify \
 libogg \
 libopenmpt \
 libsamplerate \
 libsndfile \
 libstdc++ \
 libvorbis \
 libxml2 \
 lirc-libs \
 mpg123-libs \
 neon \
 opusfile \
 pango \
 pipewire-libs \
 pulseaudio-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 soxr \
 virtual/libSDL2-2.0.so.0___64bit_ \
 virtual/libcurl.so.4___64bit_ \
 wavpack \
 "
RDEPENDS:audacious-plugins-amidi = " \
 audacious-libs \
 audacious-plugins \
 fluidsynth-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libgcc \
 libstdc++ \
 pango \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:audacious-plugins-exotic = " \
 adplug \
 audacious-libs \
 audacious-plugins \
 glibc \
 libbinio \
 libgcc \
 libsidplayfp \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:audacious-plugins-ffaudio:x86_64_v2 = " \
 audacious-libs \
 audacious-plugins \
 glibc \
 libgcc \
 libstdc++ \
"
RDEPENDS:audacious-plugins-ffaudio:aarch64 = " \
 audacious-libs \
 audacious-plugins \
 glibc \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libgcc \
 libstdc++ \
"
RDEPENDS:audacious-plugins-jack = " \
 audacious-libs \
 audacious-plugins \
 glibc \
 libgcc \
 libstdc++ \
 pipewire-jack-audio-connection-kit-libs \
 "
