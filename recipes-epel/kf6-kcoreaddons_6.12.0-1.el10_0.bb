# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcoreaddons"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kcoreaddons \
 kf6-kcoreaddons-devel \
 kf6-kcoreaddons-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcoreaddons-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e961cf73d949688b81f1b1bb9607618dcecbd7edaacb8e93f7747afeb860ada"

URI_x86_64_v2_kf6-kcoreaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons}"
SRC_URI[x86_64_v2_kf6-kcoreaddons.sha256sum] = "a4ff1e950dc179ab5cb8fc2f5d70cfcf35964e63ff142bdcf4522bcc56fe0134"

URI_x86_64_v2_kf6-kcoreaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcoreaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons-devel}"
SRC_URI[x86_64_v2_kf6-kcoreaddons-devel.sha256sum] = "aadf2971b105da66b692fb179c7ba5e06a5a1943e0812409177a9288b0074d11"

URI_x86_64_v2_kf6-kcoreaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcoreaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons-doc}"
SRC_URI[x86_64_v2_kf6-kcoreaddons-doc.sha256sum] = "7623aef9b0b2e97168017477d73287abca87e20c70c0c40340833f8fa714f01c"

URI_aarch64_kf6-kcoreaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons}"
SRC_URI[aarch64_kf6-kcoreaddons.sha256sum] = "89675f5ce5a6395728de4cc086e5b3e68cfa59458d1dd0d8dea48fe70d54368a"

URI_aarch64_kf6-kcoreaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcoreaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons-devel}"
SRC_URI[aarch64_kf6-kcoreaddons-devel.sha256sum] = "f5f9dad91d77690907113ee0ccd6cca0428d69233946eec780751097d0d1b5b0"

URI_aarch64_kf6-kcoreaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kcoreaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons-doc}"
SRC_URI[aarch64_kf6-kcoreaddons-doc.sha256sum] = "0d41821925afbb9af08263a470eb3e73214c94bdd08801dde7eb03487f3bcfab"

RDEPENDS:kf6-kcoreaddons = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 systemd-libs \
 "
RDEPENDS:kf6-kcoreaddons-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcoreaddons-doc = " \
 "
