# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-serde"
PV = "0.2.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-tracing-serde+default-devel \
 rust-tracing-serde-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-serde-0.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d40ac1bc9fd3c18dfc2f087f9fe7fdc126bdad73c1a5de26c7e23b32e4bf6bb"

URI_x86_64_v2_rust-tracing-serde+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-serde+default-devel-0.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-serde+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-serde+default-devel.sha256sum] = "834927405b3fe5ccf83f086e5434afce400a9a4650a620022b1cfb0314e7a55a"

URI_x86_64_v2_rust-tracing-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-serde-devel-0.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-serde-devel}"
SRC_URI[x86_64_v2_rust-tracing-serde-devel.sha256sum] = "958cd5d533e30147c17f1231a13a58d6d7230b836473cb3541e3bdb2d12258f3"

URI_aarch64_rust-tracing-serde+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-serde+default-devel-0.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-serde+default-devel}"
SRC_URI[aarch64_rust-tracing-serde+default-devel.sha256sum] = "cc5a947388b09709ed7f5d047e163d51ebba087f13032ce401e926ef6db9bb41"

URI_aarch64_rust-tracing-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-serde-devel-0.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-serde-devel}"
SRC_URI[aarch64_rust-tracing-serde-devel.sha256sum] = "d13d8c9372be8ca9cc824073b513c44f3d1ad36a4c371eac5461b8ed64fd7c92"

RDEPENDS:rust-tracing-serde+default-devel = " \
 cargo \
 rust-tracing-serde-devel \
 "
RDEPENDS:rust-tracing-serde-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-tracing-core+default-devel \
 "
