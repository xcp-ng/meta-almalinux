# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-url"
PV = "2.5.2"
PR = "3.el10_0"
PACKAGES = " \
 rust-url+default-devel \
 rust-url+expose_internals-devel \
 rust-url+serde-devel \
 rust-url-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-url-2.5.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80cf3dbc2274b234525837af73d84ece86f98662b4536f063793fae94d574034"

URI_x86_64_v2_rust-url+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+default-devel-2.5.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+default-devel}"
SRC_URI[x86_64_v2_rust-url+default-devel.sha256sum] = "0a243e3f97fb85476bf7f775552293e45ce1f2e3dd5900c22bb9d7e6fa08c753"

URI_x86_64_v2_rust-url+expose_internals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+expose_internals-devel-2.5.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+expose_internals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+expose_internals-devel}"
SRC_URI[x86_64_v2_rust-url+expose_internals-devel.sha256sum] = "e39df36b501b553e7cd568b34950606531cb78e50868d5217d95681890548500"

URI_x86_64_v2_rust-url+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+serde-devel-2.5.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+serde-devel}"
SRC_URI[x86_64_v2_rust-url+serde-devel.sha256sum] = "fb0444ccf44c05107d4136d4da02d33ed820b0fadc131be7313b5bb0fa4283a0"

URI_x86_64_v2_rust-url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url-devel-2.5.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url-devel}"
SRC_URI[x86_64_v2_rust-url-devel.sha256sum] = "28ab57f8bc43b2fbaab4f48bcf913f2b19516b77e7dca93fa6e6c2cb85d20952"

URI_aarch64_rust-url+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+default-devel-2.5.2-3.el10_0.noarch.rpm;name=aarch64_rust-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+default-devel}"
SRC_URI[aarch64_rust-url+default-devel.sha256sum] = "ded427f090ecd3467abd437b4ace9a098f2782e829b949f579c5ec572cec0897"

URI_aarch64_rust-url+expose_internals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+expose_internals-devel-2.5.2-3.el10_0.noarch.rpm;name=aarch64_rust-url+expose_internals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+expose_internals-devel}"
SRC_URI[aarch64_rust-url+expose_internals-devel.sha256sum] = "8dec4963e17a73490cf565aa3d41bebadf6523d6240245cda922ec1dd9c94628"

URI_aarch64_rust-url+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+serde-devel-2.5.2-3.el10_0.noarch.rpm;name=aarch64_rust-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+serde-devel}"
SRC_URI[aarch64_rust-url+serde-devel.sha256sum] = "19f39c6a8a12d2e2cf4a4535a6d0adaee709d2796590beb754bb9e3c6dd882c5"

URI_aarch64_rust-url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url-devel-2.5.2-3.el10_0.noarch.rpm;name=aarch64_rust-url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url-devel}"
SRC_URI[aarch64_rust-url-devel.sha256sum] = "ebf5c1ea00b9bd0870b4dd21c69e720b0ac005792dbabfcd0aea16c4fcdd2d21"

RDEPENDS:rust-url+default-devel = " \
 cargo \
 rust-url-devel \
 "
RDEPENDS:rust-url+expose_internals-devel = " \
 cargo \
 rust-url-devel \
 "
RDEPENDS:rust-url+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-url-devel \
 "
RDEPENDS:rust-url-devel = " \
 cargo \
 rust \
 rust-form_urlencoded+default-devel \
 rust-idna+default-devel \
 rust-percent-encoding+default-devel \
 "
