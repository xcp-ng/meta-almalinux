# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kunifiedpush"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kunifiedpush \
 kunifiedpush-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kunifiedpush-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73eb220245c71e08fc05f7310326b0ec5780ee234e52f33a4d87be17f6c42efc"

URI_x86_64_v2_kunifiedpush = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kunifiedpush-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kunifiedpush;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kunifiedpush}"
SRC_URI[x86_64_v2_kunifiedpush.sha256sum] = "937803924708aad01e25e375d990d196713bb817fa119157cd32fbb9aa8e8aaf"

URI_x86_64_v2_kunifiedpush-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kunifiedpush-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kunifiedpush-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kunifiedpush-devel}"
SRC_URI[x86_64_v2_kunifiedpush-devel.sha256sum] = "e959e44099234d3f0716d8f198a52efde9893379f9236e70220d40c59fe11d6b"

URI_aarch64_kunifiedpush = "${EPEL_MIRROR}/aarch64/Packages/k/kunifiedpush-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kunifiedpush;unpack=0"
SRC_URI:append = " ${URI_aarch64_kunifiedpush}"
SRC_URI[aarch64_kunifiedpush.sha256sum] = "10be755a9e4290cee8854b3ddd7363aa0d977795817388f74537f89cdbcf1c8e"

URI_aarch64_kunifiedpush-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kunifiedpush-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kunifiedpush-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kunifiedpush-devel}"
SRC_URI[aarch64_kunifiedpush-devel.sha256sum] = "30eb45e7e0038f756fea4db1b7cc80f08ffefa595eb8daaa036e69909aab229b"

RDEPENDS:kunifiedpush = " \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kservice \
 kf6-solid \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
RDEPENDS:kunifiedpush-devel = " \
 cmake-filesystem \
 kunifiedpush \
 "
