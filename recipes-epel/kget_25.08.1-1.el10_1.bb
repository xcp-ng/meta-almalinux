# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kget"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kget \
 kget-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kget-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "693cf38069a6b9f7b59c2d76d4064513f9bcca3b3504f006079e61329b17b217"

URI_x86_64_v2_kget = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kget-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kget;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kget}"
SRC_URI[x86_64_v2_kget.sha256sum] = "6627351b25b5d9d74b2482b342a239ddc5e7db885068076bec50dda93cd2fcff"

URI_x86_64_v2_kget-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kget-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kget-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kget-libs}"
SRC_URI[x86_64_v2_kget-libs.sha256sum] = "c46c7eabc5eb18e7bed99319ccdda8d3c77522d46dff5f4278cfc74d2f989980"

URI_aarch64_kget = "${EPEL_MIRROR}/aarch64/Packages/k/kget-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kget;unpack=0"
SRC_URI:append = " ${URI_aarch64_kget}"
SRC_URI[aarch64_kget.sha256sum] = "8124169c7b460f2ea7acbc80f12797cbf373ca4fa3b5d2805c896704396bdf6f"

URI_aarch64_kget-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kget-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kget-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kget-libs}"
SRC_URI[aarch64_kget-libs.sha256sum] = "dc5b6067e8abd7b0db2368d99a6a965197b4b1a801376411cd898a438d76d546"

RDEPENDS:kget = " \
 glibc \
 gpgmepp \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kget-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kget-libs:x86_64_v2 = " \
 glibc \
 gpgmepp \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kget \
 libgcc \
 libmms \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
"
RDEPENDS:kget-libs:aarch64 = " \
 glibc \
 gpgmepp \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kget \
 libgcc \
 libktorrent \
 libmms \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
"
