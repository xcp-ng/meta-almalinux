# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven"
PE = "1"
PV = "3.9.9"
PR = "1.el10"
PACKAGES = " \
 maven \
 maven-javadoc \
 maven-lib \
 maven-openjdk21 \
 maven-unbound \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/maven-3.9.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "820dd9c1f453d11a07ac4a1ded213e24fb115b216c4b7703cd349e84ab4c14d0"

URI_x86_64_v2_maven = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/maven-3.9.9-1.el10.noarch.rpm;name=x86_64_v2_maven;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven}"
SRC_URI[x86_64_v2_maven.sha256sum] = "529bd2938708ba51136d9a2b39921f8a4242559792792ffe2ddd7e4ff8d04627"

URI_x86_64_v2_maven-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-javadoc-3.9.9-1.el10.noarch.rpm;name=x86_64_v2_maven-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-javadoc}"
SRC_URI[x86_64_v2_maven-javadoc.sha256sum] = "c1a602207724399280ef11a3494ae4893264b7c77b60426f2e8e48cc5f1ade6c"

URI_x86_64_v2_maven-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/maven-lib-3.9.9-1.el10.noarch.rpm;name=x86_64_v2_maven-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-lib}"
SRC_URI[x86_64_v2_maven-lib.sha256sum] = "5b6739e7d3ccff97450ffdb59e61b7cb9886dd52bca59df63476e8bdfd483684"

URI_x86_64_v2_maven-openjdk21 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/maven-openjdk21-3.9.9-1.el10.noarch.rpm;name=x86_64_v2_maven-openjdk21;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-openjdk21}"
SRC_URI[x86_64_v2_maven-openjdk21.sha256sum] = "1e3f95fa23b5d3309b2cab2e2b060c80121ade402f9a826197cdb04dba544c54"
RPROVIDES:maven-openjdk21:x86_64_v2 = "virtual/maven-jdk-binding"

URI_x86_64_v2_maven-unbound = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-unbound-3.9.9-1.el10.noarch.rpm;name=x86_64_v2_maven-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-unbound}"
SRC_URI[x86_64_v2_maven-unbound.sha256sum] = "2a7680e88be645e9727441ead4d44c80e386444cb57fd1bc5ae298a68f61e434"
RPROVIDES:maven-unbound:x86_64_v2 = "virtual/maven-jdk-binding"

URI_aarch64_maven = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/maven-3.9.9-1.el10.noarch.rpm;name=aarch64_maven;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven}"
SRC_URI[aarch64_maven.sha256sum] = "529bd2938708ba51136d9a2b39921f8a4242559792792ffe2ddd7e4ff8d04627"

URI_aarch64_maven-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-javadoc-3.9.9-1.el10.noarch.rpm;name=aarch64_maven-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-javadoc}"
SRC_URI[aarch64_maven-javadoc.sha256sum] = "c1a602207724399280ef11a3494ae4893264b7c77b60426f2e8e48cc5f1ade6c"

URI_aarch64_maven-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/maven-lib-3.9.9-1.el10.noarch.rpm;name=aarch64_maven-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-lib}"
SRC_URI[aarch64_maven-lib.sha256sum] = "5b6739e7d3ccff97450ffdb59e61b7cb9886dd52bca59df63476e8bdfd483684"

URI_aarch64_maven-openjdk21 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/maven-openjdk21-3.9.9-1.el10.noarch.rpm;name=aarch64_maven-openjdk21;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-openjdk21}"
SRC_URI[aarch64_maven-openjdk21.sha256sum] = "1e3f95fa23b5d3309b2cab2e2b060c80121ade402f9a826197cdb04dba544c54"
RPROVIDES:maven-openjdk21:aarch64 = "virtual/maven-jdk-binding"

URI_aarch64_maven-unbound = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-unbound-3.9.9-1.el10.noarch.rpm;name=aarch64_maven-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-unbound}"
SRC_URI[aarch64_maven-unbound.sha256sum] = "2a7680e88be645e9727441ead4d44c80e386444cb57fd1bc5ae298a68f61e434"
RPROVIDES:maven-unbound:aarch64 = "virtual/maven-jdk-binding"

RDEPENDS:maven = " \
 alternatives \
 bash \
 maven-lib \
 virtual/maven-jdk-binding \
 "
RDEPENDS:maven-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:maven-lib = " \
 apache-commons-cli \
 atinject \
 google-guice \
 guava \
 jakarta-annotations \
 jansi \
 javapackages-filesystem \
 maven-resolver \
 maven-shared-utils \
 maven-wagon \
 plexus-cipher \
 plexus-classworlds \
 plexus-containers-component-annotations \
 plexus-interpolation \
 plexus-sec-dispatcher \
 plexus-utils \
 sisu \
 slf4j \
 "
RDEPENDS:maven-openjdk21 = " \
 java-21-openjdk-headless \
 javapackages-tools \
 maven \
 "
RDEPENDS:maven-unbound = " \
 javapackages-tools \
 maven \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/maven-jdk-binding"

PROVIDES:append:aarch64 = " rpm/virtual/maven-jdk-binding"
