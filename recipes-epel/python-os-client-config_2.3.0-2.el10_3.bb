# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-os-client-config"
PV = "2.3.0"
PR = "2.el10_3"
PACKAGES = " \
 python-os-client-config-doc \
 python3-os-client-config \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-os-client-config-2.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbe46dbceff2b4e9f98cc50d0c8b76d7601f716c491be419bb79352d4187240f"

URI_x86_64_v2_python-os-client-config-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-os-client-config-doc-2.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-os-client-config-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-os-client-config-doc}"
SRC_URI[x86_64_v2_python-os-client-config-doc.sha256sum] = "3b0144d2ad9c78cde5a1dabad9e2f29707deed700f5be9271c203dba87ac7aec"

URI_x86_64_v2_python3-os-client-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-os-client-config-2.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-os-client-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-os-client-config}"
SRC_URI[x86_64_v2_python3-os-client-config.sha256sum] = "addb30d75bbb47ce231917c19846c1437ede77bb52d465fd9ccf4faa9ea00a0f"

URI_aarch64_python-os-client-config-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-os-client-config-doc-2.3.0-2.el10_3.noarch.rpm;name=aarch64_python-os-client-config-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-os-client-config-doc}"
SRC_URI[aarch64_python-os-client-config-doc.sha256sum] = "a786562f9133933b05ad420fa7e74f1e513dff9b31b86bbb0eda30e7c90aa63b"

URI_aarch64_python3-os-client-config = "${EPEL_MIRROR}/aarch64/Packages/p/python3-os-client-config-2.3.0-2.el10_3.noarch.rpm;name=aarch64_python3-os-client-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-os-client-config}"
SRC_URI[aarch64_python3-os-client-config.sha256sum] = "5d9119bfcaa3de685df03b22254e6d0de9df0a790fc7dc4eaf9565f19a562770"

RDEPENDS:python-os-client-config-doc = " \
 "
RDEPENDS:python3-os-client-config = " \
 python3 \
 python3-openstacksdk \
 python3-pbr \
 "
