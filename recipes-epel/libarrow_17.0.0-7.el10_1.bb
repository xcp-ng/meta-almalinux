# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libarrow"
PV = "17.0.0"
PR = "7.el10_1"
PACKAGES = " \
 libarrow \
 libarrow-acero-devel \
 libarrow-acero-libs \
 libarrow-dataset-devel \
 libarrow-dataset-glib-devel \
 libarrow-dataset-glib-libs \
 libarrow-dataset-libs \
 libarrow-devel \
 libarrow-doc \
 libarrow-flight-devel \
 libarrow-flight-libs \
 libarrow-glib-devel \
 libarrow-glib-libs \
 libarrow-python-devel \
 libarrow-python-flight-devel \
 libarrow-python-flight-libs \
 libarrow-python-libs \
 parquet-glib-devel \
 parquet-glib-libs \
 parquet-libs \
 parquet-libs-devel \
 python3-pyarrow \
 python3-pyarrow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libarrow-17.0.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab6b19b4f24a2808b991415c6111f3191cbfe65ee81f5e69ecd38fe4628b83fa"

URI_x86_64_v2_libarrow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow}"
SRC_URI[x86_64_v2_libarrow.sha256sum] = "fc2921859ec1ec72b027c8a8ccd35dae65e74e8769c7f247a561a5f2565ade1c"

URI_x86_64_v2_libarrow-acero-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-acero-devel-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-acero-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-acero-devel}"
SRC_URI[x86_64_v2_libarrow-acero-devel.sha256sum] = "af5424dc0104e4f83062d005b1181422487cc2ece67fb7bac79f1d1ff8ded78e"

URI_x86_64_v2_libarrow-acero-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-acero-libs-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-acero-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-acero-libs}"
SRC_URI[x86_64_v2_libarrow-acero-libs.sha256sum] = "1576afa213ff57c3d00ce96120dea6cd1c2c691b6d810a8233a6894a97485075"

URI_x86_64_v2_libarrow-dataset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-dataset-devel-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-dataset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-dataset-devel}"
SRC_URI[x86_64_v2_libarrow-dataset-devel.sha256sum] = "dbd969b7a5b89d8cd5ea72759bb14fbbf6183e14342ed8b5f5319c5f083f4f4c"

URI_x86_64_v2_libarrow-dataset-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-dataset-glib-devel-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-dataset-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-dataset-glib-devel}"
SRC_URI[x86_64_v2_libarrow-dataset-glib-devel.sha256sum] = "bad0e013e427b156f182b4e7e93b0b7611a6096c62671b692be9b85bc2a6d7d8"

URI_x86_64_v2_libarrow-dataset-glib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-dataset-glib-libs-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-dataset-glib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-dataset-glib-libs}"
SRC_URI[x86_64_v2_libarrow-dataset-glib-libs.sha256sum] = "63cbfee04a53925b2a30322dc97c4e1e5b0fef350140f41b8a9cbc733d73040b"

URI_x86_64_v2_libarrow-dataset-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-dataset-libs-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-dataset-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-dataset-libs}"
SRC_URI[x86_64_v2_libarrow-dataset-libs.sha256sum] = "1fbd1a184d2473269f85e02c9c426a9e4fdabfb29a8ecbbdc1d936db83878795"

URI_x86_64_v2_libarrow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-devel-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-devel}"
SRC_URI[x86_64_v2_libarrow-devel.sha256sum] = "db01898e427caa4ca9e1cd6878a93606738caf9abafb962c98453fc8a9bcec87"

URI_x86_64_v2_libarrow-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-doc-17.0.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libarrow-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-doc}"
SRC_URI[x86_64_v2_libarrow-doc.sha256sum] = "88e0fde49b974a4a7df537197c63b9d2c934f6c0bd9be32e44f6be199673bdf4"

URI_x86_64_v2_libarrow-flight-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-flight-devel-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-flight-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-flight-devel}"
SRC_URI[x86_64_v2_libarrow-flight-devel.sha256sum] = "3455bcaf9c535e0cef37c12f67af7597ca3d0e14f20e4e1f47547ce2e4877341"

URI_x86_64_v2_libarrow-flight-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-flight-libs-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-flight-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-flight-libs}"
SRC_URI[x86_64_v2_libarrow-flight-libs.sha256sum] = "2c3a9f01f4d979c5c5457658d4899909035f35d08b2ec286dcd98c7ed8c55f21"

URI_x86_64_v2_libarrow-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-glib-devel-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-glib-devel}"
SRC_URI[x86_64_v2_libarrow-glib-devel.sha256sum] = "7cd9f28baed7f967aded4fba55d7426087d0ab9a24a6aef5447278385253d167"

URI_x86_64_v2_libarrow-glib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-glib-libs-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-glib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-glib-libs}"
SRC_URI[x86_64_v2_libarrow-glib-libs.sha256sum] = "ceccc87dace4433d6493965a4d0cabcf25524fff9ec0f96985f5839946368cce"

URI_x86_64_v2_libarrow-python-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-python-devel-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-python-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-python-devel}"
SRC_URI[x86_64_v2_libarrow-python-devel.sha256sum] = "09b7f9b18dca42f0f790470021825b6a9cdb031abbe256da66376850e33229bd"

URI_x86_64_v2_libarrow-python-flight-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-python-flight-devel-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-python-flight-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-python-flight-devel}"
SRC_URI[x86_64_v2_libarrow-python-flight-devel.sha256sum] = "002c350a0ae53a5cc7a07f286b8bd5863cfe12f4c6a99f2f7c3d54974c0f7b20"

URI_x86_64_v2_libarrow-python-flight-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-python-flight-libs-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-python-flight-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-python-flight-libs}"
SRC_URI[x86_64_v2_libarrow-python-flight-libs.sha256sum] = "14e3acf40f0d88af1f6a48fca0a3a9ae886d97935112c00b322cc88ed73097bf"

URI_x86_64_v2_libarrow-python-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-python-libs-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-python-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-python-libs}"
SRC_URI[x86_64_v2_libarrow-python-libs.sha256sum] = "7365e74a5365fbbbe00860a8f8639b370288f2d974521b9f8550d35d412c5c51"

URI_x86_64_v2_parquet-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parquet-glib-devel-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parquet-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parquet-glib-devel}"
SRC_URI[x86_64_v2_parquet-glib-devel.sha256sum] = "c5e238e3408d5fdcacba484280f906ebebc00c824fba229254b63ab127eb6d8c"

URI_x86_64_v2_parquet-glib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parquet-glib-libs-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parquet-glib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parquet-glib-libs}"
SRC_URI[x86_64_v2_parquet-glib-libs.sha256sum] = "52d5cd7e4adc83f3d7d048ee6713435adb529bd6abade58b8c7f691da3deeef2"

URI_x86_64_v2_parquet-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parquet-libs-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parquet-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parquet-libs}"
SRC_URI[x86_64_v2_parquet-libs.sha256sum] = "3f559605218dc2b2baf11ea5e99828a48df782b7c626caf5a56f2bbaa492f3aa"

URI_x86_64_v2_parquet-libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parquet-libs-devel-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parquet-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parquet-libs-devel}"
SRC_URI[x86_64_v2_parquet-libs-devel.sha256sum] = "3ecbeba6e308f6c60614ec19a600e9abb3a0c56192f0ae2ef8faa1e541e2ca9c"

URI_x86_64_v2_python3-pyarrow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyarrow-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyarrow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyarrow}"
SRC_URI[x86_64_v2_python3-pyarrow.sha256sum] = "0c4d407b4c987d227c4ea4d1e1ad09a93896054e81dd93cb4cb79ec9fcbd2024"

URI_x86_64_v2_python3-pyarrow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyarrow-devel-17.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyarrow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyarrow-devel}"
SRC_URI[x86_64_v2_python3-pyarrow-devel.sha256sum] = "4464f4371d12e1f23d9bd8db6022d757b6684cf6779ad954c7d5f30cab5cdb36"

URI_aarch64_libarrow = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow}"
SRC_URI[aarch64_libarrow.sha256sum] = "6a1b2ba887c6731a019c1832cf3a8ba9e7acc59b7af0d14c94ba4c42289c5264"

URI_aarch64_libarrow-acero-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-acero-devel-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-acero-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-acero-devel}"
SRC_URI[aarch64_libarrow-acero-devel.sha256sum] = "56f317a3d36f8375553bcf0f11a3f50ac98f26153c240ccbd4e3236df1e77167"

URI_aarch64_libarrow-acero-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-acero-libs-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-acero-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-acero-libs}"
SRC_URI[aarch64_libarrow-acero-libs.sha256sum] = "e3992debc38640d548208d52b0a691a07103941bd1a79d606c0d8ac0efdc7c96"

URI_aarch64_libarrow-dataset-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-dataset-devel-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-dataset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-dataset-devel}"
SRC_URI[aarch64_libarrow-dataset-devel.sha256sum] = "11b86a5505a5340e31264f8d8eb4f63362e4063c3cde080158b626ec50174f91"

URI_aarch64_libarrow-dataset-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-dataset-glib-devel-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-dataset-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-dataset-glib-devel}"
SRC_URI[aarch64_libarrow-dataset-glib-devel.sha256sum] = "51b3988d034ca1c7189ef8ef6b563a0c83dd2dfa75224eab140e54c2d737f0a4"

URI_aarch64_libarrow-dataset-glib-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-dataset-glib-libs-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-dataset-glib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-dataset-glib-libs}"
SRC_URI[aarch64_libarrow-dataset-glib-libs.sha256sum] = "5e16d16711a392a7eee968e21c9332a37320c44506adea2bdf842881732a3001"

URI_aarch64_libarrow-dataset-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-dataset-libs-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-dataset-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-dataset-libs}"
SRC_URI[aarch64_libarrow-dataset-libs.sha256sum] = "d8560cfaea59c6c329587db3130602f7d3e6e501c8b87145228e92136726e8a5"

URI_aarch64_libarrow-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-devel-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-devel}"
SRC_URI[aarch64_libarrow-devel.sha256sum] = "72f3b46a34d836b9b0cb8dec5561f54adb74872305435d0c05d31ec0d39e57f2"

URI_aarch64_libarrow-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-doc-17.0.0-7.el10_1.noarch.rpm;name=aarch64_libarrow-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-doc}"
SRC_URI[aarch64_libarrow-doc.sha256sum] = "4d5599ae8d980b53820d44335f4a6a718d4180a393b6a7152f7e8a51e00eb35f"

URI_aarch64_libarrow-flight-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-flight-devel-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-flight-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-flight-devel}"
SRC_URI[aarch64_libarrow-flight-devel.sha256sum] = "9a717cb03970a2062f2cc3bb864bdd311fca1822a5e680a7977a2ebb4ca1656a"

URI_aarch64_libarrow-flight-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-flight-libs-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-flight-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-flight-libs}"
SRC_URI[aarch64_libarrow-flight-libs.sha256sum] = "57ad537f60bf526e6efc609a09f2121b77f92cdda4c32fe974eb72d2b32df4f2"

URI_aarch64_libarrow-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-glib-devel-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-glib-devel}"
SRC_URI[aarch64_libarrow-glib-devel.sha256sum] = "9660428c99ff68ac126f4940a1f721995be672ac234c8dc282ac8d2a2d182b00"

URI_aarch64_libarrow-glib-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-glib-libs-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-glib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-glib-libs}"
SRC_URI[aarch64_libarrow-glib-libs.sha256sum] = "f23914c1e6347adc23fdcda9d862f388bab431257a597522f56b8485be7b5b9b"

URI_aarch64_libarrow-python-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-python-devel-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-python-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-python-devel}"
SRC_URI[aarch64_libarrow-python-devel.sha256sum] = "846ef05567040d989fddb8df3b2673c85af139f1e7a1aa052fc54ea1e84b7f22"

URI_aarch64_libarrow-python-flight-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-python-flight-devel-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-python-flight-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-python-flight-devel}"
SRC_URI[aarch64_libarrow-python-flight-devel.sha256sum] = "f4333b6527d9bebe10691cdedba768424929c14bfc6625e04b65bc13ccc045f1"

URI_aarch64_libarrow-python-flight-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-python-flight-libs-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-python-flight-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-python-flight-libs}"
SRC_URI[aarch64_libarrow-python-flight-libs.sha256sum] = "7606ee706a88514dd544583f8a1956fb65e38c2bbda5dbd9c6a8fb2fbf67e230"

URI_aarch64_libarrow-python-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-python-libs-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_libarrow-python-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-python-libs}"
SRC_URI[aarch64_libarrow-python-libs.sha256sum] = "029a7c7d78d6cb6c7d7ccd15056b4aa26a751e705a5203cca974a7f28572b3af"

URI_aarch64_parquet-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/p/parquet-glib-devel-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_parquet-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_parquet-glib-devel}"
SRC_URI[aarch64_parquet-glib-devel.sha256sum] = "05722e823dbb453f9fa506a055487b02c58040e886ac8a749e8a180dd3d57a13"

URI_aarch64_parquet-glib-libs = "${EPEL_MIRROR}/aarch64/Packages/p/parquet-glib-libs-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_parquet-glib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_parquet-glib-libs}"
SRC_URI[aarch64_parquet-glib-libs.sha256sum] = "64f90acd440bf09c4b5c594863fa213f220f6e040c03de44da0b5d1d663c55c8"

URI_aarch64_parquet-libs = "${EPEL_MIRROR}/aarch64/Packages/p/parquet-libs-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_parquet-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_parquet-libs}"
SRC_URI[aarch64_parquet-libs.sha256sum] = "6ffe239f6dff7aabd7701c30bc9f385b3538db18bf583847d60e2bf2713d4675"

URI_aarch64_parquet-libs-devel = "${EPEL_MIRROR}/aarch64/Packages/p/parquet-libs-devel-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_parquet-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_parquet-libs-devel}"
SRC_URI[aarch64_parquet-libs-devel.sha256sum] = "c9f657c229990918607c393a823f1cb4af468c8cc2366169eb779edadcd3d7b6"

URI_aarch64_python3-pyarrow = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyarrow-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_python3-pyarrow;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyarrow}"
SRC_URI[aarch64_python3-pyarrow.sha256sum] = "e15ba9705063d3d6241f6b6d7adb352434523615d1a14e44f8e8cf1114577663"

URI_aarch64_python3-pyarrow-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyarrow-devel-17.0.0-7.el10_1.aarch64.rpm;name=aarch64_python3-pyarrow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyarrow-devel}"
SRC_URI[aarch64_python3-pyarrow-devel.sha256sum] = "67fa74088d504f278f4268d3cba7d154357d73994fbf6fb71cfca9a12c4107e1"

RDEPENDS:libarrow = " \
 bzip2-libs \
 glibc \
 libarrow-doc \
 libbrotli \
 libgcc \
 liborc2 \
 libstdc++ \
 libzstd \
 lz4-libs \
 re2 \
 snappy \
 utf8proc \
 zlib-ng-compat \
 "
RDEPENDS:libarrow-acero-devel = " \
 cmake-filesystem \
 libarrow \
 libarrow-acero-libs \
 libarrow-devel \
 libarrow-flight-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-acero-libs = " \
 glibc \
 libarrow \
 libarrow-doc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libarrow-dataset-devel = " \
 cmake-filesystem \
 libarrow \
 libarrow-acero-devel \
 libarrow-dataset-libs \
 parquet-libs-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-dataset-glib-devel = " \
 glib2-devel \
 libarrow \
 libarrow-dataset-devel \
 libarrow-dataset-glib-libs \
 libarrow-glib-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-dataset-glib-libs = " \
 glib2 \
 glibc \
 libarrow \
 libarrow-dataset-libs \
 libarrow-doc \
 libarrow-glib-libs \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libarrow-dataset-libs = " \
 glibc \
 libarrow \
 libarrow-acero-libs \
 libarrow-doc \
 libgcc \
 libstdc++ \
 parquet-libs \
 "
RDEPENDS:libarrow-devel = " \
 brotli-devel \
 bzip2-devel \
 cmake-filesystem \
 libarrow \
 libarrow-devel \
 libzstd-devel \
 lz4-devel \
 openssl-devel \
 pkgconf-pkg-config \
 rapidjson-devel \
 re2-devel \
 snappy-devel \
 utf8proc-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:libarrow-doc = " \
 "
RDEPENDS:libarrow-flight-devel = " \
 cmake-filesystem \
 glib2-devel \
 libarrow \
 libarrow-devel \
 libarrow-flight-devel \
 libarrow-flight-libs \
 libarrow-glib-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-flight-libs = " \
 abseil-cpp \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 libarrow \
 libarrow-doc \
 libarrow-glib-libs \
 libgcc \
 libstdc++ \
 protobuf \
 "
RDEPENDS:libarrow-glib-devel = " \
 glib2-devel \
 gobject-introspection-devel \
 libarrow \
 libarrow-devel \
 libarrow-glib-devel \
 libarrow-glib-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-glib-libs = " \
 glib2 \
 glibc \
 libarrow \
 libarrow-acero-libs \
 libarrow-doc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libarrow-python-devel = " \
 libarrow \
 libarrow-devel \
 libarrow-python-libs \
 python3-devel \
 "
RDEPENDS:libarrow-python-flight-devel = " \
 libarrow \
 libarrow-flight-devel \
 libarrow-python-devel \
 libarrow-python-flight-libs \
 "
RDEPENDS:libarrow-python-flight-libs = " \
 glibc \
 libarrow \
 libarrow-doc \
 libarrow-flight-libs \
 libarrow-python-libs \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:libarrow-python-libs = " \
 glibc \
 libarrow \
 libarrow-doc \
 libgcc \
 libstdc++ \
 python3 \
 python3-numpy \
 "
RDEPENDS:parquet-glib-devel = " \
 glib2-devel \
 libarrow \
 libarrow-glib-devel \
 parquet-glib-libs \
 parquet-libs-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:parquet-glib-libs = " \
 glib2 \
 glibc \
 libarrow \
 libarrow-doc \
 libarrow-glib-libs \
 libgcc \
 libstdc++ \
 parquet-libs \
 "
RDEPENDS:parquet-libs = " \
 boost-program-options \
 glibc \
 libarrow \
 libarrow-doc \
 libgcc \
 libstdc++ \
 openssl-libs \
 thrift \
 "
RDEPENDS:parquet-libs-devel = " \
 cmake-filesystem \
 glib2-devel \
 libarrow \
 libarrow-devel \
 libarrow-glib-devel \
 parquet-libs \
 parquet-libs-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:python3-pyarrow = " \
 glibc \
 libarrow \
 libarrow-acero-libs \
 libarrow-dataset-libs \
 libarrow-flight-libs \
 libgcc \
 libstdc++ \
 parquet-libs \
 python3 \
 python3-numpy \
 "
RDEPENDS:python3-pyarrow-devel = " \
 python3-pyarrow \
 "
