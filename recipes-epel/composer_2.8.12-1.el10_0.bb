# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "composer"
PV = "2.8.12"
PR = "1.el10_0"
PACKAGES = " \
 composer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/composer-2.8.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7edff54861251b02a04178cf311880644eb6b326171118df0dffd36554fbd47"

URI_x86_64_v2_composer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/composer-2.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_composer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_composer}"
SRC_URI[x86_64_v2_composer.sha256sum] = "dd920a1619c1aaafa70cb4a344ea9ba0672cf6384f68569850c754b65f7fd6a0"

URI_aarch64_composer = "${EPEL_MIRROR}/aarch64/Packages/c/composer-2.8.12-1.el10_0.noarch.rpm;name=aarch64_composer;unpack=0"
SRC_URI:append = " ${URI_aarch64_composer}"
SRC_URI[aarch64_composer.sha256sum] = "36479b95c086a1da7d32f007de96e0823a31dc1e6865b7a5aecd4502b73bc9f6"

RDEPENDS:composer = " \
 ca-certificates \
 php-cli \
 php-common \
 php-intl \
 php-mbstring \
 php-pecl-zip \
 php-process \
 php-xml \
 "
