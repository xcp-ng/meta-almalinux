# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bumpalo"
PV = "3.19.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-bumpalo+allocator-api2-devel \
 rust-bumpalo+allocator_api-devel \
 rust-bumpalo+boxed-devel \
 rust-bumpalo+collections-devel \
 rust-bumpalo+default-devel \
 rust-bumpalo+serde-devel \
 rust-bumpalo+std-devel \
 rust-bumpalo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bumpalo-3.19.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "625dd28201d5d31d39e712e01384d5d6de7bcffc5ff7e9f04b42fb5dea240df2"

URI_x86_64_v2_rust-bumpalo+allocator-api2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+allocator-api2-devel-3.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+allocator-api2-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+allocator-api2-devel.sha256sum] = "71dd8d7b3fd7f9774f2afddf582bf4abe3c55344098e61c947e6ea6b57276c4c"

URI_x86_64_v2_rust-bumpalo+allocator_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+allocator_api-devel-3.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+allocator_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+allocator_api-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+allocator_api-devel.sha256sum] = "fb69ecd267b763add6cd80489290a7e328665ff2711045d908f95c0f3db6121d"

URI_x86_64_v2_rust-bumpalo+boxed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+boxed-devel-3.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+boxed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+boxed-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+boxed-devel.sha256sum] = "31dbf187e966d184f83cf0525c317939862fb5d991036630b9c9d80616900cc7"

URI_x86_64_v2_rust-bumpalo+collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+collections-devel-3.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+collections-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+collections-devel.sha256sum] = "a1bc8d3e98209efeb45a1d6474085dea81afef881091327333917cba05ccb710"

URI_x86_64_v2_rust-bumpalo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+default-devel-3.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+default-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+default-devel.sha256sum] = "38157da6518170a6d465bf1d013eed97a94f1e1fceea12db8d47f4e177a51afa"

URI_x86_64_v2_rust-bumpalo+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+serde-devel-3.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+serde-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+serde-devel.sha256sum] = "378b58a53fab2e49e2b0e1c5508070922442b2e7ffca438286d6e6ed11e4e444"

URI_x86_64_v2_rust-bumpalo+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+std-devel-3.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+std-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+std-devel.sha256sum] = "31b42318448fef18204c8d6e8a9a9a9b5c343cfa3a0f8ee6da1a0d943bdb05c3"

URI_x86_64_v2_rust-bumpalo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo-devel-3.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo-devel}"
SRC_URI[x86_64_v2_rust-bumpalo-devel.sha256sum] = "d8f2074847285da6e54995cfdbc07896ff970de888ae4a8473d53e0f0050c028"

URI_aarch64_rust-bumpalo+allocator-api2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+allocator-api2-devel-3.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-bumpalo+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+allocator-api2-devel}"
SRC_URI[aarch64_rust-bumpalo+allocator-api2-devel.sha256sum] = "d35675bd28df9a7ffa1db9b57acf9b803ecce65132e25c20f004e3209cf7d945"

URI_aarch64_rust-bumpalo+allocator_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+allocator_api-devel-3.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-bumpalo+allocator_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+allocator_api-devel}"
SRC_URI[aarch64_rust-bumpalo+allocator_api-devel.sha256sum] = "2e0dc05ffccd26a91cf85f916509b6d5d0cdfd96836b00b02177e8c15a2d289e"

URI_aarch64_rust-bumpalo+boxed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+boxed-devel-3.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-bumpalo+boxed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+boxed-devel}"
SRC_URI[aarch64_rust-bumpalo+boxed-devel.sha256sum] = "2e8cbdb72603d1bb818eebf860e7a60157df6b76932070da528fc66e4da576aa"

URI_aarch64_rust-bumpalo+collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+collections-devel-3.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-bumpalo+collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+collections-devel}"
SRC_URI[aarch64_rust-bumpalo+collections-devel.sha256sum] = "6f0108af43fbb60ede56bfc6e6293ed4088f20c79aec77c428f018fefbf757e9"

URI_aarch64_rust-bumpalo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+default-devel-3.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-bumpalo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+default-devel}"
SRC_URI[aarch64_rust-bumpalo+default-devel.sha256sum] = "d36ff7489cdf72ecb3ecf73373c41322b122334c3c4e4fa34ec6cd6ce8b62808"

URI_aarch64_rust-bumpalo+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+serde-devel-3.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-bumpalo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+serde-devel}"
SRC_URI[aarch64_rust-bumpalo+serde-devel.sha256sum] = "a0f285089f493a908538b41a030ae5fec62a65088469c0c82b116d759d5c3a6a"

URI_aarch64_rust-bumpalo+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+std-devel-3.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-bumpalo+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+std-devel}"
SRC_URI[aarch64_rust-bumpalo+std-devel.sha256sum] = "08af32a10755da199f32c3af426f62cae2c23dee0508ee12bfff94fdb2989bae"

URI_aarch64_rust-bumpalo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo-devel-3.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-bumpalo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo-devel}"
SRC_URI[aarch64_rust-bumpalo-devel.sha256sum] = "59adb3716f216e8432609e25a2eb7e7b8a3b68d19ead6bdb93fb18804dee4ec0"

RDEPENDS:rust-bumpalo+allocator-api2-devel = " \
 cargo \
 rust-allocator-api2-devel \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+allocator_api-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+boxed-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+collections-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+default-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+serde-devel = " \
 cargo \
 rust-bumpalo-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-bumpalo+std-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo-devel = " \
 cargo \
 rust \
 "
