# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opkssh"
PV = "0.16.0"
PR = "1.el10_2"
PACKAGES = " \
 opkssh \
 opkssh-doc \
 opkssh-server \
 opkssh-server-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opkssh-0.16.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a764a64603ce479d685e35c814c33574cade6d9e42ff5ee2d46aa23c36d721c"

URI_x86_64_v2_opkssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-0.16.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opkssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opkssh}"
SRC_URI[x86_64_v2_opkssh.sha256sum] = "a1e90cf157693822cf23685f83c4a76a6cb75578f136fd77734f1dc50f316a19"

URI_x86_64_v2_opkssh-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-doc-0.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opkssh-doc}"
SRC_URI[x86_64_v2_opkssh-doc.sha256sum] = "3ffa83f380d4ebf687ff7d94ae521ae50b8ee195228d07cd53c9b34734d30192"

URI_x86_64_v2_opkssh-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-server-0.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opkssh-server}"
SRC_URI[x86_64_v2_opkssh-server.sha256sum] = "bc18bdb1a7c3cb8c7bfb78fcd7132572311e91f1b13db5a48171f22b8761ab76"

URI_x86_64_v2_opkssh-server-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-server-selinux-0.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-server-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opkssh-server-selinux}"
SRC_URI[x86_64_v2_opkssh-server-selinux.sha256sum] = "e14353bad4c967c3bfa08da6bd59e3299e3fa30b9e642528204b0f06193d7e24"

URI_aarch64_opkssh = "${EPEL_MIRROR}/aarch64/Packages/o/opkssh-0.16.0-1.el10_2.aarch64.rpm;name=aarch64_opkssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_opkssh}"
SRC_URI[aarch64_opkssh.sha256sum] = "deb7b50b4c5a0af115ecabcce980fda3df111c17944283e1b7d161ffd15e48fb"

URI_aarch64_opkssh-doc = "${EPEL_MIRROR}/aarch64/Packages/o/opkssh-doc-0.16.0-1.el10_2.noarch.rpm;name=aarch64_opkssh-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opkssh-doc}"
SRC_URI[aarch64_opkssh-doc.sha256sum] = "1118f37140dd0ec8c1253e03f169eaf0fe8676e11bc57dbe84c7a8c80d173313"

URI_aarch64_opkssh-server = "${EPEL_MIRROR}/aarch64/Packages/o/opkssh-server-0.16.0-1.el10_2.noarch.rpm;name=aarch64_opkssh-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_opkssh-server}"
SRC_URI[aarch64_opkssh-server.sha256sum] = "2475c8e29845d49fbcf31259a91724da49650b789f0025c056eba3c3e092397b"

URI_aarch64_opkssh-server-selinux = "${EPEL_MIRROR}/aarch64/Packages/o/opkssh-server-selinux-0.16.0-1.el10_2.noarch.rpm;name=aarch64_opkssh-server-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_opkssh-server-selinux}"
SRC_URI[aarch64_opkssh-server-selinux.sha256sum] = "f71fbd3ed07adb78fe96b32981eee87814cef3297b4ea74b702951fd1cfe414e"

RDEPENDS:opkssh = " \
 glibc \
 shadow-utils \
 "
RDEPENDS:opkssh-doc = " \
 "
RDEPENDS:opkssh-server = " \
 bash \
 opkssh \
 opkssh-server-selinux \
 "
RDEPENDS:opkssh-server-selinux = " \
 bash \
 selinux-policy-targeted \
 "
