# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-CSV_XS"
PV = "1.62"
PR = "1.el10_1"
PACKAGES = " \
 perl-Text-CSV_XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-CSV_XS-1.62-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33e881c34b0e1af38f01d27f264470b697994f6d08d5aa48d48be25cf1fb2bfa"

URI_x86_64_v2_perl-Text-CSV_XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-CSV_XS-1.62-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Text-CSV_XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-CSV_XS}"
SRC_URI[x86_64_v2_perl-Text-CSV_XS.sha256sum] = "36fc5225fa139184ea1934668428a628cecb0aff695345f1d6a35cb15422f60e"

URI_aarch64_perl-Text-CSV_XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-CSV_XS-1.62-1.el10_1.aarch64.rpm;name=aarch64_perl-Text-CSV_XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-CSV_XS}"
SRC_URI[aarch64_perl-Text-CSV_XS.sha256sum] = "bc8188a0cc014cf58a8d0bd346117f070ae0adbcb16c83c8a7ca42985045699e"

RDEPENDS:perl-Text-CSV_XS = " \
 glibc \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-IO \
 perl-UNIVERSAL-isa \
 perl-libs \
 perl-vars \
 "
