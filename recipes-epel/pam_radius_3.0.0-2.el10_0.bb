# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam_radius"
PV = "3.0.0"
PR = "2.el10_0"
PACKAGES = " \
 pam_radius \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam_radius-3.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0155d6cafd5c856075c58c80a95cd8343d783c784a6f4527b3ef515495283306"

URI_x86_64_v2_pam_radius = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_radius-3.0.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_radius;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_radius}"
SRC_URI[x86_64_v2_pam_radius.sha256sum] = "3fdf13bab7c66b774982ac8417f02e5d2d95f92bae21f129c49b231cb87ee11a"

URI_aarch64_pam_radius = "${EPEL_MIRROR}/aarch64/Packages/p/pam_radius-3.0.0-2.el10_0.aarch64.rpm;name=aarch64_pam_radius;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_radius}"
SRC_URI[aarch64_pam_radius.sha256sum] = "af267ea0cb58c116b350596a10245403381ba208ae417879f9b513bb0e56c644"

RDEPENDS:pam_radius = " \
 bash \
 glibc \
 pam \
 pam-libs \
 "
