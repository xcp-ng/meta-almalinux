# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Dumper-Concise"
PV = "2.023"
PR = "24.el10_0"
PACKAGES = " \
 perl-Data-Dumper-Concise \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Dumper-Concise-2.023-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68319208264152f9c18c6130c88f5d1e0b013220c5f2ecd0fb8033c1c0ea69f8"

URI_x86_64_v2_perl-Data-Dumper-Concise = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Dumper-Concise-2.023-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Dumper-Concise;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Dumper-Concise}"
SRC_URI[x86_64_v2_perl-Data-Dumper-Concise.sha256sum] = "0386c40d015c75ad9f04f87b78f7c5d3389242e117b1ca9da93f7ca70009436f"

URI_aarch64_perl-Data-Dumper-Concise = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Dumper-Concise-2.023-24.el10_0.noarch.rpm;name=aarch64_perl-Data-Dumper-Concise;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Dumper-Concise}"
SRC_URI[aarch64_perl-Data-Dumper-Concise.sha256sum] = "c0cb055107d74dc3b77367b3b071c86e4fea1f2bf31b541565141ffb83f26c06"

RDEPENDS:perl-Data-Dumper-Concise = " \
 perl-Data-Dumper \
 perl-Data-Dumper-Concise \
 perl-Devel-ArgNames \
 perl-Exporter \
 perl-libs \
 "
