# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksmtp"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ksmtp \
 ksmtp-devel \
 ksmtp-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ksmtp-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "034927d7022bce55c1f5f93de0439a4fb4e095473ef68f9f5461ea8f2613e8a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksmtp;unpack=0"
SRC_URI[x86_64_v2_ksmtp.sha256sum] = "262e24c05b99ad21ca69d17a6f1975f31b7cac29d9c769a7ba40900149da9896"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksmtp-devel;unpack=0"
SRC_URI[x86_64_v2_ksmtp-devel.sha256sum] = "d685bcc545fb9889d672b0348e34181ebdf4a4ffcc237981b46615c9a7e8c46e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ksmtp-doc;unpack=0"
SRC_URI[x86_64_v2_ksmtp-doc.sha256sum] = "52e75d3b6556c4e5a576d6969b87fa658ec22fa14c33033df2ae8b1e715ff3a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ksmtp;unpack=0"
SRC_URI[aarch64_ksmtp.sha256sum] = "89ccfff47991d11ed164812226daa246eb900593496e41f559bf5c9e340a285e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ksmtp-devel;unpack=0"
SRC_URI[aarch64_ksmtp-devel.sha256sum] = "0ba80041cb69dd0583cfc055316e54a655b54f3b0197846f819c470bb86f13c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_ksmtp-doc;unpack=0"
SRC_URI[aarch64_ksmtp-doc.sha256sum] = "ee86c5af17ddf73c64b8bb085a0768f50658ea0c11bdbae8394473bffc135a87"

RDEPENDS:ksmtp = " \
 cyrus-sasl-lib \
 cyrus-sasl-plain \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:ksmtp-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kmime-devel \
 ksmtp \
 "
RDEPENDS:ksmtp-doc = " \
 "
