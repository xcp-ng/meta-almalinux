# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-docker"
PV = "7.1.0"
PR = "11.el10_3"
PACKAGES = " \
 python3-docker \
 python3-docker+ssh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-docker-7.1.0-11.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edbd3ed8a01ab3eed7fa08509f3e52e50a3d3efb3c24d0268c0fac3180c025c1"

URI_x86_64_v2_python3-docker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-docker-7.1.0-11.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-docker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-docker}"
SRC_URI[x86_64_v2_python3-docker.sha256sum] = "14d72e5f675676407bf37fc92e4bfe25501f384ac8f77e27b5897a3b5dc75881"

URI_x86_64_v2_python3-docker+ssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-docker+ssh-7.1.0-11.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-docker+ssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-docker+ssh}"
SRC_URI[x86_64_v2_python3-docker+ssh.sha256sum] = "cb2a2cdbec9eaaca9745cbfbb62cacc5b85cff59b1ed9f88f4c2fd9b4908048b"

URI_aarch64_python3-docker = "${EPEL_MIRROR}/aarch64/Packages/p/python3-docker-7.1.0-11.el10_3.noarch.rpm;name=aarch64_python3-docker;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-docker}"
SRC_URI[aarch64_python3-docker.sha256sum] = "75f83d764eb81a072667c3b8c180425b8445594cd4396890e1edb0f812afec5c"

URI_aarch64_python3-docker+ssh = "${EPEL_MIRROR}/aarch64/Packages/p/python3-docker+ssh-7.1.0-11.el10_3.noarch.rpm;name=aarch64_python3-docker+ssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-docker+ssh}"
SRC_URI[aarch64_python3-docker+ssh.sha256sum] = "875b69b61a34493613a31ee65adc6db2ea933ee78d3613d2fe4342c1bdbcd574"

RDEPENDS:python3-docker = " \
 python3 \
 python3-requests \
 python3-urllib3 \
 "
RDEPENDS:python3-docker+ssh = " \
 python3 \
 python3-docker \
 python3-paramiko \
 "
