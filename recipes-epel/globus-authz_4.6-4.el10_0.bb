# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-authz"
PV = "4.6"
PR = "4.el10_0"
PACKAGES = " \
 globus-authz \
 globus-authz-devel \
 globus-authz-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-authz-4.6-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a040b44dc5cd65e381bd02d5baf22179dca7d9b81119477df728bc8e04f3c6ec"

URI_x86_64_v2_globus-authz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-authz-4.6-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-authz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-authz}"
SRC_URI[x86_64_v2_globus-authz.sha256sum] = "e2bc04cd5510691c93bbfb831c63c3a916315573e314281b75e0a793063b648a"

URI_x86_64_v2_globus-authz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-authz-devel-4.6-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-authz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-authz-devel}"
SRC_URI[x86_64_v2_globus-authz-devel.sha256sum] = "911e9ced41725bcb844b186092795e52a6e77c2768857dd5ad1f6c257a24056e"

URI_x86_64_v2_globus-authz-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-authz-doc-4.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-authz-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-authz-doc}"
SRC_URI[x86_64_v2_globus-authz-doc.sha256sum] = "9a5ed4cde1307c9e1ce917b7cf7127f56c4528d62cbef4a732304b214171a051"

URI_aarch64_globus-authz = "${EPEL_MIRROR}/aarch64/Packages/g/globus-authz-4.6-4.el10_0.aarch64.rpm;name=aarch64_globus-authz;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-authz}"
SRC_URI[aarch64_globus-authz.sha256sum] = "38b49948ceef8d6503ac423997c9ae6f95637b0efdbd6d55aa5fd0ba2585d6dd"

URI_aarch64_globus-authz-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-authz-devel-4.6-4.el10_0.aarch64.rpm;name=aarch64_globus-authz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-authz-devel}"
SRC_URI[aarch64_globus-authz-devel.sha256sum] = "22161371ec408052edd364ccf824366054fd314b4a1be6f63a1f1c006821fa7e"

URI_aarch64_globus-authz-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-authz-doc-4.6-4.el10_0.noarch.rpm;name=aarch64_globus-authz-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-authz-doc}"
SRC_URI[aarch64_globus-authz-doc.sha256sum] = "5dcab77dba92c489ba11f52bf08da75b633c11c2735091be53db5349f108d405"

RDEPENDS:globus-authz = " \
 glibc \
 globus-authz-callout-error \
 globus-callout \
 globus-common \
 globus-gsi-sysconfig \
 "
RDEPENDS:globus-authz-devel = " \
 globus-authz \
 globus-authz-callout-error-devel \
 globus-callout-devel \
 globus-common-devel \
 globus-gsi-sysconfig-devel \
 globus-gssapi-gsi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-authz-doc = " \
 "
