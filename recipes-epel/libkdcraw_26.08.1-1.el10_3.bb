# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdcraw"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 libkdcraw \
 libkdcraw-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libkdcraw-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0782b021e7107e60b9001550e506e4bba105f27858cee4026264747bcdb070ee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdcraw-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdcraw;unpack=0"
SRC_URI[x86_64_v2_libkdcraw.sha256sum] = "a5f340d70b17a272219436d972545fc5aeedf73907e018f7ccd706ac56f56388"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdcraw-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdcraw-devel;unpack=0"
SRC_URI[x86_64_v2_libkdcraw-devel.sha256sum] = "2f30229d020c42f8d221bc731c3291300050066aa6f6683092a261c02d769acc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkdcraw-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkdcraw;unpack=0"
SRC_URI[aarch64_libkdcraw.sha256sum] = "949b96e8f9833d29d0062e9b01edc70c6ffcd4fd874786c08a05b1a446eaa2be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkdcraw-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkdcraw-devel;unpack=0"
SRC_URI[aarch64_libkdcraw-devel.sha256sum] = "87af7e05584854dda5f757a992367ef732cb706926ffc41b93d9667a36fd0068"

RDEPENDS:libkdcraw = " \
 LibRaw \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdcraw-devel = " \
 cmake-filesystem \
 libkdcraw \
 qt6-qtbase-devel \
 "
