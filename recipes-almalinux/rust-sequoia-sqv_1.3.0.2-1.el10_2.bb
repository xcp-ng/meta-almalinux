# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-sqv"
PV = "1.3.0.2"
PR = "1.el10_2"
PACKAGES = " \
 sequoia-sqv \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-sequoia-sqv-1.3.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ed11e97da6e7243467965d7767036807e2a191d7cc42e2ed28e62513a0700417"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sequoia-sqv-1.3.0.2-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_sequoia-sqv;unpack=0"
SRC_URI[x86_64_v2_sequoia-sqv.sha256sum] = "fb4d59b0451d82abdc25879b8e1c5b1f888cc75e56e1e7fdd7aed87e0f6a9b59"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sequoia-sqv-1.3.0.2-1.el10_2.aarch64.rpm;name=aarch64_sequoia-sqv;unpack=0"
SRC_URI[aarch64_sequoia-sqv.sha256sum] = "5ccf0f82b66c7ac38ebe7a407b173d53fc586cf06ab51375de89403477aa3095"

RDEPENDS:sequoia-sqv = " \
 glibc \
 libgcc \
 openssl-libs \
 "
