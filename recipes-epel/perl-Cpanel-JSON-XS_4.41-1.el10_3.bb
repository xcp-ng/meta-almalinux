# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cpanel-JSON-XS"
PV = "4.41"
PR = "1.el10_3"
PACKAGES = " \
 perl-Cpanel-JSON-XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cpanel-JSON-XS-4.41-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f18678720dd090633c1821b9760e767b572490ff89d73fea30303ddcf59aa6c"

URI_x86_64_v2_perl-Cpanel-JSON-XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cpanel-JSON-XS-4.41-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Cpanel-JSON-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cpanel-JSON-XS}"
SRC_URI[x86_64_v2_perl-Cpanel-JSON-XS.sha256sum] = "2145de96a6768fec162238e7992b56333332a6b1dadd2b781c042c0d2fa46c44"

URI_aarch64_perl-Cpanel-JSON-XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cpanel-JSON-XS-4.41-1.el10_3.aarch64.rpm;name=aarch64_perl-Cpanel-JSON-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cpanel-JSON-XS}"
SRC_URI[aarch64_perl-Cpanel-JSON-XS.sha256sum] = "a9f830f0fa3200911d11783238358c4bcc8adc26aa8501d12661585672c64d40"

RDEPENDS:perl-Cpanel-JSON-XS = " \
 glibc \
 perl-Carp \
 perl-Cpanel-JSON-XS \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-overload \
 "
