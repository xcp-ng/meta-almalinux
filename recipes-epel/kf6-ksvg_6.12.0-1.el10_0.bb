# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ksvg"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-ksvg \
 kf6-ksvg-devel \
 kf6-ksvg-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ksvg-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c879f5f10ab8f730fd919cac77b05ff115a2472e539ae21c31bae5f0dac1c60"

URI_x86_64_v2_kf6-ksvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ksvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg}"
SRC_URI[x86_64_v2_kf6-ksvg.sha256sum] = "8321c0d490a3b134f0eaa90ec23eb99a38a11be2a7d37586496a21bdda1c4173"

URI_x86_64_v2_kf6-ksvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ksvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg-devel}"
SRC_URI[x86_64_v2_kf6-ksvg-devel.sha256sum] = "c99c690fe02b2697be6c4514928b657e042ff5d8f0e57b9e9112665a497f4510"

URI_x86_64_v2_kf6-ksvg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ksvg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg-doc}"
SRC_URI[x86_64_v2_kf6-ksvg-doc.sha256sum] = "d7a022a38c7ba0bced0a32c8670bef82dd1c2dda95f625b3df97ccbb282bc036"

URI_aarch64_kf6-ksvg = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-ksvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg}"
SRC_URI[aarch64_kf6-ksvg.sha256sum] = "96da066454614467db3d100070b39aaa566df7eb4718c3249a64b931c3049527"

URI_aarch64_kf6-ksvg-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-ksvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg-devel}"
SRC_URI[aarch64_kf6-ksvg-devel.sha256sum] = "759e87def016152df57f2d08ccf899d3d90011de59884f288fecb036f58453de"

URI_aarch64_kf6-ksvg-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-ksvg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg-doc}"
SRC_URI[aarch64_kf6-ksvg-doc.sha256sum] = "94ad1e856dca63d8e1f0ceef17df180762adf927571b731c791e78a6320b7910"

RDEPENDS:kf6-ksvg = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kirigami \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:kf6-ksvg-devel = " \
 cmake-filesystem \
 kf6-ksvg \
 "
RDEPENDS:kf6-ksvg-doc = " \
 "
