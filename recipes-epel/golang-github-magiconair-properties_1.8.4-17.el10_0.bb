# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-magiconair-properties"
PV = "1.8.4"
PR = "17.el10_0"
PACKAGES = " \
 golang-github-magiconair-properties-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-magiconair-properties-1.8.4-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e725277dbb947414a616f55dda63c20eb4f09ef0ceed177a272e6e70195c4b0f"

URI_x86_64_v2_golang-github-magiconair-properties-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-magiconair-properties-devel-1.8.4-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-magiconair-properties-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-magiconair-properties-devel}"
SRC_URI[x86_64_v2_golang-github-magiconair-properties-devel.sha256sum] = "e583c5e93503941d67d26b8fd3cfa197f06d1207c349d563b0898f7c32773137"

URI_aarch64_golang-github-magiconair-properties-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-magiconair-properties-devel-1.8.4-17.el10_0.noarch.rpm;name=aarch64_golang-github-magiconair-properties-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-magiconair-properties-devel}"
SRC_URI[aarch64_golang-github-magiconair-properties-devel.sha256sum] = "da55aac923811d7b654c2548519f791786c7e20fe224ab2ad20c7d3d0e72be91"

RDEPENDS:golang-github-magiconair-properties-devel = " \
 go-filesystem \
 "
