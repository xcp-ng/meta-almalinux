# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prosody"
PV = "13.0.5"
PR = "1.el10_1"
PACKAGES = " \
 prosody \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/prosody-13.0.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fc68591ec759f5c1aa9217df99b6f82bdfc025e385ef65910abc012f15e1e022"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prosody-13.0.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_prosody;unpack=0"
SRC_URI[x86_64_v2_prosody.sha256sum] = "f773f186acbfdd38f36f100d73cc583c3828b3be589ba60dbe33e22755bc16b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/prosody-13.0.5-1.el10_1.aarch64.rpm;name=aarch64_prosody;unpack=0"
SRC_URI[aarch64_prosody.sha256sum] = "0e302ee4724982f8a9a9d8e1f29483d6901507b4757f9f201ed6ae0955d3af27"

RDEPENDS:prosody = " \
 bash \
 glibc \
 libicu \
 lua \
 lua-expat \
 lua-filesystem \
 lua-libs \
 lua-sec \
 lua-socket \
 openssl \
 openssl-libs \
 shadow-utils \
 systemd \
 "
