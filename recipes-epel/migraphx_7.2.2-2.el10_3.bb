# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "migraphx"
PV = "7.2.2"
PR = "2.el10_3"
PACKAGES:x86_64_v2 = " \
 migraphx \
 migraphx-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/m/migraphx-7.2.2-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8a8342a1895c0a59233bfed1753ce63e7aadf4372af9f91bc3323664a0a3363"

URI_x86_64_v2_migraphx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/migraphx-7.2.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_migraphx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_migraphx}"
SRC_URI[x86_64_v2_migraphx.sha256sum] = "d318ff942a608309dde952906aa1101c609ee14c82910591bff8b48751d4449d"

URI_x86_64_v2_migraphx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/migraphx-devel-7.2.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_migraphx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_migraphx-devel}"
SRC_URI[x86_64_v2_migraphx-devel.sha256sum] = "c0bee577b15af45153be76add7d205bab121d6cc86b8c216995cd7693dd583de"

RDEPENDS:migraphx = " \
 glibc \
 libgcc \
 libstdc++ \
 miopen \
 protobuf \
 rocblas \
 rocm-hip \
 rocm-runtime \
 sqlite-libs \
 "
RDEPENDS:migraphx-devel = " \
 cmake-filesystem \
 migraphx \
 "
