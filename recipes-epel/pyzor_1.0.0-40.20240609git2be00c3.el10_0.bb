# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyzor"
PV = "1.0.0"
PR = "40.20240609git2be00c3.el10_0"
PACKAGES = " \
 pyzor \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pyzor-1.0.0-40.20240609git2be00c3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f41562a09f348951aa38db4507b9776fcd7301b538be700bb192061cb7ed900f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pyzor-1.0.0-40.20240609git2be00c3.el10_0.noarch.rpm;name=aarch64_pyzor;unpack=0"
SRC_URI[aarch64_pyzor.sha256sum] = "696deea11754cf80fcdfe23b880e7e5242cf0f43bef196da0d821e65bb5c5f95"

RDEPENDS:pyzor = " \
 python3 \
 "
