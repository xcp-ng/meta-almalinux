# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lbzip2"
PV = "2.5"
PR = "31.20171011gitb6dc48a.el10_1"
PACKAGES = " \
 lbzip2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lbzip2-2.5-31.20171011gitb6dc48a.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "608c2ae29647776095dd8c4943b1d55e8aef64b2243fb44647dbbb9ac7a37eba"

URI_x86_64_v2_lbzip2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lbzip2-2.5-31.20171011gitb6dc48a.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lbzip2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lbzip2}"
SRC_URI[x86_64_v2_lbzip2.sha256sum] = "07fb0aeaf3c311455940700355fa81e9f66c1abb182d5e93405354a5905039a3"

URI_aarch64_lbzip2 = "${EPEL_MIRROR}/aarch64/Packages/l/lbzip2-2.5-31.20171011gitb6dc48a.el10_1.aarch64.rpm;name=aarch64_lbzip2;unpack=0"
SRC_URI:append = " ${URI_aarch64_lbzip2}"
SRC_URI[aarch64_lbzip2.sha256sum] = "4049912aebaab6dbb9124c74852765f2496bce156283fa416ddf6c9528d8d1fc"

RDEPENDS:lbzip2 = " \
 glibc \
 "
