# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pesign"
PV = "116"
PR = "8.el10.alma.1"
PACKAGES = " \
 pesign \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pesign-116-8.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d55a42aee4cee0e2b2b0bfc796e51343a32b04d0a8de77197d578087ee9d562f"

URI_x86_64_v2_pesign = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pesign-116-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_pesign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pesign}"
SRC_URI[x86_64_v2_pesign.sha256sum] = "7f6bbafdf9e1a92cda7464d974d59c019b3b6dc24b74ba6e9ccae05ed276432c"

URI_aarch64_pesign = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pesign-116-8.el10.alma.1.aarch64.rpm;name=aarch64_pesign;unpack=0"
SRC_URI:append = " ${URI_aarch64_pesign}"
SRC_URI[aarch64_pesign.sha256sum] = "44bc97ad2cda705d75307b631e5be53d10b7d1bb07883b22c18324c702773c51"

RDEPENDS:pesign = " \
 bash \
 efivar-libs \
 glibc \
 libuuid \
 nspr \
 nss \
 nss-tools \
 nss-util \
 popt \
 python3 \
 rpm \
 shadow-utils \
 "
