# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dbus-glib"
PV = "0.112"
PR = "8.el10_0"
PACKAGES = " \
 dbus-glib \
 dbus-glib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dbus-glib-0.112-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdae8eb87a5a5fa6a1e2dd286364d02f86f23b30632e73c38ace78fcbebb96c5"

URI_x86_64_v2_dbus-glib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dbus-glib-0.112-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dbus-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-glib}"
SRC_URI[x86_64_v2_dbus-glib.sha256sum] = "7e18f592b0981c1a6afc71c4a9530bb34d9b567cbc004a1db6cb840db17e692e"

URI_x86_64_v2_dbus-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dbus-glib-devel-0.112-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dbus-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-glib-devel}"
SRC_URI[x86_64_v2_dbus-glib-devel.sha256sum] = "f44ebae633bb988d6696425cdc4f4ed127c90bc702a2e87d767264f1e6b3c537"

URI_aarch64_dbus-glib = "${EPEL_MIRROR}/aarch64/Packages/d/dbus-glib-0.112-8.el10_0.aarch64.rpm;name=aarch64_dbus-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-glib}"
SRC_URI[aarch64_dbus-glib.sha256sum] = "c1a7f33893b44e588951e2f02a6edf1c78677c1748d7de2fe085fa374f77a335"

URI_aarch64_dbus-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dbus-glib-devel-0.112-8.el10_0.aarch64.rpm;name=aarch64_dbus-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-glib-devel}"
SRC_URI[aarch64_dbus-glib-devel.sha256sum] = "dd58403f07099dafcad52b8ab78f6f93337712964d4c5dc79f31f9f37c001ea3"

RDEPENDS:dbus-glib = " \
 dbus-libs \
 expat \
 glib2 \
 glibc \
 "
RDEPENDS:dbus-glib-devel = " \
 dbus-devel \
 dbus-glib \
 dbus-libs \
 expat \
 glib2 \
 glib2-devel \
 glibc \
 pkgconf-pkg-config \
 "
