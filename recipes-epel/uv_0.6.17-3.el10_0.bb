# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uv"
PV = "0.6.17"
PR = "3.el10_0"
PACKAGES = " \
 python3-uv \
 uv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uv-0.6.17-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe618393ff40b4ffacf8284b8e07e0cc59af4bcd17442c81e71778a99f971a5b"

URI_x86_64_v2_python3-uv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uv-0.6.17-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-uv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-uv}"
SRC_URI[x86_64_v2_python3-uv.sha256sum] = "3623d183294bf3bca29ba697a7f8bc964bd64872f93710c590ab87ed5371988a"

URI_x86_64_v2_uv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uv-0.6.17-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uv}"
SRC_URI[x86_64_v2_uv.sha256sum] = "1140999a2691a01c2666601bc472a19b2c24e89d969352bca85cd558434d313f"

URI_aarch64_python3-uv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uv-0.6.17-3.el10_0.noarch.rpm;name=aarch64_python3-uv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uv}"
SRC_URI[aarch64_python3-uv.sha256sum] = "e5558ab90ab812d62db13645964c82abcfd86a5dc30d11943d03d68730fdc6f9"

URI_aarch64_uv = "${EPEL_MIRROR}/aarch64/Packages/u/uv-0.6.17-3.el10_0.aarch64.rpm;name=aarch64_uv;unpack=0"
SRC_URI:append = " ${URI_aarch64_uv}"
SRC_URI[aarch64_uv.sha256sum] = "885a8382befbfdd6d5680c145b3a1a41aa00c046ab568e50e2e8ef4994ac7556"

RDEPENDS:python3-uv = " \
 python3 \
 uv \
 "
RDEPENDS:uv = " \
 bzip2-libs \
 glibc \
 libgcc \
 libzstd \
 xz-libs \
 "
