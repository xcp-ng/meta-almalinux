# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfg_aliases"
PV = "0.2.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-cfg_aliases+default-devel \
 rust-cfg_aliases-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cfg_aliases-0.2.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3a4b841adc5fc668c0e5294108962c284abf3a70463a55bc1f690f3a529632e"

URI_x86_64_v2_rust-cfg_aliases+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg_aliases+default-devel-0.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg_aliases+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg_aliases+default-devel}"
SRC_URI[x86_64_v2_rust-cfg_aliases+default-devel.sha256sum] = "e9767f8f96124f9165d4da6801c9b4c3c4409d3404c58079489dd0f628bebb76"

URI_x86_64_v2_rust-cfg_aliases-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg_aliases-devel-0.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg_aliases-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg_aliases-devel}"
SRC_URI[x86_64_v2_rust-cfg_aliases-devel.sha256sum] = "89aae8be2640cb08e4b03d36095f34f786b28e0856134a6e47632330ed0f9ac3"

URI_aarch64_rust-cfg_aliases+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg_aliases+default-devel-0.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-cfg_aliases+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg_aliases+default-devel}"
SRC_URI[aarch64_rust-cfg_aliases+default-devel.sha256sum] = "f827c577a9bc339ce670260c50d1b77c697b287ee979e4ef1a99fcfcfeee367a"

URI_aarch64_rust-cfg_aliases-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg_aliases-devel-0.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-cfg_aliases-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg_aliases-devel}"
SRC_URI[aarch64_rust-cfg_aliases-devel.sha256sum] = "69d14e2cfd9456e65f1d08f744d8a52767e65d1d7642103de23cb97e91617e65"

RDEPENDS:rust-cfg_aliases+default-devel = " \
 cargo \
 rust-cfg_aliases-devel \
 "
RDEPENDS:rust-cfg_aliases-devel = " \
 cargo \
 "
