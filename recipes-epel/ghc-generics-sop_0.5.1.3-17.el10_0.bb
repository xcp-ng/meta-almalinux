# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-generics-sop"
PV = "0.5.1.3"
PR = "17.el10_0"
PACKAGES = " \
 ghc-generics-sop \
 ghc-generics-sop-devel \
 ghc-generics-sop-doc \
 ghc-generics-sop-prof \
 ghc-sop-core \
 ghc-sop-core-devel \
 ghc-sop-core-doc \
 ghc-sop-core-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-generics-sop-0.5.1.3-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "120cc6a67863e8e20d36b972bd21024a213d2cba2146c7946f6c3052272f789c"

URI_x86_64_v2_ghc-generics-sop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-generics-sop-0.5.1.3-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-generics-sop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-generics-sop}"
SRC_URI[x86_64_v2_ghc-generics-sop.sha256sum] = "954ec0e7deb0849600e5204661514b224d64aa81177c0e72e4cb0674494235fe"

URI_x86_64_v2_ghc-generics-sop-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-generics-sop-devel-0.5.1.3-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-generics-sop-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-generics-sop-devel}"
SRC_URI[x86_64_v2_ghc-generics-sop-devel.sha256sum] = "c70f1a84a2f6f06618e2edefa7eef80a9ef887b5c0c968813509f5b14c7e5310"

URI_x86_64_v2_ghc-generics-sop-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-generics-sop-doc-0.5.1.3-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-generics-sop-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-generics-sop-doc}"
SRC_URI[x86_64_v2_ghc-generics-sop-doc.sha256sum] = "358d61312dd6804f29da50a5d71672d05314695466feeb1332627626715e8bea"

URI_x86_64_v2_ghc-generics-sop-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-generics-sop-prof-0.5.1.3-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-generics-sop-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-generics-sop-prof}"
SRC_URI[x86_64_v2_ghc-generics-sop-prof.sha256sum] = "8937b813561fa45e940da653ad2d38264f18918dc0a9ad17554b41f347d962d5"

URI_x86_64_v2_ghc-sop-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-sop-core-0.5.0.2-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-sop-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-sop-core}"
SRC_URI[x86_64_v2_ghc-sop-core.sha256sum] = "081846d6363960af245196ab05e57d5ddfdea2078b9fa74b810b400e8aaf90de"

URI_x86_64_v2_ghc-sop-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-sop-core-devel-0.5.0.2-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-sop-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-sop-core-devel}"
SRC_URI[x86_64_v2_ghc-sop-core-devel.sha256sum] = "749c3ec8439a8e29b9bb75e8a7dffd399f1bdbc45b2e1cd25ec107949f93fff9"

URI_x86_64_v2_ghc-sop-core-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-sop-core-doc-0.5.0.2-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-sop-core-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-sop-core-doc}"
SRC_URI[x86_64_v2_ghc-sop-core-doc.sha256sum] = "afd5566ba0ae8a12e9ee2e6b943d505c429c8c36d03a2f9f32300a558b0abf90"

URI_x86_64_v2_ghc-sop-core-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-sop-core-prof-0.5.0.2-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-sop-core-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-sop-core-prof}"
SRC_URI[x86_64_v2_ghc-sop-core-prof.sha256sum] = "f64d525b2d952f80af5d2c4ffd35d0cbade5b9313334158daafadce486878a4d"

URI_aarch64_ghc-generics-sop = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-generics-sop-0.5.1.3-17.el10_0.aarch64.rpm;name=aarch64_ghc-generics-sop;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-generics-sop}"
SRC_URI[aarch64_ghc-generics-sop.sha256sum] = "eab29090cad6822937484cd20e17ee2952f13462aea9f73b846922ca9d758ffe"

URI_aarch64_ghc-generics-sop-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-generics-sop-devel-0.5.1.3-17.el10_0.aarch64.rpm;name=aarch64_ghc-generics-sop-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-generics-sop-devel}"
SRC_URI[aarch64_ghc-generics-sop-devel.sha256sum] = "2c68f6115448cec61506cd5674ba87fd894ef57e7fc514812b1113e26260b516"

URI_aarch64_ghc-generics-sop-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-generics-sop-doc-0.5.1.3-17.el10_0.noarch.rpm;name=aarch64_ghc-generics-sop-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-generics-sop-doc}"
SRC_URI[aarch64_ghc-generics-sop-doc.sha256sum] = "94202c50fd88537cd05a452f004509796c4d7229b5147f8fbb0ffd92ea6f51d8"

URI_aarch64_ghc-generics-sop-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-generics-sop-prof-0.5.1.3-17.el10_0.aarch64.rpm;name=aarch64_ghc-generics-sop-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-generics-sop-prof}"
SRC_URI[aarch64_ghc-generics-sop-prof.sha256sum] = "d075ee457202b28daa43de87ac4d098b8d09324ddf5ee2709590059792af542e"

URI_aarch64_ghc-sop-core = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-sop-core-0.5.0.2-17.el10_0.aarch64.rpm;name=aarch64_ghc-sop-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-sop-core}"
SRC_URI[aarch64_ghc-sop-core.sha256sum] = "f9a7e341110f5696d115fba5b2c3f8aefe6630e7f299e26d354b908a0fc72086"

URI_aarch64_ghc-sop-core-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-sop-core-devel-0.5.0.2-17.el10_0.aarch64.rpm;name=aarch64_ghc-sop-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-sop-core-devel}"
SRC_URI[aarch64_ghc-sop-core-devel.sha256sum] = "2370f6035be6c3074ca821efeb062946f7989ae7da98fce57b61a15a0f46a0f0"

URI_aarch64_ghc-sop-core-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-sop-core-doc-0.5.0.2-17.el10_0.noarch.rpm;name=aarch64_ghc-sop-core-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-sop-core-doc}"
SRC_URI[aarch64_ghc-sop-core-doc.sha256sum] = "ccc17c9a0bafe790f2d8d6a6b9322fc400cb12da345a7591564d20022f564a1e"

URI_aarch64_ghc-sop-core-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-sop-core-prof-0.5.0.2-17.el10_0.aarch64.rpm;name=aarch64_ghc-sop-core-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-sop-core-prof}"
SRC_URI[aarch64_ghc-sop-core-prof.sha256sum] = "d477f8d2c6cd22aaed4b41f6361f245e5fcf971a1f546dbbc24e3854281c5cc4"

RDEPENDS:ghc-generics-sop = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-sop-core \
 ghc-template-haskell \
 ghc-th-abstraction \
 glibc \
 gmp \
 "
RDEPENDS:ghc-generics-sop-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-generics-sop \
 ghc-sop-core-devel \
 ghc-template-haskell-devel \
 ghc-th-abstraction-devel \
 "
RDEPENDS:ghc-generics-sop-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-generics-sop-prof = " \
 ghc-base-prof \
 ghc-generics-sop-devel \
 ghc-sop-core-prof \
 ghc-template-haskell-prof \
 ghc-th-abstraction-prof \
 "
RDEPENDS:ghc-sop-core = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-sop-core-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-sop-core \
 "
RDEPENDS:ghc-sop-core-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-sop-core-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-sop-core-devel \
 "
