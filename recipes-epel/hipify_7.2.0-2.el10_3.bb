# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipify"
PV = "7.2.0"
PR = "2.el10_3"
PACKAGES:x86_64_v2 = " \
 hipify \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipify-7.2.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "946923eb85f20ad7d93fd38e071e4ee72cb1d897190e907b270cfe903c63725a"

URI_x86_64_v2_hipify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipify-7.2.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipify}"
SRC_URI[x86_64_v2_hipify.sha256sum] = "5d89e5b0d923720ec22639b723eb164e30693454d24efc043a801fecf3242f61"

RDEPENDS:hipify = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 perl \
 perl-interpreter \
 rocm-clang-libs \
 rocm-filesystem \
 rocm-llvm-libs \
 "
