# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hex-literal-impl"
PV = "0.2.3"
PR = "7.el10_0"
PACKAGES = " \
 rust-hex-literal-impl+default-devel \
 rust-hex-literal-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hex-literal-impl-0.2.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6643997359d171119de37816cf9224edd250dac37df3fdead59a752de892d28"

URI_x86_64_v2_rust-hex-literal-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex-literal-impl+default-devel-0.2.3-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex-literal-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hex-literal-impl+default-devel}"
SRC_URI[x86_64_v2_rust-hex-literal-impl+default-devel.sha256sum] = "77fc82d35b562439e9609c329f44da94565084c77638edd0b5d46b4f837e99b9"

URI_x86_64_v2_rust-hex-literal-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex-literal-impl-devel-0.2.3-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex-literal-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hex-literal-impl-devel}"
SRC_URI[x86_64_v2_rust-hex-literal-impl-devel.sha256sum] = "01bd56a6b3e81b5b869334034b003f0a8ec664c451a28ac90043f20dba6d542d"

URI_aarch64_rust-hex-literal-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hex-literal-impl+default-devel-0.2.3-7.el10_0.noarch.rpm;name=aarch64_rust-hex-literal-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hex-literal-impl+default-devel}"
SRC_URI[aarch64_rust-hex-literal-impl+default-devel.sha256sum] = "6b40830f8916651adf33284fa3bc2509077b18866feddd298c08a7e3aaf63783"

URI_aarch64_rust-hex-literal-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hex-literal-impl-devel-0.2.3-7.el10_0.noarch.rpm;name=aarch64_rust-hex-literal-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hex-literal-impl-devel}"
SRC_URI[aarch64_rust-hex-literal-impl-devel.sha256sum] = "e67544e86f3461f0061614c3cf4278dbac3d2f1d0b474bc660953367df71c72f"

RDEPENDS:rust-hex-literal-impl+default-devel = " \
 cargo \
 rust-hex-literal-impl-devel \
 "
RDEPENDS:rust-hex-literal-impl-devel = " \
 cargo \
 rust-proc-macro-hack+default-devel \
 "
