# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-v2v"
PE = "1"
PV = "2.10.0"
PR = "23.el10_2"
PACKAGES:x86_64_v2 = " \
 virt-v2v \
 virt-v2v-bash-completion \
 virt-v2v-man-pages-ja \
 virt-v2v-man-pages-uk \
"
PACKAGES:aarch64 = " \
 virt-v2v-bash-completion \
 virt-v2v-man-pages-ja \
 virt-v2v-man-pages-uk \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virt-v2v-2.10.0-23.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9dfbaad8974cffcf821cb4228e0bc22471e745487eb18ce10e58995756196486"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - virt-v2v-bash-completion: virt-v2v = 1:2.10.0-23.el10_2
# - virt-v2v-man-pages-ja: virt-v2v = 1:2.10.0-23.el10_2
# - virt-v2v-man-pages-uk: virt-v2v = 1:2.10.0-23.el10_2

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-v2v-2.10.0-23.el10_2.x86_64_v2.rpm;name=x86_64_v2_virt-v2v;unpack=0"
SRC_URI[x86_64_v2_virt-v2v.sha256sum] = "900f6c48dfce9718043eecc3c30f76ed94fc081dcf300629a799fe1b4c9de005"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-v2v-bash-completion-2.10.0-23.el10_2.noarch.rpm;name=x86_64_v2_virt-v2v-bash-completion;unpack=0"
SRC_URI[x86_64_v2_virt-v2v-bash-completion.sha256sum] = "f745d78b558b6295fa5766664faec663449bd5f85c4ab774438b50545d32cb3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/virt-v2v-man-pages-ja-2.10.0-23.el10_2.noarch.rpm;name=x86_64_v2_virt-v2v-man-pages-ja;unpack=0"
SRC_URI[x86_64_v2_virt-v2v-man-pages-ja.sha256sum] = "24e1f66f36459b03b697e95b872cfbac8551c4a306befa4ea66abfe1698c4b1c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/virt-v2v-man-pages-uk-2.10.0-23.el10_2.noarch.rpm;name=x86_64_v2_virt-v2v-man-pages-uk;unpack=0"
SRC_URI[x86_64_v2_virt-v2v-man-pages-uk.sha256sum] = "238fc55b6f3c7c5e522b130a74335705ce5645f0749d66225a4600f79d3e79c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-v2v-bash-completion-2.10.0-23.el10_2.noarch.rpm;name=aarch64_virt-v2v-bash-completion;unpack=0"
SRC_URI[aarch64_virt-v2v-bash-completion.sha256sum] = "f745d78b558b6295fa5766664faec663449bd5f85c4ab774438b50545d32cb3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/virt-v2v-man-pages-ja-2.10.0-23.el10_2.noarch.rpm;name=aarch64_virt-v2v-man-pages-ja;unpack=0"
SRC_URI[aarch64_virt-v2v-man-pages-ja.sha256sum] = "24e1f66f36459b03b697e95b872cfbac8551c4a306befa4ea66abfe1698c4b1c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/virt-v2v-man-pages-uk-2.10.0-23.el10_2.noarch.rpm;name=aarch64_virt-v2v-man-pages-uk;unpack=0"
SRC_URI[aarch64_virt-v2v-man-pages-uk.sha256sum] = "238fc55b6f3c7c5e522b130a74335705ce5645f0749d66225a4600f79d3e79c0"

RDEPENDS:virt-v2v = " \
 curl \
 edk2-ovmf \
 gawk \
 glib2 \
 glibc \
 guestfs-tools \
 gzip \
 json-c \
 libgcc \
 libguestfs \
 libguestfs-winsupport \
 libguestfs-xfs \
 libnbd \
 libosinfo \
 libvirt-client \
 libvirt-libs \
 libxcrypt \
 libxml2 \
 mingw-srvany-redistributable \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-curl-plugin \
 nbdkit-nbd-plugin \
 nbdkit-python-plugin \
 nbdkit-server \
 nbdkit-ssh-plugin \
 nbdkit-vddk-plugin \
 openssh-clients \
 openssl \
 pcre2 \
 python3 \
 qemu-img \
 unzip \
 "
RDEPENDS:virt-v2v-bash-completion:x86_64_v2 = " \
 bash-completion \
 virt-v2v \
"
RDEPENDS:virt-v2v-bash-completion:aarch64 = " \
 bash-completion \
"
RDEPENDS:virt-v2v-man-pages-ja:x86_64_v2 = " \
 virt-v2v \
"
RDEPENDS:virt-v2v-man-pages-ja:aarch64 = " \
  \
"
RDEPENDS:virt-v2v-man-pages-uk:x86_64_v2 = " \
 virt-v2v \
"
RDEPENDS:virt-v2v-man-pages-uk:aarch64 = " \
  \
"
