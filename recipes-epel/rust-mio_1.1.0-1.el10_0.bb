# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mio"
PV = "1.1.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-mio+default-devel \
 rust-mio+log-devel \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mio-1.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03a3a7f1e92622f56b89281dc13eb444e0c367098ec075156cd7581e5cb3c9ff"

URI_x86_64_v2_rust-mio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+default-devel-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+default-devel}"
SRC_URI[x86_64_v2_rust-mio+default-devel.sha256sum] = "68ec20ff5f627307f17410cac9b32ee959ba7ea167dd6ee4a3dcb9472a34025f"

URI_x86_64_v2_rust-mio+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+log-devel-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+log-devel}"
SRC_URI[x86_64_v2_rust-mio+log-devel.sha256sum] = "6791ee554bb84ac3bb6ecd3df0caf63279fa4ba48929b2a2aa9816e206ac7afa"

URI_x86_64_v2_rust-mio+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+net-devel-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+net-devel}"
SRC_URI[x86_64_v2_rust-mio+net-devel.sha256sum] = "c533696522ca8252e0f9668d2b8fa1fb49b8277b04196815daced20cf0c54ec9"

URI_x86_64_v2_rust-mio+os-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+os-ext-devel-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+os-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+os-ext-devel}"
SRC_URI[x86_64_v2_rust-mio+os-ext-devel.sha256sum] = "efde67ca4a1f8cdffa49616cb2322f6afc56213f2a1404bb13eaa28d31ce9d50"

URI_x86_64_v2_rust-mio+os-poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+os-poll-devel-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+os-poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+os-poll-devel}"
SRC_URI[x86_64_v2_rust-mio+os-poll-devel.sha256sum] = "d5a8cb5e8c2a05f2813e37602beb8f54db3e8e5fdd337ccd44056c396ab8e5bb"

URI_x86_64_v2_rust-mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio-devel-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio-devel}"
SRC_URI[x86_64_v2_rust-mio-devel.sha256sum] = "d62ec9144a8dad0413d794c6c4b8fee3d607cf94c917f720b564749c221f67bc"

URI_aarch64_rust-mio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+default-devel-1.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+default-devel}"
SRC_URI[aarch64_rust-mio+default-devel.sha256sum] = "addfe54307a9142e82bd03c9a9a8d6d5907f6ba1a982969011d8c37898a924e9"

URI_aarch64_rust-mio+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+log-devel-1.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-mio+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+log-devel}"
SRC_URI[aarch64_rust-mio+log-devel.sha256sum] = "86aa1d15fd05e319ef0542ebc882ff044772a5bd6da2f4a2bd27719edcb41ebf"

URI_aarch64_rust-mio+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+net-devel-1.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-mio+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+net-devel}"
SRC_URI[aarch64_rust-mio+net-devel.sha256sum] = "55b2283258cea2b204e768a7ab5a81cd96f86d01bc69c9ccd12b922738153872"

URI_aarch64_rust-mio+os-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+os-ext-devel-1.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-mio+os-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+os-ext-devel}"
SRC_URI[aarch64_rust-mio+os-ext-devel.sha256sum] = "f964edf934db66a7d1927249c4accda3de31301ef75047c9ee413677d4dd6c60"

URI_aarch64_rust-mio+os-poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+os-poll-devel-1.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-mio+os-poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+os-poll-devel}"
SRC_URI[aarch64_rust-mio+os-poll-devel.sha256sum] = "61011af9c7f6585dedb9e71b3b0c967df7e4be50090b931dfaa8cb1068b077f2"

URI_aarch64_rust-mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio-devel-1.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio-devel}"
SRC_URI[aarch64_rust-mio-devel.sha256sum] = "cb3e37ee7a8705eb0ad613057c3c125fbdbbabb078166b053190d424faee61c0"

RDEPENDS:rust-mio+default-devel = " \
 cargo \
 rust-mio+log-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+net-devel = " \
 cargo \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+os-ext-devel = " \
 cargo \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+os-poll-devel = " \
 cargo \
 rust-mio-devel \
 "
RDEPENDS:rust-mio-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
