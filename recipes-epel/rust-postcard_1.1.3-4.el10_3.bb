# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-postcard"
PV = "1.1.3"
PR = "4.el10_3"
PACKAGES = " \
 rust-postcard+alloc-devel \
 rust-postcard+core-num-saturating-devel \
 rust-postcard+crc-devel \
 rust-postcard+default-devel \
 rust-postcard+experimental-derive-devel \
 rust-postcard+heapless-cas-devel \
 rust-postcard+heapless-devel \
 rust-postcard+nalgebra-v0_33-devel \
 rust-postcard+nalgebra_v0_33-devel \
 rust-postcard+paste-devel \
 rust-postcard+postcard-derive-devel \
 rust-postcard+use-crc-devel \
 rust-postcard+use-std-devel \
 rust-postcard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-postcard-1.1.3-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e4f0cd8f8e34d7410097626197d7c0e0afc8d7802a7960feefada9c2a38931f"

URI_x86_64_v2_rust-postcard+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+alloc-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+alloc-devel}"
SRC_URI[x86_64_v2_rust-postcard+alloc-devel.sha256sum] = "965590a9157ea954d779817346b4fe6d89bbe208181753c45093aebc07455a2c"

URI_x86_64_v2_rust-postcard+core-num-saturating-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+core-num-saturating-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+core-num-saturating-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+core-num-saturating-devel}"
SRC_URI[x86_64_v2_rust-postcard+core-num-saturating-devel.sha256sum] = "b50dc39838b6394bea451c4dcfbea61e7657f466a0e5abc5d21e5354eaa6ce84"

URI_x86_64_v2_rust-postcard+crc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+crc-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+crc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+crc-devel}"
SRC_URI[x86_64_v2_rust-postcard+crc-devel.sha256sum] = "7adbea73fbd62453681878f85a65be8860654adb72aba18a03bc3033fa4397e1"

URI_x86_64_v2_rust-postcard+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+default-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+default-devel}"
SRC_URI[x86_64_v2_rust-postcard+default-devel.sha256sum] = "7aedb07d5038dd75279c6334caf8dd09cb03fbf9ceac6f9943d99e1859a37be5"

URI_x86_64_v2_rust-postcard+experimental-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+experimental-derive-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+experimental-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+experimental-derive-devel}"
SRC_URI[x86_64_v2_rust-postcard+experimental-derive-devel.sha256sum] = "a9bef1fcc66d3192960cc8818b52944a6077b591b24ff806071355cb99a35c65"

URI_x86_64_v2_rust-postcard+heapless-cas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+heapless-cas-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+heapless-cas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+heapless-cas-devel}"
SRC_URI[x86_64_v2_rust-postcard+heapless-cas-devel.sha256sum] = "1f026d8b41cb7e18d6182d121097f759aacd4c96ca260c52bc211015f2f906fd"

URI_x86_64_v2_rust-postcard+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+heapless-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+heapless-devel}"
SRC_URI[x86_64_v2_rust-postcard+heapless-devel.sha256sum] = "36c7944025d53f8a677555df61562594aaf0b674227ec976e4dfcaf7d12a5335"

URI_x86_64_v2_rust-postcard+nalgebra-v0_33-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+nalgebra-v0_33-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+nalgebra-v0_33-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+nalgebra-v0_33-devel}"
SRC_URI[x86_64_v2_rust-postcard+nalgebra-v0_33-devel.sha256sum] = "c01e54889a89cf4da94ccbe297cd44b7505a53b1708fd4d1c13f552837e72559"

URI_x86_64_v2_rust-postcard+nalgebra_v0_33-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+nalgebra_v0_33-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+nalgebra_v0_33-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+nalgebra_v0_33-devel}"
SRC_URI[x86_64_v2_rust-postcard+nalgebra_v0_33-devel.sha256sum] = "fed28cb1918089119dbdfd4ec04cbede28e9e208b1e2e481aa62f257b753c336"

URI_x86_64_v2_rust-postcard+paste-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+paste-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+paste-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+paste-devel}"
SRC_URI[x86_64_v2_rust-postcard+paste-devel.sha256sum] = "4e365d5d987bc3df27c015bce0cbea91ed7e5fce0124f2602bc92fd0370b77ef"

URI_x86_64_v2_rust-postcard+postcard-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+postcard-derive-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+postcard-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+postcard-derive-devel}"
SRC_URI[x86_64_v2_rust-postcard+postcard-derive-devel.sha256sum] = "7a08ea550269da8616c7a3412a74e1974413f53e1d6ea592cdaf7a927d3ed15c"

URI_x86_64_v2_rust-postcard+use-crc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+use-crc-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+use-crc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+use-crc-devel}"
SRC_URI[x86_64_v2_rust-postcard+use-crc-devel.sha256sum] = "1cfc7b4f1f8badf89aa3028abbdd87b4271add3038f81b96fb8b8a51fb5809f6"

URI_x86_64_v2_rust-postcard+use-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+use-std-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+use-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+use-std-devel}"
SRC_URI[x86_64_v2_rust-postcard+use-std-devel.sha256sum] = "3b632404a3f4c5d336873c2d97723bb87251fc93fbc266fe8da2180dfd2ee152"

URI_x86_64_v2_rust-postcard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard-devel-1.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard-devel}"
SRC_URI[x86_64_v2_rust-postcard-devel.sha256sum] = "59f875c80ca0af55a1334540e741e17e199d79fc95dfa1aec3d0a32126982141"

URI_aarch64_rust-postcard+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+alloc-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+alloc-devel}"
SRC_URI[aarch64_rust-postcard+alloc-devel.sha256sum] = "0a9888326942637546d495326ad997d1db116b466e2f34f2c9558dc5a7d60693"

URI_aarch64_rust-postcard+core-num-saturating-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+core-num-saturating-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard+core-num-saturating-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+core-num-saturating-devel}"
SRC_URI[aarch64_rust-postcard+core-num-saturating-devel.sha256sum] = "ba9de124459c92ddfc78112f2206a3b6c79de1bfb0a3eafa8124d906f0578f92"

URI_aarch64_rust-postcard+crc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+crc-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard+crc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+crc-devel}"
SRC_URI[aarch64_rust-postcard+crc-devel.sha256sum] = "53769a87d5ca77bd74fc1cde23574de0a24696d8e75e85bfc2ee73bd8ccaa3ab"

URI_aarch64_rust-postcard+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+default-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+default-devel}"
SRC_URI[aarch64_rust-postcard+default-devel.sha256sum] = "735e0d0193119ff8011a46c1f21315d5c22d10a9bce4b93b846acccbb62bc6b5"

URI_aarch64_rust-postcard+experimental-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+experimental-derive-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard+experimental-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+experimental-derive-devel}"
SRC_URI[aarch64_rust-postcard+experimental-derive-devel.sha256sum] = "c1a16a68e10b57f19b30005910b2e44e2ff26d1727493031b809f34928ab9803"

URI_aarch64_rust-postcard+heapless-cas-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+heapless-cas-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard+heapless-cas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+heapless-cas-devel}"
SRC_URI[aarch64_rust-postcard+heapless-cas-devel.sha256sum] = "35d62933347ebd43676c5451c3a4cd1795f3317a0f527f0e853c265ba75d7984"

URI_aarch64_rust-postcard+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+heapless-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+heapless-devel}"
SRC_URI[aarch64_rust-postcard+heapless-devel.sha256sum] = "1b2f8bec482b7466f4b189c9f29e49b6a81e65a53e551b94540f65ca37c322e2"

URI_aarch64_rust-postcard+nalgebra-v0_33-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+nalgebra-v0_33-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard+nalgebra-v0_33-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+nalgebra-v0_33-devel}"
SRC_URI[aarch64_rust-postcard+nalgebra-v0_33-devel.sha256sum] = "6080fb23080e61381e94ee27ec10ca84e8531bba5e4944a38684b8c10efbbe10"

URI_aarch64_rust-postcard+nalgebra_v0_33-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+nalgebra_v0_33-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard+nalgebra_v0_33-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+nalgebra_v0_33-devel}"
SRC_URI[aarch64_rust-postcard+nalgebra_v0_33-devel.sha256sum] = "5769dec4cac7725afc5026f54d1d8118ed3d81ab5686285fc89e7fe4192482ff"

URI_aarch64_rust-postcard+paste-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+paste-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard+paste-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+paste-devel}"
SRC_URI[aarch64_rust-postcard+paste-devel.sha256sum] = "1d4989de69477fac3c0ae955c907aacd048101fdb5d064d57e991c18735e6126"

URI_aarch64_rust-postcard+postcard-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+postcard-derive-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard+postcard-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+postcard-derive-devel}"
SRC_URI[aarch64_rust-postcard+postcard-derive-devel.sha256sum] = "ec5c88ee2c25eee1281161a58e625fd734dda6eb810774f17669ace15fa17cf5"

URI_aarch64_rust-postcard+use-crc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+use-crc-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard+use-crc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+use-crc-devel}"
SRC_URI[aarch64_rust-postcard+use-crc-devel.sha256sum] = "85c3638a3c687c17747e8a59085ffda78a928f301a9d0eab58ed55a6f0df0b6a"

URI_aarch64_rust-postcard+use-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+use-std-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard+use-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+use-std-devel}"
SRC_URI[aarch64_rust-postcard+use-std-devel.sha256sum] = "3a4108dbd7b4118ef41fa676bd3ec7a049fa91ad89dd804146890a62269faecb"

URI_aarch64_rust-postcard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard-devel-1.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-postcard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard-devel}"
SRC_URI[aarch64_rust-postcard-devel.sha256sum] = "683e4762bd899d64af48f0d8774c00608856afeae680846905938eb0d95c7e8b"

RDEPENDS:rust-postcard+alloc-devel = " \
 cargo \
 rust-postcard-devel \
 rust-serde+alloc-devel \
 "
RDEPENDS:rust-postcard+core-num-saturating-devel = " \
 cargo \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+crc-devel = " \
 cargo \
 rust-crc+default-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+default-devel = " \
 cargo \
 rust-postcard+heapless-cas-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+experimental-derive-devel = " \
 cargo \
 rust-postcard+postcard-derive-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+heapless-cas-devel = " \
 cargo \
 rust-heapless0.7+cas-devel \
 rust-heapless0.7+serde-devel \
 rust-heapless0.7-devel \
 rust-postcard+heapless-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+heapless-devel = " \
 cargo \
 rust-heapless0.7+serde-devel \
 rust-heapless0.7-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+nalgebra-v0_33-devel = " \
 cargo \
 rust-postcard+nalgebra_v0_33-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+nalgebra_v0_33-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+paste-devel = " \
 cargo \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+postcard-derive-devel = " \
 cargo \
 rust-postcard-derive+default-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+use-crc-devel = " \
 cargo \
 rust-postcard+crc-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+use-std-devel = " \
 cargo \
 rust-postcard+alloc-devel \
 rust-postcard-devel \
 rust-serde+std-devel \
 "
RDEPENDS:rust-postcard-devel = " \
 cargo \
 rust-cobs-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
