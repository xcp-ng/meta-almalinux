# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-inline-tabs"
PV = "2023.04.21"
PR = "3.el10_0"
PACKAGES = " \
 python3-sphinx-inline-tabs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-inline-tabs-2023.04.21-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "993320e960d173d2add2c4402e959c3ff544a601067f3d7699a5237be83dd6b4"

URI_x86_64_v2_python3-sphinx-inline-tabs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-inline-tabs-2023.04.21-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-inline-tabs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-inline-tabs}"
SRC_URI[x86_64_v2_python3-sphinx-inline-tabs.sha256sum] = "01605dae02a321aa7de7c4f0949cefcfc0c8a4c26908155a2632f4659a26e4fb"

URI_aarch64_python3-sphinx-inline-tabs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-inline-tabs-2023.04.21-3.el10_0.noarch.rpm;name=aarch64_python3-sphinx-inline-tabs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-inline-tabs}"
SRC_URI[aarch64_python3-sphinx-inline-tabs.sha256sum] = "e1c654f2075d5aa06b24505d54c51812823d8baba6626c564cba7f9349724574"

RDEPENDS:python3-sphinx-inline-tabs = " \
 python3 \
 python3-sphinx \
 "
