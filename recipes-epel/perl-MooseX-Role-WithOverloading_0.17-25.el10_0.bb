# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MooseX-Role-WithOverloading"
PV = "0.17"
PR = "25.el10_0"
PACKAGES = " \
 perl-MooseX-Role-WithOverloading \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MooseX-Role-WithOverloading-0.17-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca5307b215d19980032aa75c4d68d60d01c88e5b83522154ec89f77563415df7"

URI_x86_64_v2_perl-MooseX-Role-WithOverloading = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MooseX-Role-WithOverloading-0.17-25.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-MooseX-Role-WithOverloading;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MooseX-Role-WithOverloading}"
SRC_URI[x86_64_v2_perl-MooseX-Role-WithOverloading.sha256sum] = "24b5a016560add21155f51fd800742d799458b5e3266f66d03a21ef8c3ee15b1"

URI_aarch64_perl-MooseX-Role-WithOverloading = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MooseX-Role-WithOverloading-0.17-25.el10_0.aarch64.rpm;name=aarch64_perl-MooseX-Role-WithOverloading;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MooseX-Role-WithOverloading}"
SRC_URI[aarch64_perl-MooseX-Role-WithOverloading.sha256sum] = "d66a58789f629f82212e080c140b18546ad3ae564789b93f5b707ad2a2c2f963"

RDEPENDS:perl-MooseX-Role-WithOverloading = " \
 glibc \
 perl-Moose \
 perl-MooseX-Role-WithOverloading \
 perl-aliased \
 perl-libs \
 perl-namespace-autoclean \
 perl-namespace-clean \
 perl-overload \
 "
