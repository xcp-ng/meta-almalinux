# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-Diff"
PV = "0.4.1"
PR = "9.el10_0"
PACKAGES = " \
 ghc-Diff \
 ghc-Diff-devel \
 ghc-Diff-doc \
 ghc-Diff-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-Diff-0.4.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88df3b5d35b1c1e355b54d0bacfdf57d5cf2a5ba82d53ce11531d46daa41270c"

URI_x86_64_v2_ghc-Diff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Diff-0.4.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Diff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Diff}"
SRC_URI[x86_64_v2_ghc-Diff.sha256sum] = "3d67877c8ac3f90e2f5af0386e965f78526540fc04f4a010c8745dc7830e013f"

URI_x86_64_v2_ghc-Diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Diff-devel-0.4.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Diff-devel}"
SRC_URI[x86_64_v2_ghc-Diff-devel.sha256sum] = "dcd64c6ba2aa1155237c8c57ef690f7fe37b61dd1b7e83a9de742d74714bbda9"

URI_x86_64_v2_ghc-Diff-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Diff-doc-0.4.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-Diff-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Diff-doc}"
SRC_URI[x86_64_v2_ghc-Diff-doc.sha256sum] = "2ac1225d9670823241dd028e038fa2758b22cb82eb439dfc2558eb542aea30ec"

URI_x86_64_v2_ghc-Diff-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Diff-prof-0.4.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Diff-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Diff-prof}"
SRC_URI[x86_64_v2_ghc-Diff-prof.sha256sum] = "589d5acb9e8d22174ec947b687bab5d5215b843073c779531109bb8eb1594b70"

URI_aarch64_ghc-Diff = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Diff-0.4.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-Diff;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Diff}"
SRC_URI[aarch64_ghc-Diff.sha256sum] = "f590db6d5846dabfcb139fddc4f3c011362d73cc709f49916565b4f9b52d46f6"

URI_aarch64_ghc-Diff-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Diff-devel-0.4.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-Diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Diff-devel}"
SRC_URI[aarch64_ghc-Diff-devel.sha256sum] = "9571c675670e43f46397598b8faf5cf0412e10416e83431f050f88298098ef08"

URI_aarch64_ghc-Diff-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Diff-doc-0.4.1-9.el10_0.noarch.rpm;name=aarch64_ghc-Diff-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Diff-doc}"
SRC_URI[aarch64_ghc-Diff-doc.sha256sum] = "32c71dfb4fe00b6d2a21034e8eb7f8cf8d4d367ee7136c5914624ee3dc877bc8"

URI_aarch64_ghc-Diff-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Diff-prof-0.4.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-Diff-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Diff-prof}"
SRC_URI[aarch64_ghc-Diff-prof.sha256sum] = "de8aec5f49e66d0025a4fa302f75bd6142dc01c01d0718b45e565e6101f067f0"

RDEPENDS:ghc-Diff = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc-Diff-devel = " \
 ghc-Diff \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-pretty-devel \
 "
RDEPENDS:ghc-Diff-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-Diff-prof = " \
 ghc-Diff-devel \
 ghc-array-prof \
 ghc-base-prof \
 ghc-pretty-prof \
 "
