# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipewire-epel"
PV = "1.4.11"
PR = "4.el10_2"
PACKAGES = " \
 pipewire-module-filter-chain-lv2 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pipewire-epel-1.4.11-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "25388278fd1737ddbf12535a06917c342b64d405f102b8b8af436929e81ea0d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pipewire-module-filter-chain-lv2-1.4.11-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pipewire-module-filter-chain-lv2;unpack=0"
SRC_URI[x86_64_v2_pipewire-module-filter-chain-lv2.sha256sum] = "2b8d3bf652906711aa4ddd399d7f6dcf521a921b42cf1f9bcea83a1237d8c901"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pipewire-module-filter-chain-lv2-1.4.11-4.el10_2.aarch64.rpm;name=aarch64_pipewire-module-filter-chain-lv2;unpack=0"
SRC_URI[aarch64_pipewire-module-filter-chain-lv2.sha256sum] = "c17f003f4206eae393292833bb1fb7cae47eae3693dfcb1773916448ec198c05"

RDEPENDS:pipewire-module-filter-chain-lv2 = " \
 glibc \
 lilv-libs \
 pipewire-libs \
 "
