# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snowball"
PV = "2.2.0"
PR = "13.el10_0"
PACKAGES = " \
 libstemmer \
 libstemmer-devel \
 python3-snowballstemmer \
 snowball \
 snowball-java \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/snowball-2.2.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72ce036c6a47e45ef7ca932fd011ea7d037ff7f0485ae16480218b2e9e233ac5"

URI_x86_64_v2_libstemmer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libstemmer-2.2.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libstemmer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstemmer}"
SRC_URI[x86_64_v2_libstemmer.sha256sum] = "5e2f91e0bd728efb87462da9839bed49fdcb28ed1fdb09d998ea50a37fe6b456"

URI_x86_64_v2_libstemmer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libstemmer-devel-2.2.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libstemmer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstemmer-devel}"
SRC_URI[x86_64_v2_libstemmer-devel.sha256sum] = "80b4cdf2579db15d69f7c54f416da69cdc179a4ffd19f5eba2a57ca21b676533"

URI_x86_64_v2_python3-snowballstemmer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-snowballstemmer-2.2.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-snowballstemmer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-snowballstemmer}"
SRC_URI[x86_64_v2_python3-snowballstemmer.sha256sum] = "eebebf90c9be669c2370d7f228137749d235df2aed9efac4cf9743f87c83e95b"

URI_x86_64_v2_snowball = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snowball-2.2.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snowball;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snowball}"
SRC_URI[x86_64_v2_snowball.sha256sum] = "6b3116bfdea3bb5242f1dddbff42c24274702a938d3a73493e8305131e19b288"

URI_x86_64_v2_snowball-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snowball-java-2.2.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_snowball-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snowball-java}"
SRC_URI[x86_64_v2_snowball-java.sha256sum] = "efc405d77f2529b240ab184b595eb096c34a585524a6e9aba866d160d8073f3f"

URI_aarch64_libstemmer = "${EPEL_MIRROR}/aarch64/Packages/l/libstemmer-2.2.0-13.el10_0.aarch64.rpm;name=aarch64_libstemmer;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstemmer}"
SRC_URI[aarch64_libstemmer.sha256sum] = "cb91270f4451c038adf0496480d614330ebc01d911da21e7bf18a6f80b48397a"

URI_aarch64_libstemmer-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libstemmer-devel-2.2.0-13.el10_0.aarch64.rpm;name=aarch64_libstemmer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstemmer-devel}"
SRC_URI[aarch64_libstemmer-devel.sha256sum] = "56e83e361ea33e01f275ad5717707b01aca02c16dec00235bb1bada83c055058"

URI_aarch64_python3-snowballstemmer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-snowballstemmer-2.2.0-13.el10_0.noarch.rpm;name=aarch64_python3-snowballstemmer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-snowballstemmer}"
SRC_URI[aarch64_python3-snowballstemmer.sha256sum] = "ec96d1218134eb38adc4e5efdb90e8a8e287e37b43cce0b019b29614f378d8f5"

URI_aarch64_snowball = "${EPEL_MIRROR}/aarch64/Packages/s/snowball-2.2.0-13.el10_0.aarch64.rpm;name=aarch64_snowball;unpack=0"
SRC_URI:append = " ${URI_aarch64_snowball}"
SRC_URI[aarch64_snowball.sha256sum] = "6d04b1ce51a228f3cac9bc5999eeb898f8c122ec1b131e250d8c39630adcc979"

URI_aarch64_snowball-java = "${EPEL_MIRROR}/aarch64/Packages/s/snowball-java-2.2.0-13.el10_0.noarch.rpm;name=aarch64_snowball-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_snowball-java}"
SRC_URI[aarch64_snowball-java.sha256sum] = "e992ae9457e6ec94092210253250247b35d5955e6dab4d46dc17ff16d8752cde"

RDEPENDS:libstemmer = " \
 glibc \
 "
RDEPENDS:libstemmer-devel = " \
 libstemmer \
 "
RDEPENDS:python3-snowballstemmer = " \
 python3 \
 "
RDEPENDS:snowball = " \
 glibc \
 libstemmer \
 "
RDEPENDS:snowball-java = " \
 "
