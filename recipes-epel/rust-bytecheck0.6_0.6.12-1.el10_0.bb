# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytecheck0.6"
PV = "0.6.12"
PR = "1.el10_0"
PACKAGES = " \
 rust-bytecheck0.6+default-devel \
 rust-bytecheck0.6+simdutf8-devel \
 rust-bytecheck0.6+std-devel \
 rust-bytecheck0.6+uuid-devel \
 rust-bytecheck0.6+verbose-devel \
 rust-bytecheck0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytecheck0.6-0.6.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85877cc92a9fcf7432416bd57c35c4f9b293c4da28ba8e7990a6ac0e3d871348"

URI_x86_64_v2_rust-bytecheck0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck0.6+default-devel-0.6.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck0.6+default-devel}"
SRC_URI[x86_64_v2_rust-bytecheck0.6+default-devel.sha256sum] = "ba0938894298c48de4d9651aec14348b96bc62da5967836fa56440004cb67d66"

URI_x86_64_v2_rust-bytecheck0.6+simdutf8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck0.6+simdutf8-devel-0.6.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck0.6+simdutf8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck0.6+simdutf8-devel}"
SRC_URI[x86_64_v2_rust-bytecheck0.6+simdutf8-devel.sha256sum] = "ae7306ebe031d605f7807ae46629b85907bdf13c8c1b1a12e881f1aa7a1f3824"

URI_x86_64_v2_rust-bytecheck0.6+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck0.6+std-devel-0.6.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck0.6+std-devel}"
SRC_URI[x86_64_v2_rust-bytecheck0.6+std-devel.sha256sum] = "d8f314e652ec0fc4378ac98ef35f5c5bf8a010d9bed36e979caa77c32d63f57d"

URI_x86_64_v2_rust-bytecheck0.6+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck0.6+uuid-devel-0.6.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck0.6+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck0.6+uuid-devel}"
SRC_URI[x86_64_v2_rust-bytecheck0.6+uuid-devel.sha256sum] = "b7a4b641e45e67910c7c151c90c02bc5e73edff4eb84b4b69fad20cbc64b000d"

URI_x86_64_v2_rust-bytecheck0.6+verbose-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck0.6+verbose-devel-0.6.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck0.6+verbose-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck0.6+verbose-devel}"
SRC_URI[x86_64_v2_rust-bytecheck0.6+verbose-devel.sha256sum] = "262a492fb6bd2669d05f5b2a2342d07de06c978d6bfa00f6227acd964ff82091"

URI_x86_64_v2_rust-bytecheck0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck0.6-devel-0.6.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck0.6-devel}"
SRC_URI[x86_64_v2_rust-bytecheck0.6-devel.sha256sum] = "18b0c82db4c7b0d5fb924f403778d8b0a79883e30d3ea65efd853d549647e053"

URI_aarch64_rust-bytecheck0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck0.6+default-devel-0.6.12-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck0.6+default-devel}"
SRC_URI[aarch64_rust-bytecheck0.6+default-devel.sha256sum] = "3dc93d775f930141b1a996c13dbb8e5440f6dc30a6f287cf79986cdfe27400b4"

URI_aarch64_rust-bytecheck0.6+simdutf8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck0.6+simdutf8-devel-0.6.12-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck0.6+simdutf8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck0.6+simdutf8-devel}"
SRC_URI[aarch64_rust-bytecheck0.6+simdutf8-devel.sha256sum] = "697f9b8487003dcdef9e154052519a12a4dec886bfc5291c51e98474f3dd6e5b"

URI_aarch64_rust-bytecheck0.6+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck0.6+std-devel-0.6.12-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck0.6+std-devel}"
SRC_URI[aarch64_rust-bytecheck0.6+std-devel.sha256sum] = "0a5cc8d0fd468afeab44095b4c91f4ac9851f098f9e4a690228095cac090fc13"

URI_aarch64_rust-bytecheck0.6+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck0.6+uuid-devel-0.6.12-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck0.6+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck0.6+uuid-devel}"
SRC_URI[aarch64_rust-bytecheck0.6+uuid-devel.sha256sum] = "fb0776e01d067e35cb7d452b477ed4716ebfa58262a0f5c938313b5c86b85151"

URI_aarch64_rust-bytecheck0.6+verbose-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck0.6+verbose-devel-0.6.12-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck0.6+verbose-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck0.6+verbose-devel}"
SRC_URI[aarch64_rust-bytecheck0.6+verbose-devel.sha256sum] = "ef6a0d316f1a565b32fade77925b01a7d4d8154d3121770d76468f2864136722"

URI_aarch64_rust-bytecheck0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck0.6-devel-0.6.12-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck0.6-devel}"
SRC_URI[aarch64_rust-bytecheck0.6-devel.sha256sum] = "f598a68eaddfe4e4ba0d187d7fbc2afad1dc65b421697499ca8e08218d519c13"

RDEPENDS:rust-bytecheck0.6+default-devel = " \
 cargo \
 rust-bytecheck0.6+simdutf8-devel \
 rust-bytecheck0.6+std-devel \
 rust-bytecheck0.6-devel \
 "
RDEPENDS:rust-bytecheck0.6+simdutf8-devel = " \
 cargo \
 rust-bytecheck0.6-devel \
 rust-simdutf8-devel \
 "
RDEPENDS:rust-bytecheck0.6+std-devel = " \
 cargo \
 rust-bytecheck0.6-devel \
 rust-bytecheck_derive0.6+std-devel \
 rust-ptr_meta0.1+std-devel \
 rust-simdutf8+std-devel \
 rust-simdutf8-devel \
 "
RDEPENDS:rust-bytecheck0.6+uuid-devel = " \
 cargo \
 rust-bytecheck0.6-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-bytecheck0.6+verbose-devel = " \
 cargo \
 rust-bytecheck0.6-devel \
 "
RDEPENDS:rust-bytecheck0.6-devel = " \
 cargo \
 rust-bytecheck_derive0.6-devel \
 rust-ptr_meta0.1-devel \
 "
