# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skanpage"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 skanpage \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/skanpage-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "161fb55dc9b94e27d026c087641bc3d3af7f1cf97c9a3127e7a16b9965817961"

URI_x86_64_v2_skanpage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skanpage-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skanpage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skanpage}"
SRC_URI[x86_64_v2_skanpage.sha256sum] = "9089b7dcd74ae41eef799e8defc81f98eaa745e5116d39fffb27c0102a834e26"

URI_aarch64_skanpage = "${EPEL_MIRROR}/aarch64/Packages/s/skanpage-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_skanpage;unpack=0"
SRC_URI:append = " ${URI_aarch64_skanpage}"
SRC_URI[aarch64_skanpage.sha256sum] = "c2be495a977c903354eb91899da99c937654e37809c6ba744dc05dab8db7df34"

RDEPENDS:skanpage = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kxmlgui \
 kquickimageeditor-qt6 \
 ksanecore \
 leptonica \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpdf \
 tesseract \
 "
