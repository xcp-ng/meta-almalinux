# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ruamel-yaml"
PV = "0.18.5"
PR = "5.el10"
PACKAGES = " \
 python3-ruamel-yaml \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-ruamel-yaml-0.18.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0a904fa8a6aa9f98a25a6561ed8c310bd2f578f12eb9a18bad6b007790cfa996"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ruamel-yaml-0.18.5-5.el10.noarch.rpm;name=x86_64_v2_python3-ruamel-yaml;unpack=0"
SRC_URI[x86_64_v2_python3-ruamel-yaml.sha256sum] = "c1ebf0fc8aab6287149b80e8ef919d8fbb39a0890875e7ca2cc8de18a566f1e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ruamel-yaml-0.18.5-5.el10.noarch.rpm;name=aarch64_python3-ruamel-yaml;unpack=0"
SRC_URI[aarch64_python3-ruamel-yaml.sha256sum] = "c1ebf0fc8aab6287149b80e8ef919d8fbb39a0890875e7ca2cc8de18a566f1e0"

RDEPENDS:python3-ruamel-yaml = " \
 python3 \
 python3-ruamel-yaml-clib \
 "
