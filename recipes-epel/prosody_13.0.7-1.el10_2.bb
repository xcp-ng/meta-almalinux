# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prosody"
PV = "13.0.7"
PR = "1.el10_2"
PACKAGES = " \
 prosody \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/prosody-13.0.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "227338a2da0a98301f6396bee49e46dba40e9d5abdcd3934a5d1a124a6cb480f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prosody-13.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_prosody;unpack=0"
SRC_URI[x86_64_v2_prosody.sha256sum] = "af13b524c578400c26aac47ee5af58d1745d5ee64d5c9c4ebe060b291c47c921"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/prosody-13.0.7-1.el10_2.aarch64.rpm;name=aarch64_prosody;unpack=0"
SRC_URI[aarch64_prosody.sha256sum] = "35529f5c9e569a6547993f9804f919489d5839642f0c36014b49f7385937cfe9"

RDEPENDS:prosody = " \
 bash \
 glibc \
 libicu \
 lua \
 lua-expat \
 lua-filesystem \
 lua-libs \
 lua-sec \
 lua-socket \
 openssl \
 openssl-libs \
 shadow-utils \
 systemd \
 "
