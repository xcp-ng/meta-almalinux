# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pkginfo"
PV = "1.12.0"
PR = "3.el10_1"
PACKAGES = " \
 python-pkginfo-doc \
 python3-pkginfo \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-pkginfo-1.12.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c6808a27d704dff9b3ae00ecff36421cc038525d281bf4ef1ba7c3733876ba47"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pkginfo-doc-1.12.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-pkginfo-doc;unpack=0"
SRC_URI[x86_64_v2_python-pkginfo-doc.sha256sum] = "d4a13640b3637b54cbac652b37d3427bb1668463b042f96d0025d0c41653730a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pkginfo-1.12.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pkginfo;unpack=0"
SRC_URI[x86_64_v2_python3-pkginfo.sha256sum] = "8e01c7373d7de0c53ce644fb86cdadb9af23b01e30a1a046e745c1514bca9dab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-pkginfo-doc-1.12.0-3.el10_1.noarch.rpm;name=aarch64_python-pkginfo-doc;unpack=0"
SRC_URI[aarch64_python-pkginfo-doc.sha256sum] = "a155986fec23a2222e3e30a4c159b363ef74c2f1c05a4f06712cb01f88c64842"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pkginfo-1.12.0-3.el10_1.noarch.rpm;name=aarch64_python3-pkginfo;unpack=0"
SRC_URI[aarch64_python3-pkginfo.sha256sum] = "680ca552d9182ca80d0f5084bef9999ed0fab3b657c79829ac45c218937aeea7"

RDEPENDS:python-pkginfo-doc = " \
 "
RDEPENDS:python3-pkginfo = " \
 python3 \
 python3-setuptools \
 "
