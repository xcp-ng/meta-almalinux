# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libklvanc"
PV = "1.6.0"
PR = "1.el10_0"
PACKAGES = " \
 libklvanc \
 libklvanc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libklvanc-1.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecdb0d600e832d71a61ee1341e32be543ba83d88b5855e5aee11564416b63513"

URI_x86_64_v2_libklvanc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libklvanc-1.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libklvanc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libklvanc}"
SRC_URI[x86_64_v2_libklvanc.sha256sum] = "aca7de5dc311348903599963533ac602b0d972457e4503f1a644f8506d1f16b7"

URI_x86_64_v2_libklvanc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libklvanc-devel-1.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libklvanc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libklvanc-devel}"
SRC_URI[x86_64_v2_libklvanc-devel.sha256sum] = "4cd387d5a7c644c47cdb590a12987bc73823f067df5ad78d98a2e6dd870ec5fa"

URI_aarch64_libklvanc = "${EPEL_MIRROR}/aarch64/Packages/l/libklvanc-1.6.0-1.el10_0.aarch64.rpm;name=aarch64_libklvanc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libklvanc}"
SRC_URI[aarch64_libklvanc.sha256sum] = "3f27928fba221fb4f55475bbff7878c27178815ab8b8de5209c485ebdaae8bc6"

URI_aarch64_libklvanc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libklvanc-devel-1.6.0-1.el10_0.aarch64.rpm;name=aarch64_libklvanc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libklvanc-devel}"
SRC_URI[aarch64_libklvanc-devel.sha256sum] = "971127df2c3dfa58e0a4f628d690821d229e1aa376026275d2413bf027f31d6a"

RDEPENDS:libklvanc = " \
 glibc \
 "
RDEPENDS:libklvanc-devel = " \
 libklvanc \
 "
