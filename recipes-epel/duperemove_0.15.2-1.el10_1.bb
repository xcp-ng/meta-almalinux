# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "duperemove"
PV = "0.15.2"
PR = "1.el10_1"
PACKAGES = " \
 duperemove \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/duperemove-0.15.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12000b3cc84937a3688c3c771ff8e071c15957b29eebb854a6c5531052970db7"

URI_x86_64_v2_duperemove = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duperemove-0.15.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duperemove;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duperemove}"
SRC_URI[x86_64_v2_duperemove.sha256sum] = "b63b4bfd8f0903dc9b6be68c09cb30574dd88618fb7ed11c7dfb832d7bf77c58"

URI_aarch64_duperemove = "${EPEL_MIRROR}/aarch64/Packages/d/duperemove-0.15.2-1.el10_1.aarch64.rpm;name=aarch64_duperemove;unpack=0"
SRC_URI:append = " ${URI_aarch64_duperemove}"
SRC_URI[aarch64_duperemove.sha256sum] = "98fa42c8b416a0aabbeb852261d4fca06b7388a93b2dcb488c42ee5c1a5e936f"

RDEPENDS:duperemove = " \
 glib2 \
 glibc \
 libblkid \
 libgcc \
 libmount \
 libuuid \
 sqlite-libs \
 "
