# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-cert-store"
PV = "0.7.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-sequoia-cert-store+default-devel \
 rust-sequoia-cert-store+keyserver-devel \
 rust-sequoia-cert-store-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sequoia-cert-store-0.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "320846a56c7e4996a42ceedd3d44d2b28fd58799cac694814312e4b46b441f34"

URI_x86_64_v2_rust-sequoia-cert-store+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-cert-store+default-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-cert-store+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-cert-store+default-devel}"
SRC_URI[x86_64_v2_rust-sequoia-cert-store+default-devel.sha256sum] = "28ef365017d6e64d222be2fc38521d343831d05e68c68fa3d07a1478726331a8"

URI_x86_64_v2_rust-sequoia-cert-store+keyserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-cert-store+keyserver-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-cert-store+keyserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-cert-store+keyserver-devel}"
SRC_URI[x86_64_v2_rust-sequoia-cert-store+keyserver-devel.sha256sum] = "fcfe4e8493a1117b2204822b38ed7f2830b6de9d517fa467ba98319626b4b1aa"

URI_x86_64_v2_rust-sequoia-cert-store-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-cert-store-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-cert-store-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-cert-store-devel}"
SRC_URI[x86_64_v2_rust-sequoia-cert-store-devel.sha256sum] = "f0a65a463e3fed8bbf0579a485040b4cd1ff2a4a487732468a77826a45d4e3cc"

URI_aarch64_rust-sequoia-cert-store+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-cert-store+default-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-cert-store+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-cert-store+default-devel}"
SRC_URI[aarch64_rust-sequoia-cert-store+default-devel.sha256sum] = "5dc5202806d7488bb82623f3383231a73fc4fa658433cb4064e0606020053d11"

URI_aarch64_rust-sequoia-cert-store+keyserver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-cert-store+keyserver-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-cert-store+keyserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-cert-store+keyserver-devel}"
SRC_URI[aarch64_rust-sequoia-cert-store+keyserver-devel.sha256sum] = "e8416540d2cd8843e4976114ceafb3e10801c84c9bb99fc67b61f4d84a4ab7ba"

URI_aarch64_rust-sequoia-cert-store-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-cert-store-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-cert-store-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-cert-store-devel}"
SRC_URI[aarch64_rust-sequoia-cert-store-devel.sha256sum] = "1f11f5d5cf112a1784f715d518436cb409d1124a77a8b9723e294c994ce9bf24"

RDEPENDS:rust-sequoia-cert-store+default-devel = " \
 cargo \
 rust-sequoia-cert-store+keyserver-devel \
 rust-sequoia-cert-store-devel \
 "
RDEPENDS:rust-sequoia-cert-store+keyserver-devel = " \
 cargo \
 rust-sequoia-cert-store-devel \
 rust-sequoia-net-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 "
RDEPENDS:rust-sequoia-cert-store-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-crossbeam+default-devel \
 rust-dirs+default-devel \
 rust-gethostname+default-devel \
 rust-num_cpus+default-devel \
 rust-openpgp-cert-d-devel \
 rust-rayon+default-devel \
 rust-sequoia-openpgp-devel \
 rust-smallvec+default-devel \
 rust-url+default-devel \
 virtual/crate_rusqlite/blob__ge_0.29.0_with_crate_rusqlite/blob__lt_0.40.0~ \
 virtual/crate_rusqlite/collation__ge_0.29.0_with_crate_rusqlite/collation__lt_0.40.0~ \
 virtual/crate_rusqlite/default__ge_0.29.0_with_crate_rusqlite/default__lt_0.40.0~ \
 virtual/crate_rusqlite/trace__ge_0.29.0_with_crate_rusqlite/trace__lt_0.40.0~ \
 virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ \
 "
