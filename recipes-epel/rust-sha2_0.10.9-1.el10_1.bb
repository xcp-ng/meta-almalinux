# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha2"
PV = "0.10.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-sha2+asm-aarch64-devel \
 rust-sha2+asm-devel \
 rust-sha2+compress-devel \
 rust-sha2+default-devel \
 rust-sha2+force-soft-compact-devel \
 rust-sha2+force-soft-devel \
 rust-sha2+loongarch64_asm-devel \
 rust-sha2+oid-devel \
 rust-sha2+sha2-asm-devel \
 rust-sha2+std-devel \
 rust-sha2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha2-0.10.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2927b106dac935346dfc2dc507f11e4dbdd8a9d7506874b29b15d9499419c04d"

URI_x86_64_v2_rust-sha2+asm-aarch64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+asm-aarch64-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+asm-aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+asm-aarch64-devel}"
SRC_URI[x86_64_v2_rust-sha2+asm-aarch64-devel.sha256sum] = "06ddc820a95679470f907ddfc174de7930e8720da4b0b9fc98f905c16730c78d"

URI_x86_64_v2_rust-sha2+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+asm-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+asm-devel}"
SRC_URI[x86_64_v2_rust-sha2+asm-devel.sha256sum] = "f3c60b1a8e90406279b11cd6da88d4cf13609d7427f627f0b4e933cff9c13147"

URI_x86_64_v2_rust-sha2+compress-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+compress-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+compress-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+compress-devel}"
SRC_URI[x86_64_v2_rust-sha2+compress-devel.sha256sum] = "ee0c0d5edd9db02e8a787366fe2aca994078630e59ef7cfa39662244f6b4422b"

URI_x86_64_v2_rust-sha2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+default-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+default-devel}"
SRC_URI[x86_64_v2_rust-sha2+default-devel.sha256sum] = "9c69559d9bf0f3e29369bc5b0358d87e4cf32d283f8305e696db5dddf2f37bef"

URI_x86_64_v2_rust-sha2+force-soft-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+force-soft-compact-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+force-soft-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+force-soft-compact-devel}"
SRC_URI[x86_64_v2_rust-sha2+force-soft-compact-devel.sha256sum] = "1001585da25751912f0612c8f1f484cbc94ea4179232ff9d1972cf37e2d5596d"

URI_x86_64_v2_rust-sha2+force-soft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+force-soft-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+force-soft-devel}"
SRC_URI[x86_64_v2_rust-sha2+force-soft-devel.sha256sum] = "bbac8fc05ebf4327946b6ebedc4501788da496f814b7df6ca5791490bb207633"

URI_x86_64_v2_rust-sha2+loongarch64_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+loongarch64_asm-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+loongarch64_asm-devel}"
SRC_URI[x86_64_v2_rust-sha2+loongarch64_asm-devel.sha256sum] = "c6d8994b77cc171d71dc801ade5f29acce1feb5bb12f237db315cb23384a85ed"

URI_x86_64_v2_rust-sha2+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+oid-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+oid-devel}"
SRC_URI[x86_64_v2_rust-sha2+oid-devel.sha256sum] = "7b4cb74395b299253472395c24930e13826e3990cd04475841a5813176859e77"

URI_x86_64_v2_rust-sha2+sha2-asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+sha2-asm-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+sha2-asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+sha2-asm-devel}"
SRC_URI[x86_64_v2_rust-sha2+sha2-asm-devel.sha256sum] = "5300fef63a10f076c3c09a195a58113dcd6aad6b18b38db0151c9ba5732b1100"

URI_x86_64_v2_rust-sha2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+std-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+std-devel}"
SRC_URI[x86_64_v2_rust-sha2+std-devel.sha256sum] = "5077585eeb119f062f665405bd646f41c11680a5809d6e06537886ca02fd58ae"

URI_x86_64_v2_rust-sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2-devel}"
SRC_URI[x86_64_v2_rust-sha2-devel.sha256sum] = "9515cebc8f573b49f2b2d707f57225831d38ebd8122ed4d6349174659f59d78b"

URI_aarch64_rust-sha2+asm-aarch64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+asm-aarch64-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-sha2+asm-aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+asm-aarch64-devel}"
SRC_URI[aarch64_rust-sha2+asm-aarch64-devel.sha256sum] = "73808e6f3389c9018e89190a0915519e037bced3f0dc3fdba2999baad118139d"

URI_aarch64_rust-sha2+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+asm-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-sha2+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+asm-devel}"
SRC_URI[aarch64_rust-sha2+asm-devel.sha256sum] = "81a0ab4cb8489d3208efab23ffcf4254d2bc7e73b346e2772400353b570ad46c"

URI_aarch64_rust-sha2+compress-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+compress-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-sha2+compress-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+compress-devel}"
SRC_URI[aarch64_rust-sha2+compress-devel.sha256sum] = "587e5898cc104f66be410986fb34313b35406b63fd00c8900949eae12dc96176"

URI_aarch64_rust-sha2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+default-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-sha2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+default-devel}"
SRC_URI[aarch64_rust-sha2+default-devel.sha256sum] = "2456137f421c96c5275d2d1bf7f25d4f91bf9f34145681b87a0ee6f011bdcc1c"

URI_aarch64_rust-sha2+force-soft-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+force-soft-compact-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-sha2+force-soft-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+force-soft-compact-devel}"
SRC_URI[aarch64_rust-sha2+force-soft-compact-devel.sha256sum] = "2deb8f53ee9559eb0c9e640b5a2cd4648b76a38c1cc6dbbb5f201c72b00dbd51"

URI_aarch64_rust-sha2+force-soft-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+force-soft-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-sha2+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+force-soft-devel}"
SRC_URI[aarch64_rust-sha2+force-soft-devel.sha256sum] = "19bbffc58305eeb5d13fdaf3907968c9492665684f263da1cb88d76a0457b3ed"

URI_aarch64_rust-sha2+loongarch64_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+loongarch64_asm-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-sha2+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+loongarch64_asm-devel}"
SRC_URI[aarch64_rust-sha2+loongarch64_asm-devel.sha256sum] = "64714cb9eac739ef48051423b27a661cc260bc15d0c7b3298b56f629d2d747e9"

URI_aarch64_rust-sha2+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+oid-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-sha2+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+oid-devel}"
SRC_URI[aarch64_rust-sha2+oid-devel.sha256sum] = "bedee4c0c506127051a2a90409e91f9ffd0cff5a753429ec2f947178264df5ac"

URI_aarch64_rust-sha2+sha2-asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+sha2-asm-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-sha2+sha2-asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+sha2-asm-devel}"
SRC_URI[aarch64_rust-sha2+sha2-asm-devel.sha256sum] = "a014ad718e5a337ed2b52cb0066d0fd61e2abf0196eaa2c5527a937f6c41d8c7"

URI_aarch64_rust-sha2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+std-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-sha2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+std-devel}"
SRC_URI[aarch64_rust-sha2+std-devel.sha256sum] = "89b925f3c080b92924d32662ec8fada63596fb599a71f44d39b8a05e7add7036"

URI_aarch64_rust-sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2-devel}"
SRC_URI[aarch64_rust-sha2-devel.sha256sum] = "abfab95fe32e855cecd9601bcc6b45dd8950a1717147cd15ac0afa3456b7fd8a"

RDEPENDS:rust-sha2+asm-aarch64-devel = " \
 cargo \
 rust-sha2+asm-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+asm-devel = " \
 cargo \
 rust-sha2+sha2-asm-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+compress-devel = " \
 cargo \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+default-devel = " \
 cargo \
 rust-sha2+std-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+force-soft-compact-devel = " \
 cargo \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+force-soft-devel = " \
 cargo \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+loongarch64_asm-devel = " \
 cargo \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+oid-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+sha2-asm-devel = " \
 cargo \
 rust-sha2-asm+default-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-cpufeatures+default-devel \
 rust-digest+default-devel \
 "
