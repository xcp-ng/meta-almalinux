# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-git-version-macro"
PV = "0.3.9"
PR = "3.el10_0"
PACKAGES = " \
 rust-git-version-macro+default-devel \
 rust-git-version-macro+nightly-devel \
 rust-git-version-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-git-version-macro-0.3.9-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e7cca154b209bc64a7007c400fbf8504721ff6dbe4d14c427e86a5e85bae319"

URI_x86_64_v2_rust-git-version-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git-version-macro+default-devel-0.3.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git-version-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git-version-macro+default-devel}"
SRC_URI[x86_64_v2_rust-git-version-macro+default-devel.sha256sum] = "0594d85be287f533d1bd1675433919e987a3fbb0dc9eeb85fa7c15d12115fbea"

URI_x86_64_v2_rust-git-version-macro+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git-version-macro+nightly-devel-0.3.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git-version-macro+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git-version-macro+nightly-devel}"
SRC_URI[x86_64_v2_rust-git-version-macro+nightly-devel.sha256sum] = "b853e38a6d2758a025a6f3455aa30dddafe2b5dbc89bc40960be3c81b003973b"

URI_x86_64_v2_rust-git-version-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git-version-macro-devel-0.3.9-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git-version-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git-version-macro-devel}"
SRC_URI[x86_64_v2_rust-git-version-macro-devel.sha256sum] = "6e01bd73de3eba9eefeecd99f1f2645a411bfc27645fff5a11943a99b611f7b3"

URI_aarch64_rust-git-version-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git-version-macro+default-devel-0.3.9-3.el10_0.noarch.rpm;name=aarch64_rust-git-version-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git-version-macro+default-devel}"
SRC_URI[aarch64_rust-git-version-macro+default-devel.sha256sum] = "92e18f09dad51f2462a97cc6633f22c1ff8c12976db07d475df2bc31f0fe3226"

URI_aarch64_rust-git-version-macro+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git-version-macro+nightly-devel-0.3.9-3.el10_0.noarch.rpm;name=aarch64_rust-git-version-macro+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git-version-macro+nightly-devel}"
SRC_URI[aarch64_rust-git-version-macro+nightly-devel.sha256sum] = "88460c7c715c43a72878f911b2b125d70055a8b3ebb0f08d3f35b3cab0a4625b"

URI_aarch64_rust-git-version-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git-version-macro-devel-0.3.9-3.el10_0.noarch.rpm;name=aarch64_rust-git-version-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git-version-macro-devel}"
SRC_URI[aarch64_rust-git-version-macro-devel.sha256sum] = "db828b09bd6eb064642a3c3d818211c054abd1068378dff84f30fa55b3086e38"

RDEPENDS:rust-git-version-macro+default-devel = " \
 cargo \
 rust-git-version-macro-devel \
 "
RDEPENDS:rust-git-version-macro+nightly-devel = " \
 cargo \
 rust-git-version-macro-devel \
 "
RDEPENDS:rust-git-version-macro-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
