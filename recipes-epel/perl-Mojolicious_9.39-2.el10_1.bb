# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Mojolicious"
PV = "9.39"
PR = "2.el10_1"
PACKAGES = " \
 perl-Mojolicious \
 perl-Test-Mojo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Mojolicious-9.39-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0074962d1837bf5837de24585cb539564063a4c28a64253de0091e415e6f4f34"

URI_x86_64_v2_perl-Mojolicious = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Mojolicious-9.39-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Mojolicious;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Mojolicious}"
SRC_URI[x86_64_v2_perl-Mojolicious.sha256sum] = "f3f613e188d3014da3370df40992be783def11acbc888e912dd220937de20741"

URI_x86_64_v2_perl-Test-Mojo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Mojo-9.39-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Mojo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Mojo}"
SRC_URI[x86_64_v2_perl-Test-Mojo.sha256sum] = "48a11dbdc595f1afeab690852c57631439120b08654895813d0db5cacf3664f8"

URI_aarch64_perl-Mojolicious = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Mojolicious-9.39-2.el10_1.noarch.rpm;name=aarch64_perl-Mojolicious;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Mojolicious}"
SRC_URI[aarch64_perl-Mojolicious.sha256sum] = "b61806908a7ed2410903a7187a83d75095be1b5e06fe3979127803c9c8cc7c6d"

URI_aarch64_perl-Test-Mojo = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Mojo-9.39-2.el10_1.noarch.rpm;name=aarch64_perl-Test-Mojo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Mojo}"
SRC_URI[aarch64_perl-Test-Mojo.sha256sum] = "526fa1b1d9597f5d4f8c8e954793edf1629989a28c4ced1d94921df235f49ec5"

RDEPENDS:perl-Mojolicious = " \
 perl-Benchmark \
 perl-CPAN-Meta-YAML \
 perl-Carp \
 perl-Compress-Raw-Zlib \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Encode \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-File-stat \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Hash-Util-FieldHash \
 perl-IO \
 perl-IO-Compress \
 perl-IO-Socket-IP \
 perl-JSON-PP \
 perl-MIME-Base64 \
 perl-Mojolicious \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Scalar-List-Utils \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Term-ANSIColor \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-Unicode-Normalize \
 perl-constant \
 perl-experimental \
 perl-interpreter \
 perl-libs \
 perl-mro \
 perl-overload \
 "
RDEPENDS:perl-Test-Mojo = " \
 perl-Mojolicious \
 perl-Test-Simple \
 perl-libs \
 "
