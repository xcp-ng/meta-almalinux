# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libspatialaudio"
PV = "3.1"
PR = "20.20200406gitd926a2e.el10_0"
PACKAGES = " \
 libspatialaudio \
 libspatialaudio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libspatialaudio-3.1-20.20200406gitd926a2e.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6281aed4d7eff94ffde3fa224f5cc8983f89f145d1b6951029a5d3ad04210404"

URI_x86_64_v2_libspatialaudio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libspatialaudio-3.1-20.20200406gitd926a2e.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libspatialaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libspatialaudio}"
SRC_URI[x86_64_v2_libspatialaudio.sha256sum] = "c10a17f4ff0d740b506c1bd34373f3dbc98d13fd25c41f60eba9852934a087de"

URI_x86_64_v2_libspatialaudio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libspatialaudio-devel-3.1-20.20200406gitd926a2e.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libspatialaudio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libspatialaudio-devel}"
SRC_URI[x86_64_v2_libspatialaudio-devel.sha256sum] = "cdb75fe04be55a689deae774ffbd9109996139b338d15bca6a25b73d5edfd8c3"

URI_aarch64_libspatialaudio = "${EPEL_MIRROR}/aarch64/Packages/l/libspatialaudio-3.1-20.20200406gitd926a2e.el10_0.aarch64.rpm;name=aarch64_libspatialaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_libspatialaudio}"
SRC_URI[aarch64_libspatialaudio.sha256sum] = "52168180b6fa72014caabf5752ae05bbd9d56aca31ee66c7b4b499c658b8b6b7"

URI_aarch64_libspatialaudio-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libspatialaudio-devel-3.1-20.20200406gitd926a2e.el10_0.aarch64.rpm;name=aarch64_libspatialaudio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libspatialaudio-devel}"
SRC_URI[aarch64_libspatialaudio-devel.sha256sum] = "adec47a122d728dcbbf381a191498ed1a54ef50a97829d660b88ae7c28df1b0a"

RDEPENDS:libspatialaudio = " \
 glibc \
 libgcc \
 libmysofa \
 libstdc++ \
 "
RDEPENDS:libspatialaudio-devel = " \
 libmysofa-devel \
 libspatialaudio \
 pkgconf-pkg-config \
 "
