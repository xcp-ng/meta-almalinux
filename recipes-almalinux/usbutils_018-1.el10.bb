# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "usbutils"
PV = "018"
PR = "1.el10"
PACKAGES = " \
 usbutils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/usbutils-018-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "51426937170c9b87a00f474c0f2de9f5f286941e591f10b896ecdebc1b7a26bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/usbutils-018-1.el10.x86_64_v2.rpm;name=x86_64_v2_usbutils;unpack=0"
SRC_URI[x86_64_v2_usbutils.sha256sum] = "6219bb969754baf3291f068e154d2bd4b03683bf39e6411b0d25c2e6fa466b66"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/usbutils-018-1.el10.aarch64.rpm;name=aarch64_usbutils;unpack=0"
SRC_URI[aarch64_usbutils.sha256sum] = "f1dc02550f2f0117c99ff68b25eef4974d62ad34386db862fd107b096f7a5ad0"

RDEPENDS:usbutils = " \
 bash \
 glibc \
 hwdata \
 libusb1 \
 python3 \
 systemd-libs \
 "
