# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knights"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 knights \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knights-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c96f23b1058ffdce2e454f23e85332502d12ed91e1839babf72419c08333844d"

URI_x86_64_v2_knights = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knights-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knights;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knights}"
SRC_URI[x86_64_v2_knights.sha256sum] = "129433dc2e71ee44c06267da02878e85098942bd8da562e55d802a901402d7da"

URI_aarch64_knights = "${EPEL_MIRROR}/aarch64/Packages/k/knights-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_knights;unpack=0"
SRC_URI:append = " ${URI_aarch64_knights}"
SRC_URI[aarch64_knights.sha256sum] = "7fd5190db10e919d8ce7383bbbdebcdedb09e9068af839fb700955983c804e68"

RDEPENDS:knights = " \
 glibc \
 gnuchess \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kplotting \
 kf6-ksvg \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
