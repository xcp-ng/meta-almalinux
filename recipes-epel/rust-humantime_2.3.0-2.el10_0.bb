# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-humantime"
PV = "2.3.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-humantime+default-devel \
 rust-humantime+mu-devel \
 rust-humantime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-humantime-2.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96dd8ecdf8f02c6712e1ad165b3f35eea85dcecd401ac511fa7cab690a41d26a"

URI_x86_64_v2_rust-humantime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime+default-devel-2.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime+default-devel}"
SRC_URI[x86_64_v2_rust-humantime+default-devel.sha256sum] = "c9b33db2a84f76b17fd3da84482f939415c91e79b143f0a4e50ea9a28507f6a9"

URI_x86_64_v2_rust-humantime+mu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime+mu-devel-2.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime+mu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime+mu-devel}"
SRC_URI[x86_64_v2_rust-humantime+mu-devel.sha256sum] = "24367618a736f3ce2d670635855bb75a6231cc1477b178cb3373eeba4f485305"

URI_x86_64_v2_rust-humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime-devel-2.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime-devel}"
SRC_URI[x86_64_v2_rust-humantime-devel.sha256sum] = "54940afb56909b2273441c5865c322ae145a672e3635ad521a4ffb8c91c2e553"

URI_aarch64_rust-humantime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime+default-devel-2.3.0-2.el10_0.noarch.rpm;name=aarch64_rust-humantime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime+default-devel}"
SRC_URI[aarch64_rust-humantime+default-devel.sha256sum] = "7637e05796ff6fe8010e6856aada9ae922b8d830ada89725b2e5244773a5b9c6"

URI_aarch64_rust-humantime+mu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime+mu-devel-2.3.0-2.el10_0.noarch.rpm;name=aarch64_rust-humantime+mu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime+mu-devel}"
SRC_URI[aarch64_rust-humantime+mu-devel.sha256sum] = "b40fb71e9997908fb95fefe74e46a136b4eb93cbacdb68896090f57599ca319d"

URI_aarch64_rust-humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime-devel-2.3.0-2.el10_0.noarch.rpm;name=aarch64_rust-humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime-devel}"
SRC_URI[aarch64_rust-humantime-devel.sha256sum] = "304ec78a80626df6f7549d400de30c972ae091de47bbfddccbd59eec7337d1ee"

RDEPENDS:rust-humantime+default-devel = " \
 cargo \
 rust-humantime-devel \
 "
RDEPENDS:rust-humantime+mu-devel = " \
 cargo \
 rust-humantime-devel \
 "
RDEPENDS:rust-humantime-devel = " \
 cargo \
 "
