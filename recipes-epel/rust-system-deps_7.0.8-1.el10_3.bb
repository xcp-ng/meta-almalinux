# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-system-deps"
PV = "7.0.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-system-deps+default-devel \
 rust-system-deps-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-system-deps-7.0.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47a09a0453af5c3c205017a3a2a1b6e66a4730969ed67c0aaa50a3a3f6234022"

URI_x86_64_v2_rust-system-deps+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-system-deps+default-devel-7.0.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-system-deps+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-system-deps+default-devel}"
SRC_URI[x86_64_v2_rust-system-deps+default-devel.sha256sum] = "e7dfc5aecd359dbdd3fcd33610e62f154f05c366abae64fba307d64cb659b03d"

URI_x86_64_v2_rust-system-deps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-system-deps-devel-7.0.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-system-deps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-system-deps-devel}"
SRC_URI[x86_64_v2_rust-system-deps-devel.sha256sum] = "1e9443492e3ff9a284b6de5f58ac5826643bfa02f42676e7430dc38456b771b3"

URI_aarch64_rust-system-deps+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-system-deps+default-devel-7.0.8-1.el10_3.noarch.rpm;name=aarch64_rust-system-deps+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-system-deps+default-devel}"
SRC_URI[aarch64_rust-system-deps+default-devel.sha256sum] = "71de5a326b103d25ecd5ecd4e0a31ecc23b27db192fed43552e14e19318323e7"

URI_aarch64_rust-system-deps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-system-deps-devel-7.0.8-1.el10_3.noarch.rpm;name=aarch64_rust-system-deps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-system-deps-devel}"
SRC_URI[aarch64_rust-system-deps-devel.sha256sum] = "aebd7bffdbdd82629451727a1806e458974dde5820e30b46f2b1d4405d4ea71a"

RDEPENDS:rust-system-deps+default-devel = " \
 cargo \
 rust-system-deps-devel \
 "
RDEPENDS:rust-system-deps-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-pkg-config+default-devel \
 rust-toml+parse-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 rust-version-compare+default-devel \
 virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~ \
 virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~ \
 "
