# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-oauth"
PV = "2.0.9"
PR = "1.el10_0"
PACKAGES = " \
 php-pecl-oauth \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-pecl-oauth-2.0.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f6a458077313c9fa071d2598789fa43a0658f1de89da04220faf33fb7684e7ee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-oauth-2.0.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-oauth;unpack=0"
SRC_URI[x86_64_v2_php-pecl-oauth.sha256sum] = "9dc045613a1c11f9c9fa1068994da97543d3dc7035d68c5f134826806d955e3e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-oauth-2.0.9-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-oauth;unpack=0"
SRC_URI[aarch64_php-pecl-oauth.sha256sum] = "fc029566b463426e43d83ddda824eb141b6b7601ddbb416b0d6f8ecb934360bb"

RDEPENDS:php-pecl-oauth = " \
 glibc \
 php-common \
 virtual/libcurl.so.4___64bit_ \
 "
