# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hkdf0.12"
PV = "0.12.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-hkdf0.12+default-devel \
 rust-hkdf0.12+std-devel \
 rust-hkdf0.12-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hkdf0.12-0.12.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b39dfc22df3dae61bd1ca8889eeb77f5081a7e564986e241d91eed8592e8bc70"

URI_x86_64_v2_rust-hkdf0.12+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hkdf0.12+default-devel-0.12.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hkdf0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hkdf0.12+default-devel}"
SRC_URI[x86_64_v2_rust-hkdf0.12+default-devel.sha256sum] = "2ea130f89065d5cf476d329d934a09f23e533c25bd2e9276a5107e49df2a21b5"

URI_x86_64_v2_rust-hkdf0.12+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hkdf0.12+std-devel-0.12.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hkdf0.12+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hkdf0.12+std-devel}"
SRC_URI[x86_64_v2_rust-hkdf0.12+std-devel.sha256sum] = "3f4712f578797f014f4df2dca443d4639420d0bc9e788f0b0c8923c4a912e9c3"

URI_x86_64_v2_rust-hkdf0.12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hkdf0.12-devel-0.12.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hkdf0.12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hkdf0.12-devel}"
SRC_URI[x86_64_v2_rust-hkdf0.12-devel.sha256sum] = "8adf071f890c5dbc3ec0ab5b9af9573d6c0c9bdbcbe2a2e2793610a9b17bcc20"

URI_aarch64_rust-hkdf0.12+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hkdf0.12+default-devel-0.12.4-1.el10_3.noarch.rpm;name=aarch64_rust-hkdf0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hkdf0.12+default-devel}"
SRC_URI[aarch64_rust-hkdf0.12+default-devel.sha256sum] = "b3a8b4c8d2f3d92fa8a8bfd78f2758724bc5854dc315949d1940d864952f5e6c"

URI_aarch64_rust-hkdf0.12+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hkdf0.12+std-devel-0.12.4-1.el10_3.noarch.rpm;name=aarch64_rust-hkdf0.12+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hkdf0.12+std-devel}"
SRC_URI[aarch64_rust-hkdf0.12+std-devel.sha256sum] = "9a4ac15c6ebbb61c05ccb7f4ce6913e75b0739e43282113b5bee0533d29609af"

URI_aarch64_rust-hkdf0.12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hkdf0.12-devel-0.12.4-1.el10_3.noarch.rpm;name=aarch64_rust-hkdf0.12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hkdf0.12-devel}"
SRC_URI[aarch64_rust-hkdf0.12-devel.sha256sum] = "94e162160b4129753afb31c36404807168f635e53bfe408f98a78de802ebff87"

RDEPENDS:rust-hkdf0.12+default-devel = " \
 cargo \
 rust-hkdf0.12-devel \
 "
RDEPENDS:rust-hkdf0.12+std-devel = " \
 cargo \
 rust-hkdf0.12-devel \
 rust-hmac0.12+std-devel \
 "
RDEPENDS:rust-hkdf0.12-devel = " \
 cargo \
 rust-hmac0.12+default-devel \
 "
