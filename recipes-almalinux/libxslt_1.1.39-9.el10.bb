# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxslt"
PV = "1.1.39"
PR = "9.el10"
PACKAGES = " \
 libxslt \
 libxslt-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libxslt-1.1.39-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4eb774e2b7a522315d366120020baef3c3dc615914d5c11f4c9e470855689eaf"

URI_x86_64_v2_libxslt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxslt-1.1.39-9.el10.x86_64_v2.rpm;name=x86_64_v2_libxslt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxslt}"
SRC_URI[x86_64_v2_libxslt.sha256sum] = "1e7bda7311d63b3cc7d92afb4d0ce1c925f83f6b1d1f534eb0d2a6f55c2455a0"

URI_x86_64_v2_libxslt-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxslt-devel-1.1.39-9.el10.x86_64_v2.rpm;name=x86_64_v2_libxslt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxslt-devel}"
SRC_URI[x86_64_v2_libxslt-devel.sha256sum] = "6fb817be81d77e3bdd70b96ce94ca7387e47d9cc292fffb5dd6f2886dadc7805"

URI_aarch64_libxslt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxslt-1.1.39-9.el10.aarch64.rpm;name=aarch64_libxslt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxslt}"
SRC_URI[aarch64_libxslt.sha256sum] = "dfebcbda20d348fd98a9f47c7600497be43e948bbddcef592cf35ca26eac520d"

URI_aarch64_libxslt-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxslt-devel-1.1.39-9.el10.aarch64.rpm;name=aarch64_libxslt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxslt-devel}"
SRC_URI[aarch64_libxslt-devel.sha256sum] = "5f3903f0cef5a39064a68d694e8c43ef6fa9b9440db4d1f922ccf4d2f789d425"

RDEPENDS:libxslt = " \
 glibc \
 libxml2 \
 "
RDEPENDS:libxslt-devel = " \
 bash \
 libgpg-error-devel \
 libxml2-devel \
 libxslt \
 libxslt-devel \
 pkgconf-pkg-config \
 "
