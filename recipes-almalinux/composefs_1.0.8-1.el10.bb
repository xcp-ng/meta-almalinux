# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "composefs"
PV = "1.0.8"
PR = "1.el10"
PACKAGES = " \
 composefs \
 composefs-devel \
 composefs-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/composefs-1.0.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8187de35d9a036e621f7b35f0f93add26814ed0feb52c0d91ac25eca743e4a2"

URI_x86_64_v2_composefs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/composefs-1.0.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_composefs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_composefs}"
SRC_URI[x86_64_v2_composefs.sha256sum] = "f36592b3ebe12d4e308cc624c39eda936458970a63665735bbcb827ef3b1407d"

URI_x86_64_v2_composefs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/composefs-devel-1.0.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_composefs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_composefs-devel}"
SRC_URI[x86_64_v2_composefs-devel.sha256sum] = "20ac2bf817046df58b7c4df8b50cd06eec63eb9584a0e1dc462a20f9e5993fca"

URI_x86_64_v2_composefs-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/composefs-libs-1.0.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_composefs-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_composefs-libs}"
SRC_URI[x86_64_v2_composefs-libs.sha256sum] = "d79e1069bd56c63aacf9229d4b0cd0110bc72205707379b76a2904cb61c308a4"

URI_aarch64_composefs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/composefs-1.0.8-1.el10.aarch64.rpm;name=aarch64_composefs;unpack=0"
SRC_URI:append = " ${URI_aarch64_composefs}"
SRC_URI[aarch64_composefs.sha256sum] = "551e67fbc676c67a53ee2646bdeb24733eed34306446477406e5c22b3f8c3a55"

URI_aarch64_composefs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/composefs-devel-1.0.8-1.el10.aarch64.rpm;name=aarch64_composefs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_composefs-devel}"
SRC_URI[aarch64_composefs-devel.sha256sum] = "cb44504d2abbfb990b9d9f764c79bf8e35fb6a61e565adb2712d26a7959dee3e"

URI_aarch64_composefs-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/composefs-libs-1.0.8-1.el10.aarch64.rpm;name=aarch64_composefs-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_composefs-libs}"
SRC_URI[aarch64_composefs-libs.sha256sum] = "c1a7ff4e29a7fd54203bfdbc0776db74f92d5bd668e565dec0e42fe359bdc054"

RDEPENDS:composefs = " \
 composefs-libs \
 glibc \
 libgcc \
 "
RDEPENDS:composefs-devel = " \
 composefs \
 composefs-libs \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:composefs-libs = " \
 glibc \
 libgcc \
 openssl-libs \
 "
