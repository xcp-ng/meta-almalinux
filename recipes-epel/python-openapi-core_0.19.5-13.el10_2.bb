# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openapi-core"
PV = "0.19.5"
PR = "13.el10_2"
PACKAGES = " \
 python3-openapi-core \
 python3-openapi-core+aiohttp \
 python3-openapi-core+falcon \
 python3-openapi-core+fastapi \
 python3-openapi-core+flask \
 python3-openapi-core+requests \
 python3-openapi-core+starlette \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openapi-core-0.19.5-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76b666188be8fc02fad70e89bddd28936dd07781e780d39c214bee99786b82f6"

URI_x86_64_v2_python3-openapi-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core-0.19.5-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core}"
SRC_URI[x86_64_v2_python3-openapi-core.sha256sum] = "8e4ffa625c5bc3d504585e3017fae4ed6700469e4b55db3b8eef0bf71e336d6f"

URI_x86_64_v2_python3-openapi-core+aiohttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core+aiohttp-0.19.5-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core+aiohttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core+aiohttp}"
SRC_URI[x86_64_v2_python3-openapi-core+aiohttp.sha256sum] = "bca4e66b3ea1914cc492ab251f5d611d7834edd01206f90278c4c458fca994b7"

URI_x86_64_v2_python3-openapi-core+falcon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core+falcon-0.19.5-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core+falcon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core+falcon}"
SRC_URI[x86_64_v2_python3-openapi-core+falcon.sha256sum] = "39f78ffa236a86e99184f19da5a496b412f0fb714b286523998e9bbbf5522976"

URI_x86_64_v2_python3-openapi-core+fastapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core+fastapi-0.19.5-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core+fastapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core+fastapi}"
SRC_URI[x86_64_v2_python3-openapi-core+fastapi.sha256sum] = "57febcc0a8887edafc60df122d07bd9577ff1d4e298873870dbf515708100c48"

URI_x86_64_v2_python3-openapi-core+flask = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core+flask-0.19.5-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core+flask;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core+flask}"
SRC_URI[x86_64_v2_python3-openapi-core+flask.sha256sum] = "c6e536a206c96cb445c6c1a4af1ffb73f72c3e9b9034f4711c89be5ece904e9b"

URI_x86_64_v2_python3-openapi-core+requests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core+requests-0.19.5-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core+requests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core+requests}"
SRC_URI[x86_64_v2_python3-openapi-core+requests.sha256sum] = "179eeee9ac195b8f61bd7c1ad53745e745eac81a6ec2b992d437411a67a5b997"

URI_x86_64_v2_python3-openapi-core+starlette = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-core+starlette-0.19.5-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-core+starlette;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-core+starlette}"
SRC_URI[x86_64_v2_python3-openapi-core+starlette.sha256sum] = "2a9465ee17075490e6f4cdaba29b1e4dc4f8d416a9619056f1c6f91192d8ac3c"

URI_aarch64_python3-openapi-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core-0.19.5-13.el10_2.noarch.rpm;name=aarch64_python3-openapi-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core}"
SRC_URI[aarch64_python3-openapi-core.sha256sum] = "e024765397eb9244efdce2b0cbba8f8dbdde1b64760052ed74e20a867fe0eef8"

URI_aarch64_python3-openapi-core+aiohttp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core+aiohttp-0.19.5-13.el10_2.noarch.rpm;name=aarch64_python3-openapi-core+aiohttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core+aiohttp}"
SRC_URI[aarch64_python3-openapi-core+aiohttp.sha256sum] = "588a735e77351969065c639669148a60226777152c229cc4901b61370f423174"

URI_aarch64_python3-openapi-core+falcon = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core+falcon-0.19.5-13.el10_2.noarch.rpm;name=aarch64_python3-openapi-core+falcon;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core+falcon}"
SRC_URI[aarch64_python3-openapi-core+falcon.sha256sum] = "2b76236a3646215ebd12ee1312b468c456df243fcfdb3b57caeae8f81ea9d411"

URI_aarch64_python3-openapi-core+fastapi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core+fastapi-0.19.5-13.el10_2.noarch.rpm;name=aarch64_python3-openapi-core+fastapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core+fastapi}"
SRC_URI[aarch64_python3-openapi-core+fastapi.sha256sum] = "c876c4cbb56dc1e7971300f182824ddad645fa728ccead833f900af85221b8a5"

URI_aarch64_python3-openapi-core+flask = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core+flask-0.19.5-13.el10_2.noarch.rpm;name=aarch64_python3-openapi-core+flask;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core+flask}"
SRC_URI[aarch64_python3-openapi-core+flask.sha256sum] = "e7ea0161228ebb0afb35db10d37fe8b6d11874f6297c10e2db0c2def86267422"

URI_aarch64_python3-openapi-core+requests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core+requests-0.19.5-13.el10_2.noarch.rpm;name=aarch64_python3-openapi-core+requests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core+requests}"
SRC_URI[aarch64_python3-openapi-core+requests.sha256sum] = "8085a10132bc0a6ca89ac5d1e2371f38e4642bcaeb9faf655d9ba894e170ab42"

URI_aarch64_python3-openapi-core+starlette = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-core+starlette-0.19.5-13.el10_2.noarch.rpm;name=aarch64_python3-openapi-core+starlette;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-core+starlette}"
SRC_URI[aarch64_python3-openapi-core+starlette.sha256sum] = "583523afcf4012e971569a5ad5427c5a2239afc50e9b1a5f00896ea8dc6b6a2e"

RDEPENDS:python3-openapi-core = " \
 python3 \
 python3-isodate \
 python3-jsonschema \
 python3-jsonschema-path \
 python3-more-itertools \
 python3-openapi-schema-validator \
 python3-openapi-spec-validator \
 python3-parse \
 python3-typing-extensions \
 python3-werkzeug \
 "
RDEPENDS:python3-openapi-core+aiohttp = " \
 python3 \
 python3-aiohttp \
 python3-multidict \
 python3-openapi-core \
 "
RDEPENDS:python3-openapi-core+falcon = " \
 python3 \
 python3-falcon \
 python3-openapi-core \
 "
RDEPENDS:python3-openapi-core+fastapi = " \
 python3 \
 python3-fastapi \
 python3-openapi-core \
 "
RDEPENDS:python3-openapi-core+flask = " \
 python3 \
 python3-flask \
 python3-openapi-core \
 "
RDEPENDS:python3-openapi-core+requests = " \
 python3 \
 python3-openapi-core \
 python3-requests \
 "
RDEPENDS:python3-openapi-core+starlette = " \
 python3 \
 python3-aioitertools \
 python3-openapi-core \
 python3-starlette \
 "
