# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-temporary"
PV = "1.3"
PR = "26.el10_0"
PACKAGES = " \
 ghc-temporary \
 ghc-temporary-devel \
 ghc-temporary-doc \
 ghc-temporary-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-temporary-1.3-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fd1970c1f90ba5c9dfd387f671c05519109bce254e52d1bd223a6a2fe847ae7"

URI_x86_64_v2_ghc-temporary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-temporary-1.3-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-temporary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-temporary}"
SRC_URI[x86_64_v2_ghc-temporary.sha256sum] = "6fe212cbad92e8f16bddc1d61f97f9d01e34d07e3952b6f4dec67b00de2f1200"

URI_x86_64_v2_ghc-temporary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-temporary-devel-1.3-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-temporary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-temporary-devel}"
SRC_URI[x86_64_v2_ghc-temporary-devel.sha256sum] = "290561fa4a52844726a90eb3ac159b6d8d15971eb110c98fecdadb7988c67ab0"

URI_x86_64_v2_ghc-temporary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-temporary-doc-1.3-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-temporary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-temporary-doc}"
SRC_URI[x86_64_v2_ghc-temporary-doc.sha256sum] = "2ef0077fab813b44b0518195cc041fd21519f624807f85f1955fd220764517c0"

URI_x86_64_v2_ghc-temporary-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-temporary-prof-1.3-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-temporary-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-temporary-prof}"
SRC_URI[x86_64_v2_ghc-temporary-prof.sha256sum] = "59a5309eafff8d2827855d4ede28f3d9fd118a3293ad57e9eca0e35818b0668c"

URI_aarch64_ghc-temporary = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-temporary-1.3-26.el10_0.aarch64.rpm;name=aarch64_ghc-temporary;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-temporary}"
SRC_URI[aarch64_ghc-temporary.sha256sum] = "7d50b58f64c31d6d2a23709df79f0c23cd1bc5e1ef99fd67d23537245e113f49"

URI_aarch64_ghc-temporary-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-temporary-devel-1.3-26.el10_0.aarch64.rpm;name=aarch64_ghc-temporary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-temporary-devel}"
SRC_URI[aarch64_ghc-temporary-devel.sha256sum] = "cb71184f94be4de0a9268ebb59104d621c9bf2fb26003238416cd5ad6bdea4de"

URI_aarch64_ghc-temporary-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-temporary-doc-1.3-26.el10_0.noarch.rpm;name=aarch64_ghc-temporary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-temporary-doc}"
SRC_URI[aarch64_ghc-temporary-doc.sha256sum] = "ec213f406d32a8443279c326838b2e574044e91dbf5f25c893fc785e8e4b544e"

URI_aarch64_ghc-temporary-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-temporary-prof-1.3-26.el10_0.aarch64.rpm;name=aarch64_ghc-temporary-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-temporary-prof}"
SRC_URI[aarch64_ghc-temporary-prof.sha256sum] = "d0ef810588dc3fcf330614cdc439513d9429e6a0023d56480d1f5727d04c6a41"

RDEPENDS:ghc-temporary = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-random \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-temporary-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-random-devel \
 ghc-temporary \
 ghc-transformers-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-temporary-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-temporary-prof = " \
 ghc-base-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-random-prof \
 ghc-temporary-devel \
 ghc-transformers-prof \
 ghc-unix-prof \
 "
