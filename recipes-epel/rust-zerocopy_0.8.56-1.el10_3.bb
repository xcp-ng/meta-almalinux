# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy"
PV = "0.8.56"
PR = "1.el10_3"
PACKAGES = " \
 rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel \
 rust-zerocopy+alloc-devel \
 rust-zerocopy+default-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+float-nightly-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy+simd-nightly-devel \
 rust-zerocopy+std-devel \
 rust-zerocopy+zerocopy-derive-devel \
 rust-zerocopy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy-0.8.56-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79837e9ac7ba2873108e11ce3e919e12338f09d4c772f9779d21bf7e4389bd1f"

URI_x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel-0.8.56-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "5deac90d4c68ebdf416b741c8e9729fb927386045b0d36a23736c158ef77541d"

URI_x86_64_v2_rust-zerocopy+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+alloc-devel-0.8.56-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+alloc-devel.sha256sum] = "89b5ee663b049a1cea14c21dbbe84d02a335feda0ae72392b1b29c8ebe05d7cc"

URI_x86_64_v2_rust-zerocopy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+default-devel-0.8.56-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+default-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+default-devel.sha256sum] = "b052f8fac295e155ee25b063605df2cd09f1a94ec91fb012b264d262a43dce5c"

URI_x86_64_v2_rust-zerocopy+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+derive-devel-0.8.56-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+derive-devel.sha256sum] = "442e270cd4a0fdfa46c6a23b7e21b669a4eb7fa442d0f28bfdf13d25cc10c94c"

URI_x86_64_v2_rust-zerocopy+float-nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+float-nightly-devel-0.8.56-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+float-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+float-nightly-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+float-nightly-devel.sha256sum] = "3b4554d9f6d103ee61ae208186f14e8e354aa588a49a40fa73032f71b0607691"

URI_x86_64_v2_rust-zerocopy+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+simd-devel-0.8.56-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+simd-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+simd-devel.sha256sum] = "89f7c0d8dbd7878f05b9696ff726bd86d4073c7f7f90a876425033d1394cef9a"

URI_x86_64_v2_rust-zerocopy+simd-nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+simd-nightly-devel-0.8.56-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+simd-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+simd-nightly-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+simd-nightly-devel.sha256sum] = "969214b28e93225f01615673e4c03f24d30a091c64af694184f197edb6c91ed8"

URI_x86_64_v2_rust-zerocopy+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+std-devel-0.8.56-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+std-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+std-devel.sha256sum] = "c9e0ec1551e02c312784e0482291af37916a4f0282fe4b7c94a884b0d537a961"

URI_x86_64_v2_rust-zerocopy+zerocopy-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+zerocopy-derive-devel-0.8.56-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+zerocopy-derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+zerocopy-derive-devel.sha256sum] = "1512b6fbf17db9b43b1d1d54185986eb64bfc5fc2444c24a95671bad90253950"

URI_x86_64_v2_rust-zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-devel-0.8.56-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-devel.sha256sum] = "939834c94cf3d8f8a87715bf0fb39986eddffc7b0cce5108d677c1f1dad2e0aa"

URI_aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel-0.8.56-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel}"
SRC_URI[aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "780bcd47dc2e8039baebd9808713853e8b800cec6dbc8a49d6c6807589ca5dd9"

URI_aarch64_rust-zerocopy+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+alloc-devel-0.8.56-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+alloc-devel}"
SRC_URI[aarch64_rust-zerocopy+alloc-devel.sha256sum] = "8a8c403b63b9531918795540c97a76d15878907e72f39f738ea83335b27dd835"

URI_aarch64_rust-zerocopy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+default-devel-0.8.56-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+default-devel}"
SRC_URI[aarch64_rust-zerocopy+default-devel.sha256sum] = "f05fe9e973450595f7252e466c535525d5ef1c5ad0a967222a6a4c769258b817"

URI_aarch64_rust-zerocopy+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+derive-devel-0.8.56-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+derive-devel}"
SRC_URI[aarch64_rust-zerocopy+derive-devel.sha256sum] = "bb6dba6448fcc55f0ae7535a3ff886c70d3d3a9d6a7a1d34f805f11cf25420ab"

URI_aarch64_rust-zerocopy+float-nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+float-nightly-devel-0.8.56-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+float-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+float-nightly-devel}"
SRC_URI[aarch64_rust-zerocopy+float-nightly-devel.sha256sum] = "b83a1b2d826d864a19ce11f7eedc2c21dee9f06983e8c055da68bfede49b9c90"

URI_aarch64_rust-zerocopy+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+simd-devel-0.8.56-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+simd-devel}"
SRC_URI[aarch64_rust-zerocopy+simd-devel.sha256sum] = "9c03e013afdee28fce213d66a93ea8d35c119230f0fe442e374c7eb1ea3490c3"

URI_aarch64_rust-zerocopy+simd-nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+simd-nightly-devel-0.8.56-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+simd-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+simd-nightly-devel}"
SRC_URI[aarch64_rust-zerocopy+simd-nightly-devel.sha256sum] = "25e9aa42978deed1d61215f47d8085b40985b399bb66de8b6e761b4d33a42e3e"

URI_aarch64_rust-zerocopy+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+std-devel-0.8.56-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+std-devel}"
SRC_URI[aarch64_rust-zerocopy+std-devel.sha256sum] = "be41eb122ebc1e25be0832176c9c66ea5769324d5f9a31844379a6caaf0877fb"

URI_aarch64_rust-zerocopy+zerocopy-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+zerocopy-derive-devel-0.8.56-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy+zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+zerocopy-derive-devel}"
SRC_URI[aarch64_rust-zerocopy+zerocopy-derive-devel.sha256sum] = "f48cf7f0ceee05e8f2588719c63d887625a5f885369837e941d61260be788bdc"

URI_aarch64_rust-zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-devel-0.8.56-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-devel}"
SRC_URI[aarch64_rust-zerocopy-devel.sha256sum] = "71e3200a3d6a5924e0b5770cfb89daa170ee1a4bfbef9efc8854fbaeff7f4dc4"

RDEPENDS:rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = " \
 cargo \
 rust-zerocopy+alloc-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy+std-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+alloc-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+default-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+derive-devel = " \
 cargo \
 rust-zerocopy+zerocopy-derive-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+float-nightly-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+simd-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+simd-nightly-devel = " \
 cargo \
 rust-zerocopy+simd-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+std-devel = " \
 cargo \
 rust-zerocopy+alloc-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+zerocopy-derive-devel = " \
 cargo \
 rust-zerocopy-derive+default-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy-devel = " \
 cargo \
 rust \
 rust-zerocopy-derive+default-devel \
 "
