# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-gtk-config"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kde-gtk-config \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kde-gtk-config-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "91c86a07ac2cac8813ae8af211dde3e7d4b6740ab26259dcb310901d17420111"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-gtk-config-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-gtk-config;unpack=0"
SRC_URI[x86_64_v2_kde-gtk-config.sha256sum] = "0713457eb52a5871efbcee9de21faef62406ec3e4a319f0f0e933157e43a310a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-gtk-config-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kde-gtk-config;unpack=0"
SRC_URI[aarch64_kde-gtk-config.sha256sum] = "9bdfc299927ed1bebbf894be16f40cbc218e5484916e3b0dd60cec80cc29e615"

RDEPENDS:kde-gtk-config = " \
 bash \
 breeze-gtk-common \
 glib2 \
 glibc \
 gtk3 \
 kde-cli-tools \
 kdecoration \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
