# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-RPM2"
PV = "1.4"
PR = "36.el10_2"
PACKAGES = " \
 perl-RPM2 \
 perl-RPM2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-RPM2-1.4-36.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc2f3894342da6751767cd2c9655f27f07af7f2e3c032c903e5e4896b01c8e33"

URI_x86_64_v2_perl-RPM2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-RPM2-1.4-36.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-RPM2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-RPM2}"
SRC_URI[x86_64_v2_perl-RPM2.sha256sum] = "2aa17173544b6c4fe3ee95d45fc6967608cb2ac38b964bcede502d2fd11bdb66"

URI_x86_64_v2_perl-RPM2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-RPM2-tests-1.4-36.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-RPM2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-RPM2-tests}"
SRC_URI[x86_64_v2_perl-RPM2-tests.sha256sum] = "a96758beff5e86d446883723211d0a1be59642460d6ef1167fb0ac0df6d6812c"

URI_aarch64_perl-RPM2 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-RPM2-1.4-36.el10_2.aarch64.rpm;name=aarch64_perl-RPM2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-RPM2}"
SRC_URI[aarch64_perl-RPM2.sha256sum] = "3243df600aad5a66f4bfe0b9766fb6463283a4f989c67781ff7c2e6ea46a73f1"

URI_aarch64_perl-RPM2-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-RPM2-tests-1.4-36.el10_2.noarch.rpm;name=aarch64_perl-RPM2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-RPM2-tests}"
SRC_URI[aarch64_perl-RPM2-tests.sha256sum] = "d17c8bb0f3fe9e099c6f82272e64f14f8f592a261f629b40e52d08d3ab6aa41f"

RDEPENDS:perl-RPM2 = " \
 glibc \
 perl-DynaLoader \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 perl-overload \
 rpm-libs \
 "
RDEPENDS:perl-RPM2-tests = " \
 bash \
 perl-File-Temp \
 perl-POSIX \
 perl-RPM2 \
 perl-Test \
 perl-Test-Harness \
 perl-interpreter \
 perl-libs \
 rpm \
 "
