# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-milou"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 plasma-milou \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-milou-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49643cc0edaece8f909cdcae8496c4a84c8ccba4eccb93d1bc016390d3e036b0"

URI_x86_64_v2_plasma-milou = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-milou-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-milou;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-milou}"
SRC_URI[x86_64_v2_plasma-milou.sha256sum] = "117f75a79b1450db03c277aa392dcc4c46bdc885ea7fba13c47aaace65a11bc2"

URI_aarch64_plasma-milou = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-milou-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-milou;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-milou}"
SRC_URI[aarch64_plasma-milou.sha256sum] = "7fd3c9c74b3c3f5866aa1ab6c7075311713ada3fb1a2794dfab567431f4da184"

RDEPENDS:plasma-milou = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-krunner \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
