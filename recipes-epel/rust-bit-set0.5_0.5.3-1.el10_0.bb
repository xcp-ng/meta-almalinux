# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bit-set0.5"
PV = "0.5.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-bit-set0.5+default-devel \
 rust-bit-set0.5+std-devel \
 rust-bit-set0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bit-set0.5-0.5.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14172c146ab6ddf0d8aff19262e3dbb1fbe400ca2227d38989c5b478bb170934"

URI_x86_64_v2_rust-bit-set0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-set0.5+default-devel-0.5.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-set0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-set0.5+default-devel}"
SRC_URI[x86_64_v2_rust-bit-set0.5+default-devel.sha256sum] = "8c1b3fc482f37f532f40df3b8550a29abb73357f2da2fff92c1b2f8b7d4bba93"

URI_x86_64_v2_rust-bit-set0.5+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-set0.5+std-devel-0.5.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-set0.5+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-set0.5+std-devel}"
SRC_URI[x86_64_v2_rust-bit-set0.5+std-devel.sha256sum] = "a494a6208050b638c0b4b63709cdad65a14d08f2dd11f84f103595e1b161d000"

URI_x86_64_v2_rust-bit-set0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-set0.5-devel-0.5.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-set0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-set0.5-devel}"
SRC_URI[x86_64_v2_rust-bit-set0.5-devel.sha256sum] = "d5b23c8fb707e58c59f23aa642c188b62fe424738d3542e3041c8c114b25abf4"

URI_aarch64_rust-bit-set0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-set0.5+default-devel-0.5.3-1.el10_0.noarch.rpm;name=aarch64_rust-bit-set0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-set0.5+default-devel}"
SRC_URI[aarch64_rust-bit-set0.5+default-devel.sha256sum] = "18ea8cf2a7f7d0746e329f5c66d911b800e6e58628a59c7aa8d40a07f074703f"

URI_aarch64_rust-bit-set0.5+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-set0.5+std-devel-0.5.3-1.el10_0.noarch.rpm;name=aarch64_rust-bit-set0.5+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-set0.5+std-devel}"
SRC_URI[aarch64_rust-bit-set0.5+std-devel.sha256sum] = "b010d9a7fcb8813c1701572a6df5c1d557ca549ec6d4cbe674cbaf28e85af6b1"

URI_aarch64_rust-bit-set0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-set0.5-devel-0.5.3-1.el10_0.noarch.rpm;name=aarch64_rust-bit-set0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-set0.5-devel}"
SRC_URI[aarch64_rust-bit-set0.5-devel.sha256sum] = "26791f342df2e3d932f56ea20ab2cf1ab05773a5499917268e8e2f3999e3a842"

RDEPENDS:rust-bit-set0.5+default-devel = " \
 cargo \
 rust-bit-set0.5+std-devel \
 rust-bit-set0.5-devel \
 "
RDEPENDS:rust-bit-set0.5+std-devel = " \
 cargo \
 rust-bit-set0.5-devel \
 rust-bit-vec0.6+std-devel \
 "
RDEPENDS:rust-bit-set0.5-devel = " \
 cargo \
 rust-bit-vec0.6-devel \
 "
