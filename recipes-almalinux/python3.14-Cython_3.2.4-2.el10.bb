# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-Cython"
PV = "3.2.4"
PR = "2.el10"
PACKAGES = " \
 python3.14-Cython \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python3.14-Cython-3.2.4-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fb123541247bfdad8118b0cf3ed717fe114e6e6a789eb5b23f8686b4b99f248"

URI_x86_64_v2_python3.14-Cython = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-Cython-3.2.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-Cython;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-Cython}"
SRC_URI[x86_64_v2_python3.14-Cython.sha256sum] = "2e6e02488840d6cc95aacea0f73d27307ede51e75029bef78de4e80c95c89e38"

URI_aarch64_python3.14-Cython = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-Cython-3.2.4-2.el10.aarch64.rpm;name=aarch64_python3.14-Cython;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-Cython}"
SRC_URI[aarch64_python3.14-Cython.sha256sum] = "631c2f7f8886a5389bb3582eff4da4011044f724d382b371988e05d54e80f6fb"

RDEPENDS:python3.14-Cython = " \
 glibc \
 python3.14 \
 "
