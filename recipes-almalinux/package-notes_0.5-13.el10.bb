# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "package-notes"
PV = "0.5"
PR = "13.el10"
PACKAGES = " \
 package-notes-srpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/package-notes-0.5-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8afd1377c0cf89a5cf02ff14a34e8508ce2fac1b99fb19a4b63474686897622f"

URI_x86_64_v2_package-notes-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/package-notes-srpm-macros-0.5-13.el10.noarch.rpm;name=x86_64_v2_package-notes-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_package-notes-srpm-macros}"
SRC_URI[x86_64_v2_package-notes-srpm-macros.sha256sum] = "a0f267a35fa2d5fb57a4310cffac67849794e005e40b4d2a24e83e71647ce0cf"

URI_aarch64_package-notes-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/package-notes-srpm-macros-0.5-13.el10.noarch.rpm;name=aarch64_package-notes-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_package-notes-srpm-macros}"
SRC_URI[aarch64_package-notes-srpm-macros.sha256sum] = "a0f267a35fa2d5fb57a4310cffac67849794e005e40b4d2a24e83e71647ce0cf"

RDEPENDS:package-notes-srpm-macros = " \
 "
