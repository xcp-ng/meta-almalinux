# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-click"
PV = "0.9.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-mkdocs-click \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-click-0.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e94a379af9d58dbc91f7e3e45bbdc25d586706ef12d7d1bde60eb0151b8c9cd5"

URI_x86_64_v2_python3-mkdocs-click = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-click-0.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-click;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-click}"
SRC_URI[x86_64_v2_python3-mkdocs-click.sha256sum] = "5809bcbce2e951e6adb957dcc598a6fe91c07da8b7507abe26df18f80bdece26"

URI_aarch64_python3-mkdocs-click = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-click-0.9.0-1.el10_2.noarch.rpm;name=aarch64_python3-mkdocs-click;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-click}"
SRC_URI[aarch64_python3-mkdocs-click.sha256sum] = "597e8022760e314070d346b52398dbb29a4c690bac2a3252a56801458d91b3e9"

RDEPENDS:python3-mkdocs-click = " \
 python3 \
 python3-click \
 python3-markdown \
 "
