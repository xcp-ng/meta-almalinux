# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xorg-x11-util-macros"
PV = "1.20.0"
PR = "7.el10"
PACKAGES = " \
 xorg-x11-util-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/xorg-x11-util-macros-1.20.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3c7ccff688eb092957827dc162402a1a5af5f5aebfd2f75771321de37d8a3a1"

URI_x86_64_v2_xorg-x11-util-macros = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xorg-x11-util-macros-1.20.0-7.el10.noarch.rpm;name=x86_64_v2_xorg-x11-util-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-util-macros}"
SRC_URI[x86_64_v2_xorg-x11-util-macros.sha256sum] = "3f9a8cc1f1ed9be605cdeca8ad7c88f75a210cfc8e9f74f10b15e35871028716"

URI_aarch64_xorg-x11-util-macros = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xorg-x11-util-macros-1.20.0-7.el10.noarch.rpm;name=aarch64_xorg-x11-util-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-util-macros}"
SRC_URI[aarch64_xorg-x11-util-macros.sha256sum] = "3f9a8cc1f1ed9be605cdeca8ad7c88f75a210cfc8e9f74f10b15e35871028716"

RDEPENDS:xorg-x11-util-macros = " \
 autoconf \
 automake \
 pkgconf-pkg-config \
 "
