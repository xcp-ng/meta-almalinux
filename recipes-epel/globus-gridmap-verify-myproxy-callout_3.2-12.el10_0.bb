# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gridmap-verify-myproxy-callout"
PV = "3.2"
PR = "12.el10_0"
PACKAGES = " \
 globus-gridmap-verify-myproxy-callout \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gridmap-verify-myproxy-callout-3.2-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a265dbada2a40c9d9abb5e394c8a1b86d1bcc9245e77e7bd9a4981d0b54e16f8"

URI_x86_64_v2_globus-gridmap-verify-myproxy-callout = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridmap-verify-myproxy-callout-3.2-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridmap-verify-myproxy-callout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridmap-verify-myproxy-callout}"
SRC_URI[x86_64_v2_globus-gridmap-verify-myproxy-callout.sha256sum] = "6eedccbd0c33e67817955cb97d1c42dc17f96f91c247c40af38196f1b38505d4"

URI_aarch64_globus-gridmap-verify-myproxy-callout = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridmap-verify-myproxy-callout-3.2-12.el10_0.aarch64.rpm;name=aarch64_globus-gridmap-verify-myproxy-callout;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridmap-verify-myproxy-callout}"
SRC_URI[aarch64_globus-gridmap-verify-myproxy-callout.sha256sum] = "0a1446123db3eeac02c2b0c197fbb348ea9054391a313132863b662e6208efd0"

RDEPENDS:globus-gridmap-verify-myproxy-callout = " \
 glibc \
 globus-common \
 globus-gridmap-callout-error \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gss-assist \
 globus-gssapi-error \
 globus-gssapi-gsi \
 openssl-libs \
 "
