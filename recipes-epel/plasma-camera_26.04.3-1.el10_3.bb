# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-camera"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-camera \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-camera-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "371771e205efff47d991ee2343e04b03d0517386f031d3076cccc720e79a407a"

URI_x86_64_v2_plasma-camera = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-camera-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-camera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-camera}"
SRC_URI[x86_64_v2_plasma-camera.sha256sum] = "ce6b8ac2138b7a710c65d5f39bf59bfaa5778a5f20ff4f45dbe6bb66df00053a"

URI_aarch64_plasma-camera = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-camera-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-camera;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-camera}"
SRC_URI[aarch64_plasma-camera.sha256sum] = "e11c3d2c9b626c5c0f3a6d261d83a531f51f6e9085f4a8d3ed4477032499ad3b"

RDEPENDS:plasma-camera = " \
 exiv2-libs \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libcamera \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtsensors \
 "
