# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust"
PV = "1.88.0"
PR = "1.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 cargo \
 clippy \
 rust \
 rust-analyzer \
 rust-debugger-common \
 rust-doc \
 rust-gdb \
 rust-lldb \
 rust-src \
 rust-std-static \
 rust-std-static-wasm32-unknown-unknown \
 rust-std-static-wasm32-wasip1 \
 rust-std-static-x86_64-unknown-none \
 rust-toolset \
 rust-toolset-srpm-macros \
 rustfmt \
"
PACKAGES:aarch64 = " \
 cargo \
 clippy \
 rust \
 rust-analyzer \
 rust-debugger-common \
 rust-doc \
 rust-gdb \
 rust-lldb \
 rust-src \
 rust-std-static \
 rust-std-static-aarch64-unknown-none-softfloat \
 rust-std-static-wasm32-unknown-unknown \
 rust-std-static-wasm32-wasip1 \
 rust-toolset \
 rust-toolset-srpm-macros \
 rustfmt \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-1.88.0-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47ba7d597690745a3294c9c0d418b9a17ad9d63e9d0a205e975649baf4ac1ffa"

URI_x86_64_v2_cargo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cargo-1.88.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_cargo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo}"
SRC_URI[x86_64_v2_cargo.sha256sum] = "5c9916a52af583709912837ecbc9b552710eea45ab63e5b7b513d25896f89963"

URI_x86_64_v2_clippy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clippy-1.88.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clippy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clippy}"
SRC_URI[x86_64_v2_clippy.sha256sum] = "9a54956aee3ca15f4cb7f8f9e4aee9f86d846693826c6c0509006fefcc36d717"

URI_x86_64_v2_rust = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-1.88.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust}"
SRC_URI[x86_64_v2_rust.sha256sum] = "7497b84688d9fa58bbcd88aa1aa16dcb2199fcba1deab08bb697c7e46060dca4"

URI_x86_64_v2_rust-analyzer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-analyzer-1.88.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-analyzer}"
SRC_URI[x86_64_v2_rust-analyzer.sha256sum] = "419deb7f8acee5f627542143dbde3d2fe1bb1550ad512f26d5fcb4e1452b42ef"

URI_x86_64_v2_rust-debugger-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-debugger-common-1.88.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-debugger-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-debugger-common}"
SRC_URI[x86_64_v2_rust-debugger-common.sha256sum] = "cb54f66697eddad7c8b98a845738a599b74702115e6884f15c92f29e4e28faf0"

URI_x86_64_v2_rust-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-doc-1.88.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc}"
SRC_URI[x86_64_v2_rust-doc.sha256sum] = "448221500a6e7093f5d314e37967f65945b984c655dd9e629f02049a2a20bdfe"

URI_x86_64_v2_rust-gdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-gdb-1.88.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-gdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gdb}"
SRC_URI[x86_64_v2_rust-gdb.sha256sum] = "cc8314d1725a6799c0dc79065176c58667d2fb03659588f41f3037251817957f"

URI_x86_64_v2_rust-lldb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-lldb-1.88.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-lldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lldb}"
SRC_URI[x86_64_v2_rust-lldb.sha256sum] = "4a9dd3a6f0efbee3061d049046070191cc8ab09c795a3e7ef59e93b2f19a5acc"

URI_x86_64_v2_rust-src = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-src-1.88.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-src}"
SRC_URI[x86_64_v2_rust-src.sha256sum] = "7c67aaafbec80047e32ee9ae37db04b50d67734b015116ebcd3aa467909065c7"

URI_x86_64_v2_rust-std-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-1.88.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-std-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static}"
SRC_URI[x86_64_v2_rust-std-static.sha256sum] = "509103f35a64e168e0f569138695c0d1b0d64d6318d2abe1b46a9050d701d231"

URI_x86_64_v2_rust-std-static-wasm32-unknown-unknown = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-unknown-unknown-1.88.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-wasm32-unknown-unknown;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static-wasm32-unknown-unknown}"
SRC_URI[x86_64_v2_rust-std-static-wasm32-unknown-unknown.sha256sum] = "4d791c79de4d71977fb1e7c24a88192053ae9916afc42b20d760bffed5c54159"

URI_x86_64_v2_rust-std-static-wasm32-wasip1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-wasip1-1.88.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-wasm32-wasip1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static-wasm32-wasip1}"
SRC_URI[x86_64_v2_rust-std-static-wasm32-wasip1.sha256sum] = "1f80f3b1be865ed726446ccc576e80ae4a87acfff6678a77803c6337f2fb4621"

URI_x86_64_v2_rust-std-static-x86_64-unknown-none = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rust-std-static-x86_64-unknown-none-1.88.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-std-static-x86_64-unknown-none;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static-x86_64-unknown-none}"
SRC_URI[x86_64_v2_rust-std-static-x86_64-unknown-none.sha256sum] = "5d1854f0653fcb89df8ba37adc801a5b698f450bddebee4582e54670b3eeef61"

URI_x86_64_v2_rust-toolset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-toolset-1.88.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toolset}"
SRC_URI[x86_64_v2_rust-toolset.sha256sum] = "818a802c5d0f4d579a554be144da4c614fe70fa32b74e2f0183873822c9a9822"

URI_x86_64_v2_rust-toolset-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-toolset-srpm-macros-1.88.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-toolset-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toolset-srpm-macros}"
SRC_URI[x86_64_v2_rust-toolset-srpm-macros.sha256sum] = "4ebb52ed7903442b6b251530b734f0079013343b6bc7fca6621cd375f77b6d20"

URI_x86_64_v2_rustfmt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rustfmt-1.88.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rustfmt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rustfmt}"
SRC_URI[x86_64_v2_rustfmt.sha256sum] = "5e4aa8c94df71c4b91c92c1974d27068b7d205b62d288a0e251e8275256e1296"

URI_aarch64_cargo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cargo-1.88.0-1.el10.alma.1.aarch64.rpm;name=aarch64_cargo;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo}"
SRC_URI[aarch64_cargo.sha256sum] = "361ff5faa3351ab180b8775ffc213efb337b8605530eddf354e4a48464b004fb"

URI_aarch64_clippy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clippy-1.88.0-1.el10.alma.1.aarch64.rpm;name=aarch64_clippy;unpack=0"
SRC_URI:append = " ${URI_aarch64_clippy}"
SRC_URI[aarch64_clippy.sha256sum] = "672c7c17a026710da537afcdf7076d83874d75f9505ac6cb37aefc024fa0353a"

URI_aarch64_rust = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-1.88.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust}"
SRC_URI[aarch64_rust.sha256sum] = "90bd529345c104ddb31cf0f2e8b051dd870a84de50bb8031e7b23f9a2605a2d2"

URI_aarch64_rust-analyzer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-analyzer-1.88.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-analyzer}"
SRC_URI[aarch64_rust-analyzer.sha256sum] = "abcc0707b5f32178fc0352e21d5ae2c67628581fbabf11d55e79ff07ded8df61"

URI_aarch64_rust-debugger-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-debugger-common-1.88.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-debugger-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-debugger-common}"
SRC_URI[aarch64_rust-debugger-common.sha256sum] = "cb54f66697eddad7c8b98a845738a599b74702115e6884f15c92f29e4e28faf0"

URI_aarch64_rust-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-doc-1.88.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc}"
SRC_URI[aarch64_rust-doc.sha256sum] = "4dfe47aaa6086bbb2b5337bc7b90a53bc9863fb36f11f3f2f3b6455b487b300c"

URI_aarch64_rust-gdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-gdb-1.88.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-gdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gdb}"
SRC_URI[aarch64_rust-gdb.sha256sum] = "cc8314d1725a6799c0dc79065176c58667d2fb03659588f41f3037251817957f"

URI_aarch64_rust-lldb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-lldb-1.88.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-lldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lldb}"
SRC_URI[aarch64_rust-lldb.sha256sum] = "4a9dd3a6f0efbee3061d049046070191cc8ab09c795a3e7ef59e93b2f19a5acc"

URI_aarch64_rust-src = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-src-1.88.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-src}"
SRC_URI[aarch64_rust-src.sha256sum] = "7c67aaafbec80047e32ee9ae37db04b50d67734b015116ebcd3aa467909065c7"

URI_aarch64_rust-std-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-1.88.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-std-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static}"
SRC_URI[aarch64_rust-std-static.sha256sum] = "00bb3397bb031911d7c653f7d179cbc75c83bf9aff7820a0304fca44d9509ab9"

URI_aarch64_rust-std-static-aarch64-unknown-none-softfloat = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rust-std-static-aarch64-unknown-none-softfloat-1.88.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-std-static-aarch64-unknown-none-softfloat;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static-aarch64-unknown-none-softfloat}"
SRC_URI[aarch64_rust-std-static-aarch64-unknown-none-softfloat.sha256sum] = "68ae35d043b4952503aab2694b5e95593a4e3f00e968da39565200870db51335"

URI_aarch64_rust-std-static-wasm32-unknown-unknown = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-wasm32-unknown-unknown-1.88.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-std-static-wasm32-unknown-unknown;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static-wasm32-unknown-unknown}"
SRC_URI[aarch64_rust-std-static-wasm32-unknown-unknown.sha256sum] = "4d791c79de4d71977fb1e7c24a88192053ae9916afc42b20d760bffed5c54159"

URI_aarch64_rust-std-static-wasm32-wasip1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-wasm32-wasip1-1.88.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-std-static-wasm32-wasip1;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static-wasm32-wasip1}"
SRC_URI[aarch64_rust-std-static-wasm32-wasip1.sha256sum] = "1f80f3b1be865ed726446ccc576e80ae4a87acfff6678a77803c6337f2fb4621"

URI_aarch64_rust-toolset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-toolset-1.88.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toolset}"
SRC_URI[aarch64_rust-toolset.sha256sum] = "818a802c5d0f4d579a554be144da4c614fe70fa32b74e2f0183873822c9a9822"

URI_aarch64_rust-toolset-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-toolset-srpm-macros-1.88.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-toolset-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toolset-srpm-macros}"
SRC_URI[aarch64_rust-toolset-srpm-macros.sha256sum] = "4ebb52ed7903442b6b251530b734f0079013343b6bc7fca6621cd375f77b6d20"

URI_aarch64_rustfmt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rustfmt-1.88.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rustfmt;unpack=0"
SRC_URI:append = " ${URI_aarch64_rustfmt}"
SRC_URI[aarch64_rustfmt.sha256sum] = "4ea60b2c318817127889c494fcbd8306c2bcd709536485d1af5867054a2f0e95"

RDEPENDS:cargo = " \
 glibc \
 libgcc \
 openssl-libs \
 rust \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clippy = " \
 cargo \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust = " \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 rust-std-static \
 "
RDEPENDS:rust-analyzer = " \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust-debugger-common = " \
 "
RDEPENDS:rust-doc = " \
 "
RDEPENDS:rust-gdb = " \
 bash \
 gdb \
 rust-debugger-common \
 "
RDEPENDS:rust-lldb = " \
 bash \
 lldb \
 python3-lldb \
 rust-debugger-common \
 "
RDEPENDS:rust-src = " \
 "
RDEPENDS:rust-std-static = " \
 glibc \
 glibc-devel \
 libgcc \
 rust \
 "
RDEPENDS:rust-std-static-wasm32-unknown-unknown = " \
 lld \
 rust \
 "
RDEPENDS:rust-std-static-wasm32-wasip1 = " \
 lld \
 rust \
 "
RDEPENDS:rust-std-static-x86_64-unknown-none = " \
 lld \
 rust \
 "
RDEPENDS:rust-toolset = " \
 cargo \
 python3 \
 rust \
 rust-toolset-srpm-macros \
 "
RDEPENDS:rust-toolset-srpm-macros = " \
 "
RDEPENDS:rustfmt = " \
 cargo \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust-std-static-aarch64-unknown-none-softfloat = " \
 lld \
 rust \
 "
