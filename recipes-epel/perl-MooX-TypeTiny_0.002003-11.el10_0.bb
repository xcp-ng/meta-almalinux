# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MooX-TypeTiny"
PV = "0.002003"
PR = "11.el10_0"
PACKAGES = " \
 perl-MooX-TypeTiny \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MooX-TypeTiny-0.002003-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28426214112b9ab3b0113c3670d3e00f0c48ef95d7ca83b5a33006b953a4cbad"

URI_x86_64_v2_perl-MooX-TypeTiny = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MooX-TypeTiny-0.002003-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MooX-TypeTiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MooX-TypeTiny}"
SRC_URI[x86_64_v2_perl-MooX-TypeTiny.sha256sum] = "f155fd17218220872b0a7f60f7bcffca398d848df48a26bba5eeb894c32daa9a"

URI_aarch64_perl-MooX-TypeTiny = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MooX-TypeTiny-0.002003-11.el10_0.noarch.rpm;name=aarch64_perl-MooX-TypeTiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MooX-TypeTiny}"
SRC_URI[aarch64_perl-MooX-TypeTiny.sha256sum] = "eee23c609eb9cc68159a46e9c97897feec09bf9944fecf2d70a3141673c5af06"

RDEPENDS:perl-MooX-TypeTiny = " \
 perl-Moo \
 perl-Scalar-List-Utils \
 perl-Sub-Quote \
 perl-Type-Tiny \
 perl-libs \
 "
