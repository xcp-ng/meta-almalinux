# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-vcrpy"
PV = "7.0.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-vcrpy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-vcrpy-7.0.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "572604bab63bf199368f3f91b70d040e8b549b8e812da8b06ba8db4b36b25b57"

URI_x86_64_v2_python3-vcrpy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-vcrpy-7.0.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-vcrpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-vcrpy}"
SRC_URI[x86_64_v2_python3-vcrpy.sha256sum] = "7332b867f66922bc025663e3b16f6e0be7a84629e4327c288e75684a7c69cb67"

URI_aarch64_python3-vcrpy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-vcrpy-7.0.0-2.el10_1.noarch.rpm;name=aarch64_python3-vcrpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-vcrpy}"
SRC_URI[aarch64_python3-vcrpy.sha256sum] = "63a35b1c93b0ef4b260da173fd083fd57a172b449d200a566920462202382b68"

RDEPENDS:python3-vcrpy = " \
 python3 \
 python3-pyyaml \
 python3-urllib3 \
 python3-wrapt \
 python3-yarl \
 "
