# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openssl"
PV = "0.10.73"
PR = "1.el10_0"
PACKAGES = " \
 rust-openssl+bindgen-devel \
 rust-openssl+default-devel \
 rust-openssl+v101-devel \
 rust-openssl+v102-devel \
 rust-openssl+v110-devel \
 rust-openssl+v111-devel \
 rust-openssl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openssl-0.10.73-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c53e0b33c1b734e19c1744caa3846bf2d12548b2b7bc48b303be809218c8103"

URI_x86_64_v2_rust-openssl+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+bindgen-devel-0.10.73-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+bindgen-devel}"
SRC_URI[x86_64_v2_rust-openssl+bindgen-devel.sha256sum] = "f9231b58eb4943fd0cfd3d6d69e67880263980a0f44d9a409642609f1e4c3d76"

URI_x86_64_v2_rust-openssl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+default-devel-0.10.73-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+default-devel}"
SRC_URI[x86_64_v2_rust-openssl+default-devel.sha256sum] = "dfdfb60ceabf3b18b750db14018b7a5e0b16f85d22e4e86ac6eadbefec767e86"

URI_x86_64_v2_rust-openssl+v101-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v101-devel-0.10.73-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v101-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v101-devel}"
SRC_URI[x86_64_v2_rust-openssl+v101-devel.sha256sum] = "16914554f09f10ea21fe24c53b71d2d84c96979cfbe7ec64e170c0fb206ce3c1"

URI_x86_64_v2_rust-openssl+v102-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v102-devel-0.10.73-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v102-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v102-devel}"
SRC_URI[x86_64_v2_rust-openssl+v102-devel.sha256sum] = "910d02eef61ed03996ee277838e1a3fef9d441b832005262d890a0c02e849193"

URI_x86_64_v2_rust-openssl+v110-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v110-devel-0.10.73-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v110-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v110-devel}"
SRC_URI[x86_64_v2_rust-openssl+v110-devel.sha256sum] = "35c0bb5c94df64b36b67abdaaaefcdb1f3b9cfeb780cebbb0b1e2e6f81f5da4f"

URI_x86_64_v2_rust-openssl+v111-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v111-devel-0.10.73-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v111-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v111-devel}"
SRC_URI[x86_64_v2_rust-openssl+v111-devel.sha256sum] = "f89a70167342f8429ce215e22d60ba4182b5176fa2f3c6e5967929229ab94405"

URI_x86_64_v2_rust-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-devel-0.10.73-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-devel}"
SRC_URI[x86_64_v2_rust-openssl-devel.sha256sum] = "055159f942bf622eade21cc81e0e73773b18c0e5407d09987f7de46f466289ae"

URI_aarch64_rust-openssl+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+bindgen-devel-0.10.73-1.el10_0.noarch.rpm;name=aarch64_rust-openssl+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+bindgen-devel}"
SRC_URI[aarch64_rust-openssl+bindgen-devel.sha256sum] = "f10e8eeb34ecf6f7d622de5e12f6fcac7ef4397626dd4a9cf50053fad49e9b2f"

URI_aarch64_rust-openssl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+default-devel-0.10.73-1.el10_0.noarch.rpm;name=aarch64_rust-openssl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+default-devel}"
SRC_URI[aarch64_rust-openssl+default-devel.sha256sum] = "951fede1846912fe0d049e1592d44dbc39044e47d0f78bfe5d05fd09082a23b2"

URI_aarch64_rust-openssl+v101-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v101-devel-0.10.73-1.el10_0.noarch.rpm;name=aarch64_rust-openssl+v101-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v101-devel}"
SRC_URI[aarch64_rust-openssl+v101-devel.sha256sum] = "26595e3e42ff796e2c9929a744223d0349bad4985c042a6db01036cda3fc442d"

URI_aarch64_rust-openssl+v102-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v102-devel-0.10.73-1.el10_0.noarch.rpm;name=aarch64_rust-openssl+v102-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v102-devel}"
SRC_URI[aarch64_rust-openssl+v102-devel.sha256sum] = "9739c32431356e75f3f411829445031e6eeece8d605048c0e82c73d569be1405"

URI_aarch64_rust-openssl+v110-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v110-devel-0.10.73-1.el10_0.noarch.rpm;name=aarch64_rust-openssl+v110-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v110-devel}"
SRC_URI[aarch64_rust-openssl+v110-devel.sha256sum] = "ab5db6d8f6b75a2f94b908c8140c0866e9ed7b85cdc9aee512805a9fef5ca475"

URI_aarch64_rust-openssl+v111-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v111-devel-0.10.73-1.el10_0.noarch.rpm;name=aarch64_rust-openssl+v111-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v111-devel}"
SRC_URI[aarch64_rust-openssl+v111-devel.sha256sum] = "0e4961b4dd09df5e8be9d80c3f0f898e11f8b398150419e44ef7d4a4cc690dff"

URI_aarch64_rust-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-devel-0.10.73-1.el10_0.noarch.rpm;name=aarch64_rust-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-devel}"
SRC_URI[aarch64_rust-openssl-devel.sha256sum] = "c3091b2ce376c96c0e35abfbd5c16d9ad607f1556981cad7b0bba22629fcac25"

RDEPENDS:rust-openssl+bindgen-devel = " \
 cargo \
 rust-openssl-devel \
 rust-openssl-sys+bindgen-devel \
 "
RDEPENDS:rust-openssl+default-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v101-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v102-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v110-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v111-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-foreign-types0.3+default-devel \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 rust-openssl-macros+default-devel \
 rust-openssl-sys+default-devel \
 "
