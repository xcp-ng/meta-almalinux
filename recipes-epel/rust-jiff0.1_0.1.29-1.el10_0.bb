# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jiff0.1"
PV = "0.1.29"
PR = "1.el10_0"
PACKAGES = " \
 rust-jiff0.1+alloc-devel \
 rust-jiff0.1+default-devel \
 rust-jiff0.1+logging-devel \
 rust-jiff0.1+serde-devel \
 rust-jiff0.1+std-devel \
 rust-jiff0.1+tz-system-devel \
 rust-jiff0.1+tzdb-bundle-platform-devel \
 rust-jiff0.1+tzdb-concatenated-devel \
 rust-jiff0.1+tzdb-zoneinfo-devel \
 rust-jiff0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jiff0.1-0.1.29-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de2b1a3d087fca48d60b11e9b4837e79708f964edc068386fde5393fe292bfa3"

URI_x86_64_v2_rust-jiff0.1+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff0.1+alloc-devel-0.1.29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff0.1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff0.1+alloc-devel}"
SRC_URI[x86_64_v2_rust-jiff0.1+alloc-devel.sha256sum] = "7b01cfa3551c55369025528dd2d3d97169907c17715ce053aa6bfc7575644b0c"

URI_x86_64_v2_rust-jiff0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff0.1+default-devel-0.1.29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff0.1+default-devel}"
SRC_URI[x86_64_v2_rust-jiff0.1+default-devel.sha256sum] = "5fd4e9aa4cf315a3aa6be5152b6b781174b3077f2ad8434d32ce0ab06a1f8b40"

URI_x86_64_v2_rust-jiff0.1+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff0.1+logging-devel-0.1.29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff0.1+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff0.1+logging-devel}"
SRC_URI[x86_64_v2_rust-jiff0.1+logging-devel.sha256sum] = "5fc6378c567b18876a0151e74eb190f4436c3b2e8ec0174cfcffb0117317766d"

URI_x86_64_v2_rust-jiff0.1+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff0.1+serde-devel-0.1.29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff0.1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff0.1+serde-devel}"
SRC_URI[x86_64_v2_rust-jiff0.1+serde-devel.sha256sum] = "e90e33fb71ee59122406e3ba63152142557e0034e5c6a5f41177aea09acc2f37"

URI_x86_64_v2_rust-jiff0.1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff0.1+std-devel-0.1.29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff0.1+std-devel}"
SRC_URI[x86_64_v2_rust-jiff0.1+std-devel.sha256sum] = "c4ed768367810a831d59921d8973631bee64ed51102483d3449e9c459fef48a1"

URI_x86_64_v2_rust-jiff0.1+tz-system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff0.1+tz-system-devel-0.1.29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff0.1+tz-system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff0.1+tz-system-devel}"
SRC_URI[x86_64_v2_rust-jiff0.1+tz-system-devel.sha256sum] = "2baee513450d445b9e098cc1d0380321352d7e0b029e0d285416eeb9d5f2a735"

URI_x86_64_v2_rust-jiff0.1+tzdb-bundle-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff0.1+tzdb-bundle-platform-devel-0.1.29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff0.1+tzdb-bundle-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff0.1+tzdb-bundle-platform-devel}"
SRC_URI[x86_64_v2_rust-jiff0.1+tzdb-bundle-platform-devel.sha256sum] = "056f52cb5711a975ddc0f045b62141858a9e86b5e20a36581190b6003c840691"

URI_x86_64_v2_rust-jiff0.1+tzdb-concatenated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff0.1+tzdb-concatenated-devel-0.1.29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff0.1+tzdb-concatenated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff0.1+tzdb-concatenated-devel}"
SRC_URI[x86_64_v2_rust-jiff0.1+tzdb-concatenated-devel.sha256sum] = "b99037c64535f80e55767a59d8f9626dc5456ca666ba4196f33e0bc70d0449c1"

URI_x86_64_v2_rust-jiff0.1+tzdb-zoneinfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff0.1+tzdb-zoneinfo-devel-0.1.29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff0.1+tzdb-zoneinfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff0.1+tzdb-zoneinfo-devel}"
SRC_URI[x86_64_v2_rust-jiff0.1+tzdb-zoneinfo-devel.sha256sum] = "7790a0281f8f890d634e0ef26a354b4896862c61ed1e95d794946f9b20fffe57"

URI_x86_64_v2_rust-jiff0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff0.1-devel-0.1.29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff0.1-devel}"
SRC_URI[x86_64_v2_rust-jiff0.1-devel.sha256sum] = "c59d0eb27333023c74eb5aa04c7ea469ef5828e4b5508e39a65165ba53f5381c"

URI_aarch64_rust-jiff0.1+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff0.1+alloc-devel-0.1.29-1.el10_0.noarch.rpm;name=aarch64_rust-jiff0.1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff0.1+alloc-devel}"
SRC_URI[aarch64_rust-jiff0.1+alloc-devel.sha256sum] = "cec2bbca84bfd339d6690ac3e1153b5caa54267e9fea0e1f19f397d18dde1836"

URI_aarch64_rust-jiff0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff0.1+default-devel-0.1.29-1.el10_0.noarch.rpm;name=aarch64_rust-jiff0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff0.1+default-devel}"
SRC_URI[aarch64_rust-jiff0.1+default-devel.sha256sum] = "174a87b745634c1229fa024616393eeaea59265dea669bd97ab26e838d4b9fdb"

URI_aarch64_rust-jiff0.1+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff0.1+logging-devel-0.1.29-1.el10_0.noarch.rpm;name=aarch64_rust-jiff0.1+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff0.1+logging-devel}"
SRC_URI[aarch64_rust-jiff0.1+logging-devel.sha256sum] = "e4d41bbce2f2e418a047c749d8c6c36c356130ad843afa57a54fc62b44900af0"

URI_aarch64_rust-jiff0.1+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff0.1+serde-devel-0.1.29-1.el10_0.noarch.rpm;name=aarch64_rust-jiff0.1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff0.1+serde-devel}"
SRC_URI[aarch64_rust-jiff0.1+serde-devel.sha256sum] = "b0b9c3e6e1a2a894c78608f670bc9578881aad2d2c79e31c4d3d426302bd6f8f"

URI_aarch64_rust-jiff0.1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff0.1+std-devel-0.1.29-1.el10_0.noarch.rpm;name=aarch64_rust-jiff0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff0.1+std-devel}"
SRC_URI[aarch64_rust-jiff0.1+std-devel.sha256sum] = "cdba62bb7f3cfe289da1705bab6b44f4a07f77a31bff33fb57990763ef399690"

URI_aarch64_rust-jiff0.1+tz-system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff0.1+tz-system-devel-0.1.29-1.el10_0.noarch.rpm;name=aarch64_rust-jiff0.1+tz-system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff0.1+tz-system-devel}"
SRC_URI[aarch64_rust-jiff0.1+tz-system-devel.sha256sum] = "83c403351e120b75fe838c61e3a35c7d7b565158704e4b1806e1c7cb14dc89a1"

URI_aarch64_rust-jiff0.1+tzdb-bundle-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff0.1+tzdb-bundle-platform-devel-0.1.29-1.el10_0.noarch.rpm;name=aarch64_rust-jiff0.1+tzdb-bundle-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff0.1+tzdb-bundle-platform-devel}"
SRC_URI[aarch64_rust-jiff0.1+tzdb-bundle-platform-devel.sha256sum] = "2da3d8ba026b299a869aae3b188c62b83ec83e3905df4efb04d0135a80fe52fa"

URI_aarch64_rust-jiff0.1+tzdb-concatenated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff0.1+tzdb-concatenated-devel-0.1.29-1.el10_0.noarch.rpm;name=aarch64_rust-jiff0.1+tzdb-concatenated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff0.1+tzdb-concatenated-devel}"
SRC_URI[aarch64_rust-jiff0.1+tzdb-concatenated-devel.sha256sum] = "7ff76ce149d0d3f384b6788e554d5b4369772e01a37476a7fa1f02391f97bed6"

URI_aarch64_rust-jiff0.1+tzdb-zoneinfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff0.1+tzdb-zoneinfo-devel-0.1.29-1.el10_0.noarch.rpm;name=aarch64_rust-jiff0.1+tzdb-zoneinfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff0.1+tzdb-zoneinfo-devel}"
SRC_URI[aarch64_rust-jiff0.1+tzdb-zoneinfo-devel.sha256sum] = "5811c334759128885f8f5999da4fcae66cbe8d8a34f0bb542c15e60d698625d5"

URI_aarch64_rust-jiff0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff0.1-devel-0.1.29-1.el10_0.noarch.rpm;name=aarch64_rust-jiff0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff0.1-devel}"
SRC_URI[aarch64_rust-jiff0.1-devel.sha256sum] = "9a1715ee1675625cff07464ab6d1c570f038fe7c423c477c58d48a8d4d376ca6"

RDEPENDS:rust-jiff0.1+alloc-devel = " \
 cargo \
 rust-jiff0.1-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-jiff0.1+default-devel = " \
 cargo \
 rust-jiff0.1+std-devel \
 rust-jiff0.1+tz-system-devel \
 rust-jiff0.1+tzdb-bundle-platform-devel \
 rust-jiff0.1+tzdb-concatenated-devel \
 rust-jiff0.1+tzdb-zoneinfo-devel \
 rust-jiff0.1-devel \
 "
RDEPENDS:rust-jiff0.1+logging-devel = " \
 cargo \
 rust-jiff0.1-devel \
 rust-log-devel \
 "
RDEPENDS:rust-jiff0.1+serde-devel = " \
 cargo \
 rust-jiff0.1-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-jiff0.1+std-devel = " \
 cargo \
 rust-jiff0.1+alloc-devel \
 rust-jiff0.1-devel \
 rust-log+std-devel \
 rust-log-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-jiff0.1+tz-system-devel = " \
 cargo \
 rust-jiff0.1+std-devel \
 rust-jiff0.1-devel \
 "
RDEPENDS:rust-jiff0.1+tzdb-bundle-platform-devel = " \
 cargo \
 rust-jiff0.1+alloc-devel \
 rust-jiff0.1-devel \
 "
RDEPENDS:rust-jiff0.1+tzdb-concatenated-devel = " \
 cargo \
 rust-jiff0.1+std-devel \
 rust-jiff0.1-devel \
 "
RDEPENDS:rust-jiff0.1+tzdb-zoneinfo-devel = " \
 cargo \
 rust-jiff0.1+std-devel \
 rust-jiff0.1-devel \
 "
RDEPENDS:rust-jiff0.1-devel = " \
 cargo \
 rust \
 "
