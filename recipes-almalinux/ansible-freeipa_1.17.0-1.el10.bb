# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-freeipa"
PV = "1.17.0"
PR = "1.el10"
PACKAGES = " \
 ansible-freeipa \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-freeipa-1.17.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fd1e59ec99ab1b22336f49386e59d21ee747b5b1d5d2f91bd0c521a5c9b8f082"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-freeipa-1.17.0-1.el10.noarch.rpm;name=x86_64_v2_ansible-freeipa;unpack=0"
SRC_URI[x86_64_v2_ansible-freeipa.sha256sum] = "05c00605d740d44c1d99af100287db48c9f7b766f872c47bde137ba64b10fc5d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-freeipa-1.17.0-1.el10.noarch.rpm;name=aarch64_ansible-freeipa;unpack=0"
SRC_URI[aarch64_ansible-freeipa.sha256sum] = "05c00605d740d44c1d99af100287db48c9f7b766f872c47bde137ba64b10fc5d"

RDEPENDS:ansible-freeipa = " \
 ansible-core \
 bash \
 python3 \
 "
