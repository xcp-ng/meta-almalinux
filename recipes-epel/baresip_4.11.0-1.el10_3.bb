# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "baresip"
PV = "4.11.0"
PR = "1.el10_3"
PACKAGES = " \
 baresip \
 baresip-aac \
 baresip-alsa \
 baresip-av1 \
 baresip-avcodec \
 baresip-avfilter \
 baresip-avformat \
 baresip-codec2 \
 baresip-ctrl_dbus \
 baresip-devel \
 baresip-g722 \
 baresip-gst \
 baresip-gtk \
 baresip-jack \
 baresip-mqtt \
 baresip-opus \
 baresip-pipewire \
 baresip-plc \
 baresip-portaudio \
 baresip-pulse \
 baresip-sdl \
 baresip-snapshot \
 baresip-sndfile \
 baresip-swscale \
 baresip-tools \
 baresip-v4l2 \
 baresip-vp8 \
 baresip-vp9 \
 baresip-x11 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/baresip-4.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5b5d07bf22cdcbdcb81a5548202185527bdbf8993b68753e895acd4b34be8032"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip;unpack=0"
SRC_URI[x86_64_v2_baresip.sha256sum] = "d9eedd818692fa52bb785576c8cc87f199e403878108b752296d2970b1281976"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-aac-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-aac;unpack=0"
SRC_URI[x86_64_v2_baresip-aac.sha256sum] = "1612b29797bc5963621578d4d81c04a8c27b812fcbf3e36fd6cc89a19108d095"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-alsa-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-alsa;unpack=0"
SRC_URI[x86_64_v2_baresip-alsa.sha256sum] = "f62c32dbb7f26dc9513ef58d5e9f6a9f33b3c48cac08430af73ea15e7f1863bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-av1-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-av1;unpack=0"
SRC_URI[x86_64_v2_baresip-av1.sha256sum] = "6f64554a419a984a9cd914585d106eba37480a5887aef89724677004fbadc940"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avcodec-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avcodec;unpack=0"
SRC_URI[x86_64_v2_baresip-avcodec.sha256sum] = "1c1652b2c245e21f761cc6485b73694dcdbf7f332c66ce1d059557740767543a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avfilter-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avfilter;unpack=0"
SRC_URI[x86_64_v2_baresip-avfilter.sha256sum] = "096ac095e654f0924270154ffd72e7798a08ab653e7ce9a579481c906d14613e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avformat-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avformat;unpack=0"
SRC_URI[x86_64_v2_baresip-avformat.sha256sum] = "47493be7a6f0a5fd8227c4cc93f52896ee6c40e0f3f7829a038ee8574f123f4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-codec2-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-codec2;unpack=0"
SRC_URI[x86_64_v2_baresip-codec2.sha256sum] = "d203e3c15fa1261a96396c7de7854c97f1ed84c69d7d1fd8046587fe7f858a82"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-ctrl_dbus-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-ctrl_dbus;unpack=0"
SRC_URI[x86_64_v2_baresip-ctrl_dbus.sha256sum] = "d57ffca574db566038142d6ad480f884b65c71f4c3f0882c34489670ee28a9d9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-devel-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-devel;unpack=0"
SRC_URI[x86_64_v2_baresip-devel.sha256sum] = "047a77d577d2deed9fd7309a5aa54dc2eb3bfbbf0772434af31ae29917afb303"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-g722-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-g722;unpack=0"
SRC_URI[x86_64_v2_baresip-g722.sha256sum] = "fa1c84fe57e3251c5a9651dfff26db1f57c4076fbbab10fce80c65b2ed1d375b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-gst-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-gst;unpack=0"
SRC_URI[x86_64_v2_baresip-gst.sha256sum] = "879087f0d9820bc224fa97d2509f3df4f5887e32081eb5e5b5daadbfd268c7ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-gtk-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-gtk;unpack=0"
SRC_URI[x86_64_v2_baresip-gtk.sha256sum] = "16788dae9451fbc211a8920d2129309deaf50f39bb935b96fdbee117a8180f50"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-jack-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-jack;unpack=0"
SRC_URI[x86_64_v2_baresip-jack.sha256sum] = "83a7c255025bda0d72bbce0b04285c84fdfab2064b17f9584a0d735adec5e25d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-mqtt-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-mqtt;unpack=0"
SRC_URI[x86_64_v2_baresip-mqtt.sha256sum] = "bef1ff74902b446550c037fdb13c070e511fdc8479c6b2dcb4c070d975b57c34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-opus-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-opus;unpack=0"
SRC_URI[x86_64_v2_baresip-opus.sha256sum] = "82732aeeaccc74415c01a76a9a5773c70ebdedef2bc77699fb02f7b3fc3cf9ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-pipewire-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-pipewire;unpack=0"
SRC_URI[x86_64_v2_baresip-pipewire.sha256sum] = "fcdb9d4ab5a84ecafb1b07984fe293e8a424ef78af5d07b5aa21315faeb6ef0a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-plc-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-plc;unpack=0"
SRC_URI[x86_64_v2_baresip-plc.sha256sum] = "249cce8cb0389cc1ed9b87726ec3f65874a6c46421e8d8405b029a5d9eba9488"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-portaudio-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-portaudio;unpack=0"
SRC_URI[x86_64_v2_baresip-portaudio.sha256sum] = "1fcd9493a722434c077333b6a775104c90036afde2c37638e0c93ef794896117"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-pulse-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-pulse;unpack=0"
SRC_URI[x86_64_v2_baresip-pulse.sha256sum] = "72068937b286649a5ef9c5bfc4907cf8d34850182975a456281b7e8f139d3d97"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-sdl-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-sdl;unpack=0"
SRC_URI[x86_64_v2_baresip-sdl.sha256sum] = "3c260ecb65e930bdeb4ae91bc753e4f328c975a7823e461ab0b99af30cf4266d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-snapshot-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-snapshot;unpack=0"
SRC_URI[x86_64_v2_baresip-snapshot.sha256sum] = "a6bfe8fcf548769ffe79afa4b44d351362dddc452a9d16532e51dd93d156c3ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-sndfile-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-sndfile;unpack=0"
SRC_URI[x86_64_v2_baresip-sndfile.sha256sum] = "ef42a421cb042cb0757ce3a04d4b764a37f6fc34641369097fbf237eca1c1ebe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-swscale-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-swscale;unpack=0"
SRC_URI[x86_64_v2_baresip-swscale.sha256sum] = "d201083878f227cdee3f30f96613de9dfc9b58c1e8cb0228c5c639b0a9d115c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-tools-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-tools;unpack=0"
SRC_URI[x86_64_v2_baresip-tools.sha256sum] = "8a615cf1677a7c83a022d7382f5504478db2584e7727eedab73ac00795aa2711"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-v4l2-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-v4l2;unpack=0"
SRC_URI[x86_64_v2_baresip-v4l2.sha256sum] = "7df0c2ff8bd62900cdb65dbcf4b6ceb4bafb5e37bfbfe1d73902d554c31f6fa5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-vp8-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-vp8;unpack=0"
SRC_URI[x86_64_v2_baresip-vp8.sha256sum] = "82c71891765ef74879d7a169175fdc22cf2dd094cdf8ab52124147a8834c86f9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-vp9-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-vp9;unpack=0"
SRC_URI[x86_64_v2_baresip-vp9.sha256sum] = "82428f41acb7156af00249d1200e6f9088843ac16b7253d0768a8838209d02ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-x11-4.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-x11;unpack=0"
SRC_URI[x86_64_v2_baresip-x11.sha256sum] = "e273c5fa4fecbb6118e41801ffcfe27c45d583ad2d6e466fa67507cbdfdd9ebf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip;unpack=0"
SRC_URI[aarch64_baresip.sha256sum] = "ac32c96e3de41d673121b973173ac898814d5438aabfe4feea9e22e2a056c511"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-aac-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-aac;unpack=0"
SRC_URI[aarch64_baresip-aac.sha256sum] = "599a8658d58d5c3a42579e3ebfdcd08eedd73c1d2dce6808c9721ff22f6341a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-alsa-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-alsa;unpack=0"
SRC_URI[aarch64_baresip-alsa.sha256sum] = "49ca22160eeb8cbfa8e2780a85d89b550d6b3cc0b71ee120e22ff7d7bdf8ac84"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-av1-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-av1;unpack=0"
SRC_URI[aarch64_baresip-av1.sha256sum] = "ad87dfc678bfda000a2dff5560ca22787b1e10cd2f0f353beefc63e44e591927"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-avcodec-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-avcodec;unpack=0"
SRC_URI[aarch64_baresip-avcodec.sha256sum] = "ac949a25f273a8d506571e7a43c71c02debfeac7b6bc136b302c7364c7807247"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-avfilter-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-avfilter;unpack=0"
SRC_URI[aarch64_baresip-avfilter.sha256sum] = "88532d239d133d0255232bb746583f3953318b987ffecedfa14c68deb78bbb2e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-avformat-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-avformat;unpack=0"
SRC_URI[aarch64_baresip-avformat.sha256sum] = "07b534c2c02b7d45a438131954eb0031faa92bbb51c5e91b062bd377d0598d8c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-codec2-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-codec2;unpack=0"
SRC_URI[aarch64_baresip-codec2.sha256sum] = "10c005035b6c60e5a52ff0e7194b83bc64cd4cddd6b9c558a3a29a1bffbeafa6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-ctrl_dbus-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-ctrl_dbus;unpack=0"
SRC_URI[aarch64_baresip-ctrl_dbus.sha256sum] = "43ef06d88ce7eeac3c3bd8d3d1a87743f457f8dfc940fc028f6854b3c48a3978"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-devel-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-devel;unpack=0"
SRC_URI[aarch64_baresip-devel.sha256sum] = "8d8232e2a2a2ae58972352e105d77e585eaa7b0dee3525460a96d4a86a60b708"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-g722-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-g722;unpack=0"
SRC_URI[aarch64_baresip-g722.sha256sum] = "8c85457bbd36472eb5de2418e638c0f8f3451e8be08eb15c13bf648673f3b943"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-gst-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-gst;unpack=0"
SRC_URI[aarch64_baresip-gst.sha256sum] = "86f35a34f99dcbb911063f2ce5b83bec32d44b6044c74cdb841b5e81e47ad74d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-gtk-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-gtk;unpack=0"
SRC_URI[aarch64_baresip-gtk.sha256sum] = "c100eab8cc161e680dc29f18cdbdb95db23d5ad312e7330a2c91d5d5a9e28117"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-jack-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-jack;unpack=0"
SRC_URI[aarch64_baresip-jack.sha256sum] = "b3284741c09e1817b944000b4ce88f8eee5acd0b68607253268a290f48a221ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-mqtt-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-mqtt;unpack=0"
SRC_URI[aarch64_baresip-mqtt.sha256sum] = "c919c5d0e815c94fd814de65416fefcb95625558ce5596a939fa9746ad7845ce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-opus-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-opus;unpack=0"
SRC_URI[aarch64_baresip-opus.sha256sum] = "88c4847d3506c295c2460316ff343f1b42e1da0655832d9d1e3bfc5074f22d29"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-pipewire-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-pipewire;unpack=0"
SRC_URI[aarch64_baresip-pipewire.sha256sum] = "807dccaf262eb4fddee8086a3a60f7d9acf35127fbda2d50ade76886776f675c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-plc-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-plc;unpack=0"
SRC_URI[aarch64_baresip-plc.sha256sum] = "a31f97746a539295a4d89b66ee40827032ecda051666bbb262a4be73e6307b59"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-portaudio-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-portaudio;unpack=0"
SRC_URI[aarch64_baresip-portaudio.sha256sum] = "41bb6a771f419e5e846b7a549151326b0b6468b73a7bb98f1cb2802a633ac233"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-pulse-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-pulse;unpack=0"
SRC_URI[aarch64_baresip-pulse.sha256sum] = "9e2bc6a24600406a010979a6cf2c3e0433427158f25d7e392ef614b43998ab4c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-sdl-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-sdl;unpack=0"
SRC_URI[aarch64_baresip-sdl.sha256sum] = "e49325d64af26e45a105d275ac9563bede82ef6825a271077e88974b0c6a101c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-snapshot-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-snapshot;unpack=0"
SRC_URI[aarch64_baresip-snapshot.sha256sum] = "82618a8cfb183a0eb5166d3ca77ba9cce7fb8878144ed3b358b240a66385b615"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-sndfile-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-sndfile;unpack=0"
SRC_URI[aarch64_baresip-sndfile.sha256sum] = "37dd4c0f27212cd698b2de46b808292ed5637a291135202da893bf81c7774a58"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-swscale-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-swscale;unpack=0"
SRC_URI[aarch64_baresip-swscale.sha256sum] = "1174fc1a0389e3a752105f6592ec08c138578bf0ba19ea3cc617cbd44ccf97f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-tools-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-tools;unpack=0"
SRC_URI[aarch64_baresip-tools.sha256sum] = "f2ed0939c6be6dc08c141e330d37b74eaed0051284b6e34f3dac260881cc0ba2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-v4l2-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-v4l2;unpack=0"
SRC_URI[aarch64_baresip-v4l2.sha256sum] = "db332a4c30d6562710705bfe5b42e51bf6e2f511ab3edb82fb9ba6df08461cd5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-vp8-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-vp8;unpack=0"
SRC_URI[aarch64_baresip-vp8.sha256sum] = "69170020794a45416b44aaa13dca3a6743e2b5b60912d6846905dce7c97319b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-vp9-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-vp9;unpack=0"
SRC_URI[aarch64_baresip-vp9.sha256sum] = "c0fd7e6dfd4f1ffc914fcf5b974a99858ecbbc832225a7c399f53157d7efa382"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-x11-4.11.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-x11;unpack=0"
SRC_URI[aarch64_baresip-x11.sha256sum] = "242e36b1da96cd4eaea19a0737fad43e3e078d591de1a748b6a173482ed187c7"

RDEPENDS:baresip = " \
 glibc \
 libre \
 "
RDEPENDS:baresip-aac = " \
 baresip \
 fdk-aac-free \
 glibc \
 "
RDEPENDS:baresip-alsa = " \
 alsa-lib \
 baresip \
 glibc \
 "
RDEPENDS:baresip-av1 = " \
 baresip \
 glibc \
 libaom \
 "
RDEPENDS:baresip-avcodec = " \
 baresip \
 glibc \
 libavcodec-free \
 libavutil-free \
 "
RDEPENDS:baresip-avfilter = " \
 baresip \
 glibc \
 libavfilter-free \
 libavutil-free \
 "
RDEPENDS:baresip-avformat = " \
 baresip \
 glibc \
 libavcodec-free \
 libavdevice-free \
 libavformat-free \
 libavutil-free \
 libswresample-free \
 "
RDEPENDS:baresip-codec2 = " \
 baresip \
 codec2 \
 glibc \
 "
RDEPENDS:baresip-ctrl_dbus = " \
 baresip \
 glib2 \
 glibc \
 "
RDEPENDS:baresip-devel = " \
 baresip \
 pkgconf-pkg-config \
 "
RDEPENDS:baresip-g722 = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-gst = " \
 baresip \
 glib2 \
 glibc \
 gstreamer1 \
 "
RDEPENDS:baresip-gtk = " \
 adwaita-icon-theme \
 baresip \
 glib2 \
 glibc \
 gnome-shell-extension-appindicator \
 gtk3 \
 "
RDEPENDS:baresip-jack = " \
 baresip \
 glibc \
 pipewire-jack-audio-connection-kit-libs \
 "
RDEPENDS:baresip-mqtt = " \
 baresip \
 glibc \
 mosquitto \
 "
RDEPENDS:baresip-opus = " \
 baresip \
 glibc \
 opus \
 "
RDEPENDS:baresip-pipewire = " \
 baresip \
 glibc \
 pipewire-libs \
 "
RDEPENDS:baresip-plc = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-portaudio = " \
 baresip \
 glibc \
 portaudio \
 "
RDEPENDS:baresip-pulse = " \
 baresip \
 glibc \
 pulseaudio-libs \
 "
RDEPENDS:baresip-sdl = " \
 baresip \
 glibc \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:baresip-snapshot = " \
 baresip \
 glibc \
 libpng \
 "
RDEPENDS:baresip-sndfile = " \
 baresip \
 glibc \
 libsndfile \
 "
RDEPENDS:baresip-swscale = " \
 baresip \
 glibc \
 libswscale-free \
 "
RDEPENDS:baresip-tools = " \
 baresip \
 python3 \
 "
RDEPENDS:baresip-v4l2 = " \
 baresip \
 glibc \
 "
RDEPENDS:baresip-vp8 = " \
 baresip \
 glibc \
 libvpx \
 "
RDEPENDS:baresip-vp9 = " \
 baresip \
 glibc \
 libvpx \
 "
RDEPENDS:baresip-x11 = " \
 baresip \
 glibc \
 libX11 \
 libXext \
 "
