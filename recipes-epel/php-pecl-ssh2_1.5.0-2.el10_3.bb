# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-ssh2"
PV = "1.5.0"
PR = "2.el10_3"
PACKAGES = " \
 php-pecl-ssh2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-ssh2-1.5.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8adc92d18661e0cd70c9812cb06fbc6a91dcd1b8bf6fef9437bac9c16e18540d"

URI_x86_64_v2_php-pecl-ssh2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-ssh2-1.5.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-ssh2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-ssh2}"
SRC_URI[x86_64_v2_php-pecl-ssh2.sha256sum] = "6c66b094875d38235e3ebd5dd199f314cc16455b998425045da5f954fa8eea11"

URI_aarch64_php-pecl-ssh2 = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-ssh2-1.5.0-2.el10_3.aarch64.rpm;name=aarch64_php-pecl-ssh2;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-ssh2}"
SRC_URI[aarch64_php-pecl-ssh2.sha256sum] = "70d969457c8ab7b5f73613132c81242581cab449fbc805aa5a29c50ccdffab7d"

RDEPENDS:php-pecl-ssh2 = " \
 glibc \
 libssh2 \
 php-common \
 "
