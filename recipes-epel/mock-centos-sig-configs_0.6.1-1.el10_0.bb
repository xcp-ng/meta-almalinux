# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mock-centos-sig-configs"
PV = "0.6.1"
PR = "1.el10_0"
PACKAGES = " \
 mock-centos-sig-configs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mock-centos-sig-configs-0.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee126c9b61cb62266212dc32beccfcb7e06bac427bc1b7681da00f555d05a0ef"

URI_x86_64_v2_mock-centos-sig-configs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-centos-sig-configs-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mock-centos-sig-configs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-centos-sig-configs}"
SRC_URI[x86_64_v2_mock-centos-sig-configs.sha256sum] = "0257eba8c22738161bd156932f0bdf0b0df802614c5a7df5d313d0bfd7efb6da"

URI_aarch64_mock-centos-sig-configs = "${EPEL_MIRROR}/aarch64/Packages/m/mock-centos-sig-configs-0.6.1-1.el10_0.noarch.rpm;name=aarch64_mock-centos-sig-configs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-centos-sig-configs}"
SRC_URI[aarch64_mock-centos-sig-configs.sha256sum] = "580e79e43265487cccb7600984beb2c49080c2f221a86068331dad69fd39bc34"

RDEPENDS:mock-centos-sig-configs = " \
 mock-core-configs \
 "
