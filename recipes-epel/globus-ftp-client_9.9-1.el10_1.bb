# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-ftp-client"
PV = "9.9"
PR = "1.el10_1"
PACKAGES = " \
 globus-ftp-client \
 globus-ftp-client-devel \
 globus-ftp-client-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-ftp-client-9.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a1ef177d8aa54495032130a5e9bb4e91f8f9765bb3f4afaca332f1bd4474ddd"

URI_x86_64_v2_globus-ftp-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-ftp-client-9.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-ftp-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-ftp-client}"
SRC_URI[x86_64_v2_globus-ftp-client.sha256sum] = "a2178848849a26ca047b5e50b4e0b7f4b86ce1241390f3c10acb3bb9f199fb17"

URI_x86_64_v2_globus-ftp-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-ftp-client-devel-9.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-ftp-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-ftp-client-devel}"
SRC_URI[x86_64_v2_globus-ftp-client-devel.sha256sum] = "54eebb62c4ae08b8c54395220c5b81b7a39d3a195e0cf700ab26089a376ce624"

URI_x86_64_v2_globus-ftp-client-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-ftp-client-doc-9.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_globus-ftp-client-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-ftp-client-doc}"
SRC_URI[x86_64_v2_globus-ftp-client-doc.sha256sum] = "ddcb21968f5f081dabe71660831b5dc6043e61f40cafa59f5ee07cf57ed858bc"

URI_aarch64_globus-ftp-client = "${EPEL_MIRROR}/aarch64/Packages/g/globus-ftp-client-9.9-1.el10_1.aarch64.rpm;name=aarch64_globus-ftp-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-ftp-client}"
SRC_URI[aarch64_globus-ftp-client.sha256sum] = "b201bc15bf8dfc482909727f6f1b7085478a5101d1586eba29463313d07f8e4d"

URI_aarch64_globus-ftp-client-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-ftp-client-devel-9.9-1.el10_1.aarch64.rpm;name=aarch64_globus-ftp-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-ftp-client-devel}"
SRC_URI[aarch64_globus-ftp-client-devel.sha256sum] = "2a3ac965fcef4e53c4eb118b3f1b9bfb5ddb9d3cd68fe097ab9e8f32592daa4d"

URI_aarch64_globus-ftp-client-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-ftp-client-doc-9.9-1.el10_1.noarch.rpm;name=aarch64_globus-ftp-client-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-ftp-client-doc}"
SRC_URI[aarch64_globus-ftp-client-doc.sha256sum] = "16252dcf0f45215710fe8fddcad60fd73f31f015ca0baf8abf20bcad6232378f"

RDEPENDS:globus-ftp-client = " \
 bash \
 glibc \
 globus-common \
 globus-ftp-control \
 globus-gsi-callback \
 globus-gsi-credential \
 globus-gsi-sysconfig \
 globus-gssapi-gsi \
 globus-xio \
 globus-xio-popen-driver \
 openssl-libs \
 "
RDEPENDS:globus-ftp-client-devel = " \
 globus-common-devel \
 globus-ftp-client \
 globus-ftp-control-devel \
 globus-gsi-callback-devel \
 globus-gsi-credential-devel \
 globus-gsi-sysconfig-devel \
 globus-gssapi-gsi-devel \
 globus-xio-devel \
 globus-xio-popen-driver-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-ftp-client-doc = " \
 "
