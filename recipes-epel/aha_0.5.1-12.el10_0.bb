# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aha"
PV = "0.5.1"
PR = "12.el10_0"
PACKAGES = " \
 aha \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aha-0.5.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcbe59896707343651d6abf6bc05b0285933ccb9c1dda667b476b8885a1695ab"

URI_x86_64_v2_aha = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aha-0.5.1-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aha;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aha}"
SRC_URI[x86_64_v2_aha.sha256sum] = "3a06313b07cf2d1d62ab787f52ce9530836d9c2b7c841c4af663ca2216387b8f"

URI_aarch64_aha = "${EPEL_MIRROR}/aarch64/Packages/a/aha-0.5.1-12.el10_0.aarch64.rpm;name=aarch64_aha;unpack=0"
SRC_URI:append = " ${URI_aarch64_aha}"
SRC_URI[aarch64_aha.sha256sum] = "dd5a9f81ac5ea91d7d2fee0becf8129e99b9211c696c6762d953ffb167276369"

RDEPENDS:aha = " \
 glibc \
 "
