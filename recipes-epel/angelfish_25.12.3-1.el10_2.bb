# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "angelfish"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 angelfish \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/angelfish-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8305b59f476be0c76b3ce3f684d5725d8543e595f80f690660ab6e5bc02e04c"

URI_x86_64_v2_angelfish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/angelfish-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_angelfish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_angelfish}"
SRC_URI[x86_64_v2_angelfish.sha256sum] = "7da3fec723c10854e60d96386b382f76ae2ab595ea7fa34b2a1adf4a778d5ef9"

URI_aarch64_angelfish = "${EPEL_MIRROR}/aarch64/Packages/a/angelfish-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_angelfish;unpack=0"
SRC_URI:append = " ${URI_aarch64_angelfish}"
SRC_URI[aarch64_angelfish.sha256sum] = "cd1873a23477ccba86a51014a52010b73c265f9f3d2e686b8b750590eda05143"

RDEPENDS:angelfish = " \
 futuresql-qt6 \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kwindowsystem \
 kf6-purpose \
 kf6-qqc2-desktop-style \
 libgcc \
 libstdc++ \
 qcoro-qt6 \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 qt6-qtwebengine \
 "
