# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netavark"
PE = "2"
PV = "1.16.0"
PR = "1.el10"
PACKAGES = " \
 netavark \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/netavark-1.16.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62a28514eff0f1d9a3bd2ceddcaf27139f91527794ea58f40e7f0d9f4cdc46a6"

URI_x86_64_v2_netavark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/netavark-1.16.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_netavark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netavark}"
SRC_URI[x86_64_v2_netavark.sha256sum] = "d50b0c2e836407d154d4161d0f668da2bce5fd9f133a449c0ab6bd96dc0994fb"

URI_aarch64_netavark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/netavark-1.16.0-1.el10.aarch64.rpm;name=aarch64_netavark;unpack=0"
SRC_URI:append = " ${URI_aarch64_netavark}"
SRC_URI[aarch64_netavark.sha256sum] = "93cbe170d3c83bc2fe885e4d2ad471b0f66eee3d6c2fde5c7b4ba20db3e7ae54"

RDEPENDS:netavark = " \
 aardvark-dns \
 bash \
 glibc \
 libgcc \
 nftables \
 "
