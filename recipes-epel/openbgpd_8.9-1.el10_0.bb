# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openbgpd"
PV = "8.9"
PR = "1.el10_0"
PACKAGES = " \
 openbgpd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openbgpd-8.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04863b0ac87785605370c846a9ab874376ab31c50722b540fac763b093ae1977"

URI_x86_64_v2_openbgpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbgpd-8.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbgpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openbgpd}"
SRC_URI[x86_64_v2_openbgpd.sha256sum] = "a765bedb38bf575a669818a032d0ff97ed55722e892636cd4f4d729f7fe1feac"

URI_aarch64_openbgpd = "${EPEL_MIRROR}/aarch64/Packages/o/openbgpd-8.9-1.el10_0.aarch64.rpm;name=aarch64_openbgpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_openbgpd}"
SRC_URI[aarch64_openbgpd.sha256sum] = "fae2eaec191814c4646acceba978970fa87cd15828c7c7d79f5af74e112a7cb7"

RDEPENDS:openbgpd = " \
 bash \
 glibc \
 libmnl \
 shadow-utils \
 systemd \
 "
