# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librdkafka"
PV = "2.1.1"
PR = "7.el10"
PACKAGES = " \
 librdkafka \
 librdkafka-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/librdkafka-2.1.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "676b009c695146634b2e9610ddf920631b9a96d66aba3780bbdb979e6094f569"

URI_x86_64_v2_librdkafka = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/librdkafka-2.1.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_librdkafka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librdkafka}"
SRC_URI[x86_64_v2_librdkafka.sha256sum] = "1961c965630a04687b7eb561c6aee605438b37e0b593dfce50a36237fc05c132"

URI_x86_64_v2_librdkafka-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/librdkafka-devel-2.1.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_librdkafka-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librdkafka-devel}"
SRC_URI[x86_64_v2_librdkafka-devel.sha256sum] = "c6360f4b0a6f53b0269dc85f310490fe46f4606b00aeaccc03ae3319eb3fa516"

URI_aarch64_librdkafka = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/librdkafka-2.1.1-7.el10.aarch64.rpm;name=aarch64_librdkafka;unpack=0"
SRC_URI:append = " ${URI_aarch64_librdkafka}"
SRC_URI[aarch64_librdkafka.sha256sum] = "237eab4cf040b38363d3e64d23aa5a8ae578fbbeb9e6ecde196861357ce39d20"

URI_aarch64_librdkafka-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/librdkafka-devel-2.1.1-7.el10.aarch64.rpm;name=aarch64_librdkafka-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librdkafka-devel}"
SRC_URI[aarch64_librdkafka-devel.sha256sum] = "1db75bddb77eb3f6f56ce77cff91e19e375e1933b7d145e44022699bf0cd7359"

RDEPENDS:librdkafka = " \
 cyrus-sasl-lib \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:librdkafka-devel = " \
 cyrus-sasl-devel \
 librdkafka \
 librdkafka-devel \
 libzstd-devel \
 lz4-devel \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
