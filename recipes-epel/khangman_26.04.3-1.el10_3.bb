# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khangman"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 khangman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/khangman-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3275eea134d6513c2a7af25358bd80aa2993248a2900e6481dcd27758a4dbe76"

URI_x86_64_v2_khangman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khangman-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khangman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khangman}"
SRC_URI[x86_64_v2_khangman.sha256sum] = "c4ddbf7d5ddf1f5e0383ee7c1b107a296c0811968aa810a86a533210645230d7"

URI_aarch64_khangman = "${EPEL_MIRROR}/aarch64/Packages/k/khangman-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_khangman;unpack=0"
SRC_URI:append = " ${URI_aarch64_khangman}"
SRC_URI[aarch64_khangman.sha256sum] = "88f8b2c55595d440245d824bbd0b59500e740501c83b8ea08b1d8dac1db61cbd"

RDEPENDS:khangman = " \
 dustin-domestic-manners-fonts \
 dustin-dustismo-roman-fonts \
 glibc \
 kdeedu-data \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 libkeduvocdocument \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
