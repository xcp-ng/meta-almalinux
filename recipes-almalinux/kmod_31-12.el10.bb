# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmod"
PV = "31"
PR = "12.el10"
PACKAGES = " \
 kmod \
 kmod-devel \
 kmod-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kmod-31-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b4bb3ef770f4362b9cf05452bb32c6cf65b4c63cde1b17d3de5276a9d8e777d"

URI_x86_64_v2_kmod = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kmod-31-12.el10.x86_64_v2.rpm;name=x86_64_v2_kmod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmod}"
SRC_URI[x86_64_v2_kmod.sha256sum] = "4256df39b8d400192fd14d1ecb4a5d87d06da1bd2471797c635efc2921459c5b"

URI_x86_64_v2_kmod-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kmod-devel-31-12.el10.x86_64_v2.rpm;name=x86_64_v2_kmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmod-devel}"
SRC_URI[x86_64_v2_kmod-devel.sha256sum] = "c9ff345e09185550e0c4f70ba1e564c6a67c00b12a82dcf3d33776e4981723ee"

URI_x86_64_v2_kmod-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kmod-libs-31-12.el10.x86_64_v2.rpm;name=x86_64_v2_kmod-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmod-libs}"
SRC_URI[x86_64_v2_kmod-libs.sha256sum] = "2f8f3121426ce5585ba09a4d073895ffe8eab56a61d1cec3450d261afcdeb8ca"

URI_aarch64_kmod = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kmod-31-12.el10.aarch64.rpm;name=aarch64_kmod;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmod}"
SRC_URI[aarch64_kmod.sha256sum] = "6f754df0c4edf7193c6e7098f5ba1a0cdcf850d49775ca02682cfeba7fb7c0ed"

URI_aarch64_kmod-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kmod-devel-31-12.el10.aarch64.rpm;name=aarch64_kmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmod-devel}"
SRC_URI[aarch64_kmod-devel.sha256sum] = "ce9e6076edd95b3db2fd66e1104999ab42d0de1383c95e1b1e36c8688c878a4a"

URI_aarch64_kmod-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kmod-libs-31-12.el10.aarch64.rpm;name=aarch64_kmod-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmod-libs}"
SRC_URI[aarch64_kmod-libs.sha256sum] = "0adb4519a2908cf36b919976b0f028a6f27f4e2d5c6e16c6a1f2c53c5d0fb095"

RDEPENDS:kmod = " \
 bash \
 glibc \
 libgcc \
 libzstd \
 openssl-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:kmod-devel = " \
 kmod-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:kmod-libs = " \
 glibc \
 libgcc \
 libzstd \
 openssl-libs \
 xz-libs \
 zlib-ng-compat \
 "
