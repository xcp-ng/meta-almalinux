# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-DH-GMP"
PV = "0.00012"
PR = "34.el10_0"
PACKAGES = " \
 perl-Crypt-DH-GMP \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-DH-GMP-0.00012-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4076db04e0d70353dfc91db575cb7625cadb76bbcd66918e89cf728dee12a1e6"

URI_x86_64_v2_perl-Crypt-DH-GMP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-DH-GMP-0.00012-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-DH-GMP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-DH-GMP}"
SRC_URI[x86_64_v2_perl-Crypt-DH-GMP.sha256sum] = "ead3ee32c494e7cecf72d3750356e0cacddbf92bded949984a2d35a8c3fc31bc"

URI_aarch64_perl-Crypt-DH-GMP = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-DH-GMP-0.00012-34.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-DH-GMP;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-DH-GMP}"
SRC_URI[aarch64_perl-Crypt-DH-GMP.sha256sum] = "493229eed051f4109dd18cab6767a549be6fda0395431b2d29f91d557373d3c0"

RDEPENDS:perl-Crypt-DH-GMP = " \
 glibc \
 gmp \
 perl-libs \
 perl-vars \
 "
