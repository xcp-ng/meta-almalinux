# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libebml"
PV = "1.4.5"
PR = "2.el10_0"
PACKAGES = " \
 libebml \
 libebml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libebml-1.4.5-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "384de777bad22bffad4f9de34d4aead57bb530d6c4f34ceb3489c6a369f1481f"

URI_x86_64_v2_libebml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libebml-1.4.5-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libebml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libebml}"
SRC_URI[x86_64_v2_libebml.sha256sum] = "0f8b125fd26cc9fa250dc26f6cefb0f2ef9409d39d7a397803d67a9402786116"

URI_x86_64_v2_libebml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libebml-devel-1.4.5-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libebml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libebml-devel}"
SRC_URI[x86_64_v2_libebml-devel.sha256sum] = "1c55e07992f217dee96359bf63edbc43e4f4031003a1596b58b5036909758524"

URI_aarch64_libebml = "${EPEL_MIRROR}/aarch64/Packages/l/libebml-1.4.5-2.el10_0.aarch64.rpm;name=aarch64_libebml;unpack=0"
SRC_URI:append = " ${URI_aarch64_libebml}"
SRC_URI[aarch64_libebml.sha256sum] = "c3a6852642553a345bdae82fd772f7269c2850343ee0cb8e65d8934f87a654f2"

URI_aarch64_libebml-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libebml-devel-1.4.5-2.el10_0.aarch64.rpm;name=aarch64_libebml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libebml-devel}"
SRC_URI[aarch64_libebml-devel.sha256sum] = "6f11ca12c5fdf182e9ac29720c85fefdfab41a97a5d8bd6b355254d02ee10509"

RDEPENDS:libebml = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libebml-devel = " \
 cmake-filesystem \
 libebml \
 pkgconf-pkg-config \
 "
