# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "heimdal"
PV = "7.8.0"
PR = "26.el10_1"
PACKAGES = " \
 heimdal-devel \
 heimdal-libs \
 heimdal-path \
 heimdal-server \
 heimdal-static \
 heimdal-workstation \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/heimdal-7.8.0-26.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "461af79ce9b34b09c3e06cd98c5cbb64274882e0c0d2201c13cac80fe6bc216d"

URI_x86_64_v2_heimdal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heimdal-devel-7.8.0-26.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heimdal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_heimdal-devel}"
SRC_URI[x86_64_v2_heimdal-devel.sha256sum] = "c69a4fe3ffa4c3f59f88f938e58cd701712162bbec0e1d659fe4655903093ec5"

URI_x86_64_v2_heimdal-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heimdal-libs-7.8.0-26.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heimdal-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_heimdal-libs}"
SRC_URI[x86_64_v2_heimdal-libs.sha256sum] = "f90e1aad595fa08d5621e5d145611742ded16cf2ac633f7a283bf5c173d6abf3"

URI_x86_64_v2_heimdal-path = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heimdal-path-7.8.0-26.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heimdal-path;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_heimdal-path}"
SRC_URI[x86_64_v2_heimdal-path.sha256sum] = "d48bf1f248ab3f974a0669fcc1d819431107723552478f867babbc5399431db5"

URI_x86_64_v2_heimdal-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heimdal-server-7.8.0-26.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heimdal-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_heimdal-server}"
SRC_URI[x86_64_v2_heimdal-server.sha256sum] = "2547f4710e712ea9ef9adcca6ceced422d6da82ea4260cb152a7ce2e5537cdb5"

URI_x86_64_v2_heimdal-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heimdal-static-7.8.0-26.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heimdal-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_heimdal-static}"
SRC_URI[x86_64_v2_heimdal-static.sha256sum] = "7d7017cd550fbac24d5989335ee2b1a277cc2666858e57ec919ac0583849844a"

URI_x86_64_v2_heimdal-workstation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heimdal-workstation-7.8.0-26.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heimdal-workstation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_heimdal-workstation}"
SRC_URI[x86_64_v2_heimdal-workstation.sha256sum] = "38836c6ef6a0a73bb3d6091dbb0a208162cd8df51a3040d5c846fd228d49a51f"

URI_aarch64_heimdal-devel = "${EPEL_MIRROR}/aarch64/Packages/h/heimdal-devel-7.8.0-26.el10_1.aarch64.rpm;name=aarch64_heimdal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_heimdal-devel}"
SRC_URI[aarch64_heimdal-devel.sha256sum] = "37d34e23d750e76536a3858461056ff5343ab463a9c38f247ca5f6fceba8e062"

URI_aarch64_heimdal-libs = "${EPEL_MIRROR}/aarch64/Packages/h/heimdal-libs-7.8.0-26.el10_1.aarch64.rpm;name=aarch64_heimdal-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_heimdal-libs}"
SRC_URI[aarch64_heimdal-libs.sha256sum] = "062715a6ba180cd0bb051247cb65a06bb49f787cbf7ad78c9a4eaa55885be73e"

URI_aarch64_heimdal-path = "${EPEL_MIRROR}/aarch64/Packages/h/heimdal-path-7.8.0-26.el10_1.aarch64.rpm;name=aarch64_heimdal-path;unpack=0"
SRC_URI:append = " ${URI_aarch64_heimdal-path}"
SRC_URI[aarch64_heimdal-path.sha256sum] = "1c195f2c269c00419529a8c8cb1c22157e083882597d02a197aa04c177cc66a6"

URI_aarch64_heimdal-server = "${EPEL_MIRROR}/aarch64/Packages/h/heimdal-server-7.8.0-26.el10_1.aarch64.rpm;name=aarch64_heimdal-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_heimdal-server}"
SRC_URI[aarch64_heimdal-server.sha256sum] = "6303e06f647905953f6f5db662bed63308b3e3ec2ce418e447f7a0fd58ecf299"

URI_aarch64_heimdal-static = "${EPEL_MIRROR}/aarch64/Packages/h/heimdal-static-7.8.0-26.el10_1.aarch64.rpm;name=aarch64_heimdal-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_heimdal-static}"
SRC_URI[aarch64_heimdal-static.sha256sum] = "a41987e98872dcdb30ef5b8cf6e52e795c6234c9761c8d89e78c7ea64371ff3c"

URI_aarch64_heimdal-workstation = "${EPEL_MIRROR}/aarch64/Packages/h/heimdal-workstation-7.8.0-26.el10_1.aarch64.rpm;name=aarch64_heimdal-workstation;unpack=0"
SRC_URI:append = " ${URI_aarch64_heimdal-workstation}"
SRC_URI[aarch64_heimdal-workstation.sha256sum] = "cce7afe8cde4663c47b8ef724d6f42ed5a06ee9162a574f4dc28f588a9807830"

RDEPENDS:heimdal-devel = " \
 bash \
 glibc \
 heimdal-libs \
 libcom_err \
 "
RDEPENDS:heimdal-libs = " \
 glibc \
 info \
 libcom_err \
 libdb \
 libedit \
 libxcrypt \
 ncurses-libs \
 openldap \
 sqlite-libs \
 "
RDEPENDS:heimdal-path = " \
 heimdal-libs \
 setup \
 "
RDEPENDS:heimdal-server = " \
 bash \
 glibc \
 heimdal-libs \
 libcap-ng \
 logrotate \
 systemd \
 "
RDEPENDS:heimdal-static = " \
 heimdal-devel \
 "
RDEPENDS:heimdal-workstation = " \
 glibc \
 heimdal-libs \
 libedit \
 libxcrypt \
 "
