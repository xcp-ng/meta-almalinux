# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ordered-float"
PV = "5.1.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-ordered-float+arbitrary-devel \
 rust-ordered-float+bytemuck-devel \
 rust-ordered-float+default-devel \
 rust-ordered-float+libm-devel \
 rust-ordered-float+proptest-devel \
 rust-ordered-float+rand-devel \
 rust-ordered-float+randtest-devel \
 rust-ordered-float+rkyv-devel \
 rust-ordered-float+rkyv_16-devel \
 rust-ordered-float+rkyv_32-devel \
 rust-ordered-float+rkyv_64-devel \
 rust-ordered-float+rkyv_ck-devel \
 rust-ordered-float+serde-devel \
 rust-ordered-float+std-devel \
 rust-ordered-float-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ordered-float-5.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "465d576b3d58c1a61f4be6ff99ab1025a0d667929e02973dfacf80b2b72207f7"

URI_x86_64_v2_rust-ordered-float+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+arbitrary-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+arbitrary-devel.sha256sum] = "4412402ecd30a141a09aa4d3918fde1d8e32528791d43a2a7720e722becbaaa2"

URI_x86_64_v2_rust-ordered-float+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+bytemuck-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+bytemuck-devel.sha256sum] = "074660bc726d8a0c0885431d84c57364ece2b13a1aa117e92830582050b5bb66"

URI_x86_64_v2_rust-ordered-float+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+default-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+default-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+default-devel.sha256sum] = "a6611a247edfc03bb7e73801c265997683989fa19211680cad74b7a8305e0ee8"

URI_x86_64_v2_rust-ordered-float+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+libm-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+libm-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+libm-devel.sha256sum] = "b99d4ca96d61fa472f04d0b40fcff3e8a46396997bd862c2c0c648a1832849d8"

URI_x86_64_v2_rust-ordered-float+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+proptest-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+proptest-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+proptest-devel.sha256sum] = "fe50e7ee7883ce6ada19077cbe038959a9217d94259b8698838078c1a079f4d5"

URI_x86_64_v2_rust-ordered-float+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rand-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rand-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rand-devel.sha256sum] = "6edfe1f1f9389d49f879afba29556700dd2791b7c3ff1d794aba4cfd3a772850"

URI_x86_64_v2_rust-ordered-float+randtest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+randtest-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+randtest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+randtest-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+randtest-devel.sha256sum] = "4258a195058e12d21547715cc91385a8c520fc24ebecc5888d24343e583e7dfb"

URI_x86_64_v2_rust-ordered-float+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv-devel.sha256sum] = "ce5eacca83dc65bd3d13fc282765d828ccc99bcfd95701aa98577e219c011dc5"

URI_x86_64_v2_rust-ordered-float+rkyv_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_16-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_16-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_16-devel.sha256sum] = "7aeee8945937a78445966fd0c3461026794a78dce73bcb61a55a9c6b0a53ef7a"

URI_x86_64_v2_rust-ordered-float+rkyv_32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_32-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_32-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_32-devel.sha256sum] = "749c3094572b65e9aa8205e29cd447f4dd1518679e6adb35b5fa569f578a0d3d"

URI_x86_64_v2_rust-ordered-float+rkyv_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_64-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_64-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_64-devel.sha256sum] = "b14700f8babd54723b0733749ca4a9442508455925244976a2273f909857ca4b"

URI_x86_64_v2_rust-ordered-float+rkyv_ck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_ck-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_ck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_ck-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_ck-devel.sha256sum] = "eb26acb23c005a7f6bb9e8267ada0219b16595598b0042c2b47940af6e3b503e"

URI_x86_64_v2_rust-ordered-float+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+serde-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+serde-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+serde-devel.sha256sum] = "fce484892a3c8abbfc998545e9d84fd8d248338985a1d4eb4626c605097c1f97"

URI_x86_64_v2_rust-ordered-float+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+std-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+std-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+std-devel.sha256sum] = "bdf949fd171a8d21a7c06f77100e72238ec97eb74f7fa978943553edbe2cde0d"

URI_x86_64_v2_rust-ordered-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float-devel}"
SRC_URI[x86_64_v2_rust-ordered-float-devel.sha256sum] = "91a1073786b3e608da2fbbbc105d646726d2faa7d6c60b20b73bc626d1385d8d"

URI_aarch64_rust-ordered-float+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+arbitrary-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+arbitrary-devel}"
SRC_URI[aarch64_rust-ordered-float+arbitrary-devel.sha256sum] = "06352a5f9634bd4dae031351e85b690c1ff9de3250b544e5efe0b8a591a276e7"

URI_aarch64_rust-ordered-float+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+bytemuck-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+bytemuck-devel}"
SRC_URI[aarch64_rust-ordered-float+bytemuck-devel.sha256sum] = "85708c81356460cf8ec786e550d5836865c5630cd854586093dbb880defb5dbb"

URI_aarch64_rust-ordered-float+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+default-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+default-devel}"
SRC_URI[aarch64_rust-ordered-float+default-devel.sha256sum] = "a30acef0084b6c1de5d83703ae744437877213923512f0f5213ed18323bb7f7e"

URI_aarch64_rust-ordered-float+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+libm-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+libm-devel}"
SRC_URI[aarch64_rust-ordered-float+libm-devel.sha256sum] = "0fb03c810b16240506e0d53a0777ff01382f76c1aa6c946cea3dc061830f5d2c"

URI_aarch64_rust-ordered-float+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+proptest-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+proptest-devel}"
SRC_URI[aarch64_rust-ordered-float+proptest-devel.sha256sum] = "bacefdd2aebef755fbfe23eb81569de9a9a3b8c2b7653072221722256a673b6c"

URI_aarch64_rust-ordered-float+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rand-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rand-devel}"
SRC_URI[aarch64_rust-ordered-float+rand-devel.sha256sum] = "df4c9414a99fdc35fc7fd435a65d95bfe94566f0bf58376aa7d31071c7bcea51"

URI_aarch64_rust-ordered-float+randtest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+randtest-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+randtest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+randtest-devel}"
SRC_URI[aarch64_rust-ordered-float+randtest-devel.sha256sum] = "ba32da03c9f0dc7a2ad2f4c8bbc50ee75bb08f37a3fbbf16358377638183a1d4"

URI_aarch64_rust-ordered-float+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv-devel.sha256sum] = "1c920599650b78f982966f7f219a8aa338e25217994040130e20e3873d1844df"

URI_aarch64_rust-ordered-float+rkyv_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_16-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_16-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_16-devel.sha256sum] = "c959b652a674e691713ce91530c30c12ba67eaa384f2f4e4513e79e9481d23fc"

URI_aarch64_rust-ordered-float+rkyv_32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_32-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_32-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_32-devel.sha256sum] = "5f59227bbac458b0a8aa125d1d68fbb7c2a702d0b01c93fb78681e27b0df5c61"

URI_aarch64_rust-ordered-float+rkyv_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_64-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_64-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_64-devel.sha256sum] = "059febb3b5b070d9242c892797148986e3acd9dcbe4b7b7a7577bc380eff2bbb"

URI_aarch64_rust-ordered-float+rkyv_ck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_ck-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_ck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_ck-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_ck-devel.sha256sum] = "0f92ba6175d5fb723b31a4a2336b30ba05a4d9d081f2ffdf8625df1138b7a4c6"

URI_aarch64_rust-ordered-float+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+serde-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+serde-devel}"
SRC_URI[aarch64_rust-ordered-float+serde-devel.sha256sum] = "9840a7d9585571bec83e8059098e0b403623795ff346324c28b56a10d7a39ab8"

URI_aarch64_rust-ordered-float+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+std-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+std-devel}"
SRC_URI[aarch64_rust-ordered-float+std-devel.sha256sum] = "03c01bec84ff2343262a6bb5bfeeca6a806f728e80a46d63a276e3854117d926"

URI_aarch64_rust-ordered-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float-devel}"
SRC_URI[aarch64_rust-ordered-float-devel.sha256sum] = "40dfbc3bde86a108ed7cd41dcd28d82fa7394114459daa6ba85d6c19b024374a"

RDEPENDS:rust-ordered-float+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+bytemuck-devel = " \
 cargo \
 rust-bytemuck-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+default-devel = " \
 cargo \
 rust-ordered-float+std-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+libm-devel = " \
 cargo \
 rust-num-traits+libm-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+proptest-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-ordered-float+rand-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-ordered-float+randtest-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-ordered-float+rkyv-devel = " \
 cargo \
 rust-ordered-float+rkyv_32-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_16-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7+size_16-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_32-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_64-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7+size_64-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_ck-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7+validation-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-ordered-float+serde-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rand0.8+serde1-devel \
 rust-rand0.8-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ordered-float+std-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float-devel = " \
 cargo \
 rust \
 rust-num-traits-devel \
 "
