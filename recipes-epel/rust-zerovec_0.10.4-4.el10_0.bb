# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerovec"
PV = "0.10.4"
PR = "4.el10_0"
PACKAGES = " \
 rust-zerovec+databake-devel \
 rust-zerovec+default-devel \
 rust-zerovec+derive-devel \
 rust-zerovec+hashmap-devel \
 rust-zerovec+serde-devel \
 rust-zerovec+std-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerovec-0.10.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "939155b5893b9360307d2d32e92c9149da4a8a0ece22fe4f7de05b52f4fe046c"

URI_x86_64_v2_rust-zerovec+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+databake-devel-0.10.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+databake-devel}"
SRC_URI[x86_64_v2_rust-zerovec+databake-devel.sha256sum] = "b2297a0660183a1ccda672c56a9159b7c712211de8f5291af7e12d6a297f7e3d"

URI_x86_64_v2_rust-zerovec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+default-devel-0.10.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+default-devel}"
SRC_URI[x86_64_v2_rust-zerovec+default-devel.sha256sum] = "733692ae6c2d2797d7cad2be89494f153fb890f1d368435338cd02855a29acb9"

URI_x86_64_v2_rust-zerovec+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+derive-devel-0.10.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+derive-devel}"
SRC_URI[x86_64_v2_rust-zerovec+derive-devel.sha256sum] = "33c0f922c7cdf983112495cb8c36e95a0fd0dd42398fffebcf9dfbdd3cd8b91d"

URI_x86_64_v2_rust-zerovec+hashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+hashmap-devel-0.10.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+hashmap-devel}"
SRC_URI[x86_64_v2_rust-zerovec+hashmap-devel.sha256sum] = "4aac5ad4db52e24fe17ae2547c3aa9f0b21d766e403482d9b3d7ef07a8bb7e04"

URI_x86_64_v2_rust-zerovec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+serde-devel-0.10.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+serde-devel}"
SRC_URI[x86_64_v2_rust-zerovec+serde-devel.sha256sum] = "ab04c9c417f270facab1aa1660ce47905e5308a5d28b58bb7600ef176169908c"

URI_x86_64_v2_rust-zerovec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+std-devel-0.10.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+std-devel}"
SRC_URI[x86_64_v2_rust-zerovec+std-devel.sha256sum] = "6b9c71e52d1d16cb869a06e2a2752f7a7f78e8423195cd63adab4f24fe077771"

URI_x86_64_v2_rust-zerovec+yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+yoke-devel-0.10.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+yoke-devel}"
SRC_URI[x86_64_v2_rust-zerovec+yoke-devel.sha256sum] = "605dcfacb6d8faadfe4ee4a8b19bdc11c7925f0f1239064245e825b914801c2f"

URI_x86_64_v2_rust-zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-devel-0.10.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec-devel}"
SRC_URI[x86_64_v2_rust-zerovec-devel.sha256sum] = "43efc9c8251c36d4761db6e27a595d775295fbb42dfc2a5df77a3f43f98f8b9b"

URI_aarch64_rust-zerovec+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+databake-devel-0.10.4-4.el10_0.noarch.rpm;name=aarch64_rust-zerovec+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+databake-devel}"
SRC_URI[aarch64_rust-zerovec+databake-devel.sha256sum] = "dda18dd9be51a791b6db7767e2e6cab88b73badee20c0c8c32148051df78f5df"

URI_aarch64_rust-zerovec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+default-devel-0.10.4-4.el10_0.noarch.rpm;name=aarch64_rust-zerovec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+default-devel}"
SRC_URI[aarch64_rust-zerovec+default-devel.sha256sum] = "463be735fbd3e572e53bbf1e24b614e5b2218694552d9c7b2c0bf41aada31637"

URI_aarch64_rust-zerovec+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+derive-devel-0.10.4-4.el10_0.noarch.rpm;name=aarch64_rust-zerovec+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+derive-devel}"
SRC_URI[aarch64_rust-zerovec+derive-devel.sha256sum] = "28968e4878a3d78cfb44a15ab40b3567d650bc6ed75b097a2962765297f7ce09"

URI_aarch64_rust-zerovec+hashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+hashmap-devel-0.10.4-4.el10_0.noarch.rpm;name=aarch64_rust-zerovec+hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+hashmap-devel}"
SRC_URI[aarch64_rust-zerovec+hashmap-devel.sha256sum] = "f3066fbdc58090710b100cb8340ea294327bbe2771a6ec86d1f6e58605fefd06"

URI_aarch64_rust-zerovec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+serde-devel-0.10.4-4.el10_0.noarch.rpm;name=aarch64_rust-zerovec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+serde-devel}"
SRC_URI[aarch64_rust-zerovec+serde-devel.sha256sum] = "cc974dc3db559707a4b5a67e159cc7c074f4eaeeeb5891ae3f826268af3e4b8f"

URI_aarch64_rust-zerovec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+std-devel-0.10.4-4.el10_0.noarch.rpm;name=aarch64_rust-zerovec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+std-devel}"
SRC_URI[aarch64_rust-zerovec+std-devel.sha256sum] = "5afdd95ac6cda565fdc224ddcb2c505a1cdbe755c45c1ee7ae3829c9fdb058fd"

URI_aarch64_rust-zerovec+yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+yoke-devel-0.10.4-4.el10_0.noarch.rpm;name=aarch64_rust-zerovec+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+yoke-devel}"
SRC_URI[aarch64_rust-zerovec+yoke-devel.sha256sum] = "f6afb4fce250836ed91125f949c6ad2e9f5e291d819bfbb430eb4c5eebdd06af"

URI_aarch64_rust-zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-devel-0.10.4-4.el10_0.noarch.rpm;name=aarch64_rust-zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec-devel}"
SRC_URI[aarch64_rust-zerovec-devel.sha256sum] = "37e8c78adbfd95daa293ea06412e394190e6cec5117231d0cf81f01a9ccd0d31"

RDEPENDS:rust-zerovec+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+default-devel = " \
 cargo \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+derive-devel = " \
 cargo \
 rust-zerovec-derive-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+hashmap-devel = " \
 cargo \
 rust-twox-hash1-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+serde-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+std-devel = " \
 cargo \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+yoke-devel = " \
 cargo \
 rust-yoke+default-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec-devel = " \
 cargo \
 rust \
 rust-zerofrom-devel \
 "
