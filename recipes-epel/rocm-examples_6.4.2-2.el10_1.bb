# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-examples"
PV = "6.4.2"
PR = "2.el10_1"
PACKAGES:x86_64_v2 = " \
 rocm-examples \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-examples-6.4.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6f7ef8a609b7c76bc2c0a82fbbe2e0d7da3186432467fad9d86462881369d85"

URI_x86_64_v2_rocm-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-examples-6.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-examples}"
SRC_URI[x86_64_v2_rocm-examples.sha256sum] = "e6983208bdcd97d8c2dd7253832f329940f937b7d3a84b25718c4416779f0e7e"

RDEPENDS:rocm-examples = " \
 glibc \
 hipblas \
 hipfft \
 hiprand \
 hipsolver \
 libgcc \
 libstdc++ \
 rocblas \
 rocfft \
 rocm-hip \
 rocrand \
 rocsolver \
 rocsparse \
 "
