# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-huaweicloud-obs"
PV = "3.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-huaweicloud-obs+default-devel \
 rust-reqsign-huaweicloud-obs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-huaweicloud-obs-3.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5409f1ad9147870656790b1aff004f4bf74d801f14a1f44aa2c4f16bb15e4b1"

URI_x86_64_v2_rust-reqsign-huaweicloud-obs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-huaweicloud-obs+default-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-huaweicloud-obs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-huaweicloud-obs+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-huaweicloud-obs+default-devel.sha256sum] = "3994cae9dc296d5d2ffb06926579bbe24e6a8403da76af21b2ed14c84a5bfb24"

URI_x86_64_v2_rust-reqsign-huaweicloud-obs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-huaweicloud-obs-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-huaweicloud-obs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-huaweicloud-obs-devel}"
SRC_URI[x86_64_v2_rust-reqsign-huaweicloud-obs-devel.sha256sum] = "4147bf08bc83c05dd9ffd2432961ee9652b9062c5a43a3f14c6f40b87283e461"

URI_aarch64_rust-reqsign-huaweicloud-obs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-huaweicloud-obs+default-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-huaweicloud-obs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-huaweicloud-obs+default-devel}"
SRC_URI[aarch64_rust-reqsign-huaweicloud-obs+default-devel.sha256sum] = "cae0f8f56922923cd6a002c297c8607882e2c87d36e78f0335e84675028527b2"

URI_aarch64_rust-reqsign-huaweicloud-obs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-huaweicloud-obs-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-huaweicloud-obs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-huaweicloud-obs-devel}"
SRC_URI[aarch64_rust-reqsign-huaweicloud-obs-devel.sha256sum] = "952e6512690ff2122bf73f46355dcb67bddaef0738d92e411106806fd793e606"

RDEPENDS:rust-reqsign-huaweicloud-obs+default-devel = " \
 cargo \
 rust-reqsign-huaweicloud-obs-devel \
 "
RDEPENDS:rust-reqsign-huaweicloud-obs-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 "
