# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkscreen"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 libkscreen \
 libkscreen-devel \
 libkscreen-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkscreen-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3be7e2798f2c2a023ee3ac7fb8630bfee0ffd6b256783a2e3fe3deb492e5ca7"

URI_x86_64_v2_libkscreen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkscreen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkscreen}"
SRC_URI[x86_64_v2_libkscreen.sha256sum] = "aeaa66c9addeacf94bf5601db7d3eba9f5a0c22d9dc5c10f7ad119b67f0ba1f4"

URI_x86_64_v2_libkscreen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-devel-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkscreen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkscreen-devel}"
SRC_URI[x86_64_v2_libkscreen-devel.sha256sum] = "ce2c959ed9fc8782e364ce1ac4742d7b7478ba26c0fde69e7126a62bba53438f"

URI_x86_64_v2_libkscreen-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-doc-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libkscreen-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkscreen-doc}"
SRC_URI[x86_64_v2_libkscreen-doc.sha256sum] = "ede8166d8d5b0ef76b337c33e16567cc8506ce375fdae53339842d20ada6e955"

URI_aarch64_libkscreen = "${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_libkscreen;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkscreen}"
SRC_URI[aarch64_libkscreen.sha256sum] = "81b5dd142880e83e70822d4055c8f829a90dcdadfaa912d6393042f95826a481"

URI_aarch64_libkscreen-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-devel-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_libkscreen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkscreen-devel}"
SRC_URI[aarch64_libkscreen-devel.sha256sum] = "c463a830c70934d43e1a9e4a9228d4bbe78e61bf7b32984bc6c19009bab4a6bb"

URI_aarch64_libkscreen-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-doc-6.4.5-1.el10_1.noarch.rpm;name=aarch64_libkscreen-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkscreen-doc}"
SRC_URI[aarch64_libkscreen-doc.sha256sum] = "3be5639cfc2c2122464e13e35efa063937dac80d2e5b79a88ea719521798694f"

RDEPENDS:libkscreen = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwayland \
 "
RDEPENDS:libkscreen-devel = " \
 cmake-filesystem \
 libkscreen \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:libkscreen-doc = " \
 "
