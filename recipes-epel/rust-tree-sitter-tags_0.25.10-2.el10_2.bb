# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-tags"
PV = "0.25.10"
PR = "2.el10_2"
PACKAGES = " \
 rust-tree-sitter-tags+default-devel \
 rust-tree-sitter-tags-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-tags-0.25.10-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50314907745cd60bbdd383f26c54264a205efec49993fd9257a2aab63358f84d"

URI_x86_64_v2_rust-tree-sitter-tags+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-tags+default-devel-0.25.10-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-tags+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-tags+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-tags+default-devel.sha256sum] = "fe8eecc08b737ff16575475e4d5f28746571352478e6531538de59b7c334a197"

URI_x86_64_v2_rust-tree-sitter-tags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-tags-devel-0.25.10-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-tags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-tags-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-tags-devel.sha256sum] = "62aab14394992dd12ce2cf39ab11bf6e63370f622b3f42921e8004ed78d4c431"

URI_aarch64_rust-tree-sitter-tags+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-tags+default-devel-0.25.10-2.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-tags+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-tags+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-tags+default-devel.sha256sum] = "3075ccb717d3bfae00c6e1e3b6d43a0ebd318108c7d0d99cc524c985abe3233d"

URI_aarch64_rust-tree-sitter-tags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-tags-devel-0.25.10-2.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-tags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-tags-devel}"
SRC_URI[aarch64_rust-tree-sitter-tags-devel.sha256sum] = "77a63c9ba29252b538d20d423f5d4fc8bad7a91906f629c0b44507b928d36ae3"

RDEPENDS:rust-tree-sitter-tags+default-devel = " \
 cargo \
 rust-tree-sitter-tags-devel \
 "
RDEPENDS:rust-tree-sitter-tags-devel = " \
 cargo \
 rust \
 rust-memchr+default-devel \
 rust-regex+default-devel \
 rust-streaming-iterator+default-devel \
 rust-thiserror+default-devel \
 rust-tree-sitter0.25+default-devel \
 "
