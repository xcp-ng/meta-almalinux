# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16"
PV = "16.14"
PR = "3.el10"
PACKAGES = " \
 postgresql \
 postgresql-contrib \
 postgresql-docs \
 postgresql-plperl \
 postgresql-plpython3 \
 postgresql-pltcl \
 postgresql-private-devel \
 postgresql-private-libs \
 postgresql-server \
 postgresql-server-devel \
 postgresql-static \
 postgresql-test \
 postgresql-test-rpm-macros \
 postgresql-upgrade \
 postgresql-upgrade-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql16-16.14-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fa71200bd753d413129f22385c092a1aeb4ba265b3eea4e4c836ffa75d64bc8c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql;unpack=0"
SRC_URI[x86_64_v2_postgresql.sha256sum] = "a871539ac5241527397e052ce42548139d6e6d3c1da77a1d467e5ed1b6342440"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-contrib-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-contrib;unpack=0"
SRC_URI[x86_64_v2_postgresql-contrib.sha256sum] = "66019fb5e74d42ffdd3bd37b6bfc930548a430dc06dcc5d7b78d69dd892ee8c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-docs-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-docs;unpack=0"
SRC_URI[x86_64_v2_postgresql-docs.sha256sum] = "7c685d74f698c223df6990e891be17235de5d34ac9566af78be7f66620367cc1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-plperl-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-plperl;unpack=0"
SRC_URI[x86_64_v2_postgresql-plperl.sha256sum] = "a368e5c0019d43e836e7078e72305b6b3f7ff779aaa3829a30cdea58a284093b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-plpython3-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-plpython3;unpack=0"
SRC_URI[x86_64_v2_postgresql-plpython3.sha256sum] = "494f09011d6883b34d1e1007ea81452be208c0597325ae0abe543493feff664e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-pltcl-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-pltcl;unpack=0"
SRC_URI[x86_64_v2_postgresql-pltcl.sha256sum] = "f5154a4efdd12a4a4e841de21919e4737db210510623b5dda501f05eddf1a53c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-private-devel-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-private-devel;unpack=0"
SRC_URI[x86_64_v2_postgresql-private-devel.sha256sum] = "019c05fcb9079b49fd1eef76231e042d71283781371f16d91f5c7e21f71019e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-private-libs-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-private-libs;unpack=0"
SRC_URI[x86_64_v2_postgresql-private-libs.sha256sum] = "7abae7d5744ec49a61ebac03a60f4686d57385237a288ea010ef4cab51472470"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-server-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-server;unpack=0"
SRC_URI[x86_64_v2_postgresql-server.sha256sum] = "a059f6200942e30f7df1385ddd2448dd779f0afb24aa3ad6e5b8605bcd67465a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-server-devel-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-server-devel;unpack=0"
SRC_URI[x86_64_v2_postgresql-server-devel.sha256sum] = "27ee99f906536d3785a442b439e425cda8a6d310f5320611e880412f2d5083e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-static-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-static;unpack=0"
SRC_URI[x86_64_v2_postgresql-static.sha256sum] = "9c2f59e935677718a9c8a8672e9134769592bae732985203bc01791f743abdff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-test-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-test;unpack=0"
SRC_URI[x86_64_v2_postgresql-test.sha256sum] = "69e3954ae0a8734c176179c559b55b00be6b64505f1ad9df6746147aeea316fc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/postgresql-test-rpm-macros-16.14-3.el10.noarch.rpm;name=x86_64_v2_postgresql-test-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_postgresql-test-rpm-macros.sha256sum] = "cf38f4d4fd41b9d77069bb0b3e138d2c8df0f26207ca7011db01534b2c126913"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-upgrade;unpack=0"
SRC_URI[x86_64_v2_postgresql-upgrade.sha256sum] = "0803f920e7a813a2522efd0b77cd9d4f73b69fc99073cc400da956957436b9bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-devel-16.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql-upgrade-devel;unpack=0"
SRC_URI[x86_64_v2_postgresql-upgrade-devel.sha256sum] = "37213f762384069420f37144532fbac9a120dca16d23fd02bd62a9a63525bee1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql;unpack=0"
SRC_URI[aarch64_postgresql.sha256sum] = "d6add8c56291088671b6401995a65d6b0aa182d639540affe70f29329a57e9be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-contrib-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql-contrib;unpack=0"
SRC_URI[aarch64_postgresql-contrib.sha256sum] = "058f59d618d4761eba0347422ba7bf90611ce9f9c7b7ddb32e8fccbf292c42d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-docs-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql-docs;unpack=0"
SRC_URI[aarch64_postgresql-docs.sha256sum] = "9daf8f4f15b10af5ea746404fc74ec0f8d1a134eeff21d47a392b1e4eba8103c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-plperl-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql-plperl;unpack=0"
SRC_URI[aarch64_postgresql-plperl.sha256sum] = "57d70e37dbc7ac5f95f9814a320de417c8b961c360f8d1b71be6c5f14fbcbda1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-plpython3-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql-plpython3;unpack=0"
SRC_URI[aarch64_postgresql-plpython3.sha256sum] = "68e381501f2de9a4cc211994f2b90e3d75a74f478700837acc9e48e4b33d0f05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-pltcl-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql-pltcl;unpack=0"
SRC_URI[aarch64_postgresql-pltcl.sha256sum] = "86f5cc1a6fcf288eb96b9d4c4a89ec472a2e4be7643da934660e540e1ca36338"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-private-devel-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql-private-devel;unpack=0"
SRC_URI[aarch64_postgresql-private-devel.sha256sum] = "21606ea995060c4a0a6d93ebb88789b99bf09a1bc60e7d36a2de40a5c84005ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-private-libs-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql-private-libs;unpack=0"
SRC_URI[aarch64_postgresql-private-libs.sha256sum] = "2f5f8386189687dcf3faf5aabac996740476e6b6317c02ccb50c91db1abe05b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-server-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql-server;unpack=0"
SRC_URI[aarch64_postgresql-server.sha256sum] = "96d639c778417bd72fcbd70514572ed17fc3ae916d913ad1e62c6b5058df55cb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-server-devel-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql-server-devel;unpack=0"
SRC_URI[aarch64_postgresql-server-devel.sha256sum] = "dac674a1ed49299855ab8d4e024e4ce87ab5ff2f68ad6e64d2f9b2269c5f7e1e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-static-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql-static;unpack=0"
SRC_URI[aarch64_postgresql-static.sha256sum] = "db98ff309e90417f96ca7b37b58b74fda640f6814edef2c2e9ffb38170940fd9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-test-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql-test;unpack=0"
SRC_URI[aarch64_postgresql-test.sha256sum] = "e35ae7583c75697b6df9357155b65647cc69a10146ac45f272ba594a6f6e6e40"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/postgresql-test-rpm-macros-16.14-3.el10.noarch.rpm;name=aarch64_postgresql-test-rpm-macros;unpack=0"
SRC_URI[aarch64_postgresql-test-rpm-macros.sha256sum] = "cf38f4d4fd41b9d77069bb0b3e138d2c8df0f26207ca7011db01534b2c126913"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-upgrade-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql-upgrade;unpack=0"
SRC_URI[aarch64_postgresql-upgrade.sha256sum] = "049adf482c61af3610f74c199ded58b70eff6952fcf8cc234ada720d377c1dcd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-upgrade-devel-16.14-3.el10.aarch64.rpm;name=aarch64_postgresql-upgrade-devel;unpack=0"
SRC_URI[aarch64_postgresql-upgrade-devel.sha256sum] = "6ea9d96666da926189860611a37adbdef49da07fbe47143937cd8260bd80584c"

RDEPENDS:postgresql = " \
 glibc \
 libzstd \
 lz4-libs \
 openssl-libs \
 postgresql-private-libs \
 readline \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-contrib = " \
 glibc \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openssl-libs \
 perl-libs \
 postgresql \
 postgresql-private-libs \
 python3-libs \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-docs = " \
 glibc \
 postgresql \
 "
RDEPENDS:postgresql-plperl = " \
 glibc \
 perl-libs \
 postgresql-server \
 "
RDEPENDS:postgresql-plpython3 = " \
 glibc \
 postgresql-server \
 python3-libs \
 "
RDEPENDS:postgresql-pltcl = " \
 glibc \
 postgresql-server \
 tcl \
 "
RDEPENDS:postgresql-private-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 postgresql-private-libs \
 "
RDEPENDS:postgresql-private-libs = " \
 glibc \
 krb5-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:postgresql-server = " \
 bash \
 glibc \
 krb5-libs \
 libicu \
 libxml2 \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 postgresql \
 postgresql-private-libs \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-server-devel = " \
 bash \
 glibc \
 krb5-devel \
 libicu-devel \
 postgresql-private-devel \
 postgresql-private-libs \
 "
RDEPENDS:postgresql-static = " \
 postgresql-server-devel \
 "
RDEPENDS:postgresql-test = " \
 bash \
 glibc \
 postgresql-contrib \
 postgresql-server \
 postgresql-server-devel \
 "
RDEPENDS:postgresql-test-rpm-macros = " \
 postgresql-server \
 "
RDEPENDS:postgresql-upgrade = " \
 glibc \
 krb5-libs \
 libicu \
 libselinux \
 libxml2 \
 libxslt \
 openldap \
 openssl-libs \
 pam-libs \
 perl-libs \
 postgresql-private-libs \
 postgresql-server \
 python3-libs \
 tcl \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-upgrade-devel = " \
 bash \
 glibc \
 postgresql-upgrade \
 "
