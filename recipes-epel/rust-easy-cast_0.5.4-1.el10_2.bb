# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-easy-cast"
PV = "0.5.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-easy-cast+always_assert-devel \
 rust-easy-cast+assert_digits-devel \
 rust-easy-cast+assert_float-devel \
 rust-easy-cast+assert_int-devel \
 rust-easy-cast+assert_nonzero-devel \
 rust-easy-cast+default-devel \
 rust-easy-cast+libm-devel \
 rust-easy-cast+std-devel \
 rust-easy-cast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-easy-cast-0.5.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8836d5dd17b652c9084c362fd0adac7bae85a30bc67df8ae6dfc2281375ca469"

URI_x86_64_v2_rust-easy-cast+always_assert-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-easy-cast+always_assert-devel-0.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-easy-cast+always_assert-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-easy-cast+always_assert-devel}"
SRC_URI[x86_64_v2_rust-easy-cast+always_assert-devel.sha256sum] = "4cdc28e321148fcadcf92d621cdfe3e9dc2ffe841bacfa9c8c34d9d4a6d54991"

URI_x86_64_v2_rust-easy-cast+assert_digits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-easy-cast+assert_digits-devel-0.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-easy-cast+assert_digits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-easy-cast+assert_digits-devel}"
SRC_URI[x86_64_v2_rust-easy-cast+assert_digits-devel.sha256sum] = "e2967e6bcebe6df12e844b08e3cb50c2876f540f3dee65a5355cfeaadfe7041d"

URI_x86_64_v2_rust-easy-cast+assert_float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-easy-cast+assert_float-devel-0.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-easy-cast+assert_float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-easy-cast+assert_float-devel}"
SRC_URI[x86_64_v2_rust-easy-cast+assert_float-devel.sha256sum] = "5644206c0ef2089282adc40252b5fda0b6a2bfedb66a8dcb32fa3c507841ddf8"

URI_x86_64_v2_rust-easy-cast+assert_int-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-easy-cast+assert_int-devel-0.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-easy-cast+assert_int-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-easy-cast+assert_int-devel}"
SRC_URI[x86_64_v2_rust-easy-cast+assert_int-devel.sha256sum] = "3e6d20bcaf51c835df2d40184f1b0dd2711ce832724f52ca7bdc8b56c00f9ef7"

URI_x86_64_v2_rust-easy-cast+assert_nonzero-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-easy-cast+assert_nonzero-devel-0.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-easy-cast+assert_nonzero-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-easy-cast+assert_nonzero-devel}"
SRC_URI[x86_64_v2_rust-easy-cast+assert_nonzero-devel.sha256sum] = "79b97143fd8238edf6bdb30dc352b492e3f64a6f1d14d7da3eeac386dafb82c3"

URI_x86_64_v2_rust-easy-cast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-easy-cast+default-devel-0.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-easy-cast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-easy-cast+default-devel}"
SRC_URI[x86_64_v2_rust-easy-cast+default-devel.sha256sum] = "c216c392449bed63612d7d083c3e41175232fb816184d70660763ba673dbc6e4"

URI_x86_64_v2_rust-easy-cast+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-easy-cast+libm-devel-0.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-easy-cast+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-easy-cast+libm-devel}"
SRC_URI[x86_64_v2_rust-easy-cast+libm-devel.sha256sum] = "2bb7a65cddd4d75cc3db3c99cf4f08d232f1b1fd0862b1c07f964ae06a705c16"

URI_x86_64_v2_rust-easy-cast+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-easy-cast+std-devel-0.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-easy-cast+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-easy-cast+std-devel}"
SRC_URI[x86_64_v2_rust-easy-cast+std-devel.sha256sum] = "2c487311ca3977644a9ef805b4a1027ac813b3e8b2f7974479439fc382e292ac"

URI_x86_64_v2_rust-easy-cast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-easy-cast-devel-0.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-easy-cast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-easy-cast-devel}"
SRC_URI[x86_64_v2_rust-easy-cast-devel.sha256sum] = "ef21fd1ab90f9eb9acbac16e694019ed56bd7b00acc2dc615c1754191538abca"

URI_aarch64_rust-easy-cast+always_assert-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-easy-cast+always_assert-devel-0.5.4-1.el10_2.noarch.rpm;name=aarch64_rust-easy-cast+always_assert-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-easy-cast+always_assert-devel}"
SRC_URI[aarch64_rust-easy-cast+always_assert-devel.sha256sum] = "3b5e2d4d62f91668c11840e3f5b1f1778b74b3c3b7c176b2bca463dd77886904"

URI_aarch64_rust-easy-cast+assert_digits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-easy-cast+assert_digits-devel-0.5.4-1.el10_2.noarch.rpm;name=aarch64_rust-easy-cast+assert_digits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-easy-cast+assert_digits-devel}"
SRC_URI[aarch64_rust-easy-cast+assert_digits-devel.sha256sum] = "b5974f8dac54195a8f2bca2fcb1929cf3e664d5828ab0ad2c1f870f081b9500f"

URI_aarch64_rust-easy-cast+assert_float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-easy-cast+assert_float-devel-0.5.4-1.el10_2.noarch.rpm;name=aarch64_rust-easy-cast+assert_float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-easy-cast+assert_float-devel}"
SRC_URI[aarch64_rust-easy-cast+assert_float-devel.sha256sum] = "8b147e6a56ae8dc637f4f880c3ab04dda2e584fc12439280d850976b49462bb7"

URI_aarch64_rust-easy-cast+assert_int-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-easy-cast+assert_int-devel-0.5.4-1.el10_2.noarch.rpm;name=aarch64_rust-easy-cast+assert_int-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-easy-cast+assert_int-devel}"
SRC_URI[aarch64_rust-easy-cast+assert_int-devel.sha256sum] = "e65c5c7179e8ddefce65cb8278db015059a89a068fabaff3f63a8b59fd3d6d58"

URI_aarch64_rust-easy-cast+assert_nonzero-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-easy-cast+assert_nonzero-devel-0.5.4-1.el10_2.noarch.rpm;name=aarch64_rust-easy-cast+assert_nonzero-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-easy-cast+assert_nonzero-devel}"
SRC_URI[aarch64_rust-easy-cast+assert_nonzero-devel.sha256sum] = "4dd4d1317eed044f479e71be026cd63d9bb88ddb2430cef35febd5932bd6c4e9"

URI_aarch64_rust-easy-cast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-easy-cast+default-devel-0.5.4-1.el10_2.noarch.rpm;name=aarch64_rust-easy-cast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-easy-cast+default-devel}"
SRC_URI[aarch64_rust-easy-cast+default-devel.sha256sum] = "b8ca2afac65df2fdbf903a2cab65cd3184c0d0d4bd37b42c65a246464aefba5f"

URI_aarch64_rust-easy-cast+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-easy-cast+libm-devel-0.5.4-1.el10_2.noarch.rpm;name=aarch64_rust-easy-cast+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-easy-cast+libm-devel}"
SRC_URI[aarch64_rust-easy-cast+libm-devel.sha256sum] = "b86643db5b67582ca4cec6c827a59ecfed79ef8eb1d85fcd937e38fcb73fdf29"

URI_aarch64_rust-easy-cast+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-easy-cast+std-devel-0.5.4-1.el10_2.noarch.rpm;name=aarch64_rust-easy-cast+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-easy-cast+std-devel}"
SRC_URI[aarch64_rust-easy-cast+std-devel.sha256sum] = "2d5b3ee454bc37fbbd58f0e29a5fa5f8b3d202c054cba75b8322b26e5113b935"

URI_aarch64_rust-easy-cast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-easy-cast-devel-0.5.4-1.el10_2.noarch.rpm;name=aarch64_rust-easy-cast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-easy-cast-devel}"
SRC_URI[aarch64_rust-easy-cast-devel.sha256sum] = "72d44ca8190a5411e84ba514c2b28fc7512f9a1bec441b9372e539df94d12c58"

RDEPENDS:rust-easy-cast+always_assert-devel = " \
 cargo \
 rust-easy-cast+assert_digits-devel \
 rust-easy-cast+assert_float-devel \
 rust-easy-cast+assert_int-devel \
 rust-easy-cast+assert_nonzero-devel \
 rust-easy-cast-devel \
 "
RDEPENDS:rust-easy-cast+assert_digits-devel = " \
 cargo \
 rust-easy-cast-devel \
 "
RDEPENDS:rust-easy-cast+assert_float-devel = " \
 cargo \
 rust-easy-cast-devel \
 "
RDEPENDS:rust-easy-cast+assert_int-devel = " \
 cargo \
 rust-easy-cast-devel \
 "
RDEPENDS:rust-easy-cast+assert_nonzero-devel = " \
 cargo \
 rust-easy-cast-devel \
 "
RDEPENDS:rust-easy-cast+default-devel = " \
 cargo \
 rust-easy-cast+std-devel \
 rust-easy-cast-devel \
 "
RDEPENDS:rust-easy-cast+libm-devel = " \
 cargo \
 rust-easy-cast-devel \
 rust-libm+default-devel \
 "
RDEPENDS:rust-easy-cast+std-devel = " \
 cargo \
 rust-easy-cast-devel \
 "
RDEPENDS:rust-easy-cast-devel = " \
 cargo \
 rust \
 "
