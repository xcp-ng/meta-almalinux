# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokei"
PV = "14.0.0"
PR = "4.el10_2"
PACKAGES = " \
 rust-tokei+all-devel \
 rust-tokei+cbor-devel \
 rust-tokei+cli-devel \
 rust-tokei+default-devel \
 rust-tokei+yaml-devel \
 rust-tokei-devel \
 tokei \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokei-14.0.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6dce4b135be6f6e252058e136d5a8dcc57c291fcc61ef98f6635a2b972fe8cd"

URI_x86_64_v2_rust-tokei+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+all-devel-14.0.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+all-devel}"
SRC_URI[x86_64_v2_rust-tokei+all-devel.sha256sum] = "470052569625f003eb53aae5aeccfed00be59e5919a0aded0a3f90d38070d990"

URI_x86_64_v2_rust-tokei+cbor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+cbor-devel-14.0.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+cbor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+cbor-devel}"
SRC_URI[x86_64_v2_rust-tokei+cbor-devel.sha256sum] = "80dda33f00bd3be666d832fcaf479d41ae5fa3bdb94dd8af35adc5f0148a42b5"

URI_x86_64_v2_rust-tokei+cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+cli-devel-14.0.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+cli-devel}"
SRC_URI[x86_64_v2_rust-tokei+cli-devel.sha256sum] = "a39831053e2abc33d5c3a43ecb3a629cd096b4816195bca756c5beba678c2a20"

URI_x86_64_v2_rust-tokei+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+default-devel-14.0.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+default-devel}"
SRC_URI[x86_64_v2_rust-tokei+default-devel.sha256sum] = "f11f64dec82e1900682021980fb2f6b749c05393a6f5798250da2de34808c9e0"

URI_x86_64_v2_rust-tokei+yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+yaml-devel-14.0.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+yaml-devel}"
SRC_URI[x86_64_v2_rust-tokei+yaml-devel.sha256sum] = "5f8ec369ec48410f6657ac3d808177c55cbf23366c2a326b3d358787f1a1dff5"

URI_x86_64_v2_rust-tokei-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei-devel-14.0.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei-devel}"
SRC_URI[x86_64_v2_rust-tokei-devel.sha256sum] = "88be61a3dde5ea632acf26e711a043854199ab702461f6d4f00fe8f2d288569a"

URI_x86_64_v2_tokei = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tokei-14.0.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tokei;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tokei}"
SRC_URI[x86_64_v2_tokei.sha256sum] = "0acffe54e344af8201ad6ded324b0e7f8724390dc69085f84aca2b6671c9d985"

URI_aarch64_rust-tokei+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+all-devel-14.0.0-4.el10_2.noarch.rpm;name=aarch64_rust-tokei+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+all-devel}"
SRC_URI[aarch64_rust-tokei+all-devel.sha256sum] = "ceea25f04ae5a9912280ce0a89f90711185ea8a33845a8c29405046aece20084"

URI_aarch64_rust-tokei+cbor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+cbor-devel-14.0.0-4.el10_2.noarch.rpm;name=aarch64_rust-tokei+cbor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+cbor-devel}"
SRC_URI[aarch64_rust-tokei+cbor-devel.sha256sum] = "4aea81bcec9fc9576afd0edb8272c32bc2d649c8e17a1db529c1532fcb5143b7"

URI_aarch64_rust-tokei+cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+cli-devel-14.0.0-4.el10_2.noarch.rpm;name=aarch64_rust-tokei+cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+cli-devel}"
SRC_URI[aarch64_rust-tokei+cli-devel.sha256sum] = "f0ce1b087a24cb7078d21aace2a7702a2e8541d5f35f13b81b0ce194388a76dd"

URI_aarch64_rust-tokei+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+default-devel-14.0.0-4.el10_2.noarch.rpm;name=aarch64_rust-tokei+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+default-devel}"
SRC_URI[aarch64_rust-tokei+default-devel.sha256sum] = "6a38334963f77f0bc9778e12cd9565817811b5a81b0778abedba46e9fbb72f57"

URI_aarch64_rust-tokei+yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+yaml-devel-14.0.0-4.el10_2.noarch.rpm;name=aarch64_rust-tokei+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+yaml-devel}"
SRC_URI[aarch64_rust-tokei+yaml-devel.sha256sum] = "ae0344dd365add31f8a5f19bd547377e894d8e7faa8a571f398622b462e58f7a"

URI_aarch64_rust-tokei-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei-devel-14.0.0-4.el10_2.noarch.rpm;name=aarch64_rust-tokei-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei-devel}"
SRC_URI[aarch64_rust-tokei-devel.sha256sum] = "e347753ecbf6e4d3087b3d8f34751f56236f0587e23c7e6595fd59a6504ed378"

URI_aarch64_tokei = "${EPEL_MIRROR}/aarch64/Packages/t/tokei-14.0.0-4.el10_2.aarch64.rpm;name=aarch64_tokei;unpack=0"
SRC_URI:append = " ${URI_aarch64_tokei}"
SRC_URI[aarch64_tokei.sha256sum] = "726f7a7fff547349f6f2c47c3741251de1487d93ecdf4476405e34fa035ffcc9"

RDEPENDS:rust-tokei+all-devel = " \
 cargo \
 rust-tokei+cbor-devel \
 rust-tokei+yaml-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+cbor-devel = " \
 cargo \
 rust-hex+default-devel \
 rust-serde_cbor+default-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+cli-devel = " \
 cargo \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-clap+string-devel \
 rust-clap+wrap_help-devel \
 rust-colored+default-devel \
 rust-env_logger+default-devel \
 rust-num-format+default-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+default-devel = " \
 cargo \
 rust-tokei+cli-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+yaml-devel = " \
 cargo \
 rust-serde_yaml+default-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei-devel = " \
 cargo \
 rust \
 rust-aho-corasick+default-devel \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-clap-cargo+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-dashmap+default-devel \
 rust-dashmap+serde-devel \
 rust-encoding_rs_io+default-devel \
 rust-etcetera+default-devel \
 rust-grep-searcher+default-devel \
 rust-ignore+default-devel \
 rust-json5+default-devel \
 rust-log+default-devel \
 rust-once_cell+default-devel \
 rust-parking_lot+default-devel \
 rust-rayon+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_json+default-devel \
 rust-table_formatter+default-devel \
 rust-tera+default-devel \
 rust-term_size+default-devel \
 rust-toml0.9+default-devel \
 "
RDEPENDS:tokei = " \
 glibc \
 libgcc \
 "
