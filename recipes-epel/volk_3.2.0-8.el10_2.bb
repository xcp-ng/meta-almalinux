# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "volk"
PV = "3.2.0"
PR = "8.el10_2"
PACKAGES = " \
 volk \
 volk-devel \
 volk-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/volk-3.2.0-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8da81a652dceb1d8b6b8bfddf867af984a2f3fbf7a54c248060bbc5a7c2c7317"

URI_x86_64_v2_volk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/volk-3.2.0-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_volk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volk}"
SRC_URI[x86_64_v2_volk.sha256sum] = "c5b430c4b5d9dcefff496231136db354fb80ebf057478c8b592f136d29f923d4"

URI_x86_64_v2_volk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/volk-devel-3.2.0-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_volk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volk-devel}"
SRC_URI[x86_64_v2_volk-devel.sha256sum] = "b46e511e5bc9030d7f48e563afc7d87b8c161d054216d625681c1a9ba9fcfea1"

URI_x86_64_v2_volk-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/volk-doc-3.2.0-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_volk-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volk-doc}"
SRC_URI[x86_64_v2_volk-doc.sha256sum] = "ea8d0953a3c19ddbde1e5728eb1c564fcb7abc1c6a24ac6600a8c401f90c6525"

URI_aarch64_volk = "${EPEL_MIRROR}/aarch64/Packages/v/volk-3.2.0-8.el10_2.aarch64.rpm;name=aarch64_volk;unpack=0"
SRC_URI:append = " ${URI_aarch64_volk}"
SRC_URI[aarch64_volk.sha256sum] = "6cd00bc3caa94628b0b8e0d5174e66555fcf7bd7a112961f94103f2230553ae2"

URI_aarch64_volk-devel = "${EPEL_MIRROR}/aarch64/Packages/v/volk-devel-3.2.0-8.el10_2.aarch64.rpm;name=aarch64_volk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_volk-devel}"
SRC_URI[aarch64_volk-devel.sha256sum] = "7c12025fb32e85180130654cf110d1943e88b8bbcb0bb28ed071c4750b25bdd4"

URI_aarch64_volk-doc = "${EPEL_MIRROR}/aarch64/Packages/v/volk-doc-3.2.0-8.el10_2.noarch.rpm;name=aarch64_volk-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_volk-doc}"
SRC_URI[aarch64_volk-doc.sha256sum] = "53e73041e2eaec8b56af72c4b21cefe55cc8c0e1236329572fd66acf3947503d"

RDEPENDS:volk:x86_64_v2 = " \
 glibc \
 google-cpu_features \
 libgcc \
 libstdc++ \
 orc \
 python3 \
"
RDEPENDS:volk:aarch64 = " \
 glibc \
 libgcc \
 libstdc++ \
 orc \
 python3 \
"
RDEPENDS:volk-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 volk \
 "
RDEPENDS:volk-doc = " \
 volk \
 "
