# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-filesystem \
 kf6-rpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "655c0efaffb3fc649dc018b688a28a8573b6a74f9781144c57775041ff0eb559"

URI_x86_64_v2_kf6-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-filesystem-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-filesystem}"
SRC_URI[x86_64_v2_kf6-filesystem.sha256sum] = "cf5d799d4b02858bdb6d9e094b8c22f4048f51506a2d31c12b4e5c166730f3a3"

URI_x86_64_v2_kf6-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-rpm-macros-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-rpm-macros}"
SRC_URI[x86_64_v2_kf6-rpm-macros.sha256sum] = "4f05a08b14ce2d253a351e031d8aa7417c1229b96a3db4e7ded3e35298607a85"

URI_aarch64_kf6-filesystem = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-filesystem-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-filesystem}"
SRC_URI[aarch64_kf6-filesystem.sha256sum] = "8de83f93074b856dc7191c6218102f1e6de20d68bacedc1dd2b16c4d992468f6"

URI_aarch64_kf6-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-rpm-macros-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-rpm-macros}"
SRC_URI[aarch64_kf6-rpm-macros.sha256sum] = "fb21f408e1f3100807e19cba63872865fbb07740e64d86647dc918909dd198a1"

RDEPENDS:kf6-filesystem = " \
 kde-filesystem \
 "
RDEPENDS:kf6-rpm-macros = " \
 cmake \
 doxygen \
 gcc-c++ \
 qt6-doc-devel \
 qt6-qttools-devel \
 qt6-rpm-macros \
 "
