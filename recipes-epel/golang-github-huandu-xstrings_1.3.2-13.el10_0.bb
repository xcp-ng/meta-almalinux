# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-huandu-xstrings"
PV = "1.3.2"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-huandu-xstrings-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-huandu-xstrings-1.3.2-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f05dd689036a34a726c2a8c623a28ad24e3ea606deeb808b6f62323bb7f6f2e"

URI_x86_64_v2_golang-github-huandu-xstrings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-huandu-xstrings-devel-1.3.2-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-huandu-xstrings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-huandu-xstrings-devel}"
SRC_URI[x86_64_v2_golang-github-huandu-xstrings-devel.sha256sum] = "05fb504dc284960721b97ab3883be2c18dbb072ad36b0e64fa6d8afd8f82eb27"

URI_aarch64_golang-github-huandu-xstrings-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-huandu-xstrings-devel-1.3.2-13.el10_0.noarch.rpm;name=aarch64_golang-github-huandu-xstrings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-huandu-xstrings-devel}"
SRC_URI[aarch64_golang-github-huandu-xstrings-devel.sha256sum] = "ffc29be571edcc72c0833772c96008f8a79d759a030675c6f7bb7f1d8ee2b3ae"

RDEPENDS:golang-github-huandu-xstrings-devel = " \
 go-filesystem \
 "
