# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-argon2-cffi"
PV = "23.1.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-argon2-cffi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-argon2-cffi-23.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f54e50241a6726bd92fab076e2e070a8f34dac529e788280d19497149370fc0d"

URI_x86_64_v2_python3-argon2-cffi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-argon2-cffi-23.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-argon2-cffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-argon2-cffi}"
SRC_URI[x86_64_v2_python3-argon2-cffi.sha256sum] = "c38de13d1be9d3108a6aa1abb550ae195c2024e67b9084463d1ad13f5edaf5b7"

URI_aarch64_python3-argon2-cffi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-argon2-cffi-23.1.0-1.el10_0.noarch.rpm;name=aarch64_python3-argon2-cffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-argon2-cffi}"
SRC_URI[aarch64_python3-argon2-cffi.sha256sum] = "2227bc0008ce61773bd4cdf553828f4e1b35f8acd82c938b47e74ff85790030d"

RDEPENDS:python3-argon2-cffi = " \
 python3 \
 python3-argon2-cffi-bindings \
 "
