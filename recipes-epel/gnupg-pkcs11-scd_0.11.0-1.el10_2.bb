# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnupg-pkcs11-scd"
PV = "0.11.0"
PR = "1.el10_2"
PACKAGES = " \
 gnupg-pkcs11-scd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnupg-pkcs11-scd-0.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90596059eeed362a528a668dd97d83cf76eee641fa1859ca603850b86ba74679"

URI_x86_64_v2_gnupg-pkcs11-scd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnupg-pkcs11-scd-0.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnupg-pkcs11-scd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnupg-pkcs11-scd}"
SRC_URI[x86_64_v2_gnupg-pkcs11-scd.sha256sum] = "92680055974498d812442db877be87a436198ac9a8dee4b2e81b217373353e94"

URI_aarch64_gnupg-pkcs11-scd = "${EPEL_MIRROR}/aarch64/Packages/g/gnupg-pkcs11-scd-0.11.0-1.el10_2.aarch64.rpm;name=aarch64_gnupg-pkcs11-scd;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnupg-pkcs11-scd}"
SRC_URI[aarch64_gnupg-pkcs11-scd.sha256sum] = "ef6998fce112cf40e53abf98735ccd4ca928149a19c16b9ba20c5830cf93043b"

RDEPENDS:gnupg-pkcs11-scd = " \
 glibc \
 libassuan \
 libgcrypt \
 libgpg-error \
 openssl \
 openssl-libs \
 pkcs11-helper \
 "
