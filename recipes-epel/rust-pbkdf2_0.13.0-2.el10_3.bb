# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pbkdf2"
PV = "0.13.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-pbkdf2+alloc-devel \
 rust-pbkdf2+default-devel \
 rust-pbkdf2+getrandom-devel \
 rust-pbkdf2+hmac-devel \
 rust-pbkdf2+kdf-devel \
 rust-pbkdf2+mcf-devel \
 rust-pbkdf2+password-hash-devel \
 rust-pbkdf2+phc-devel \
 rust-pbkdf2+rand_core-devel \
 rust-pbkdf2+sha2-devel \
 rust-pbkdf2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pbkdf2-0.13.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "322d4dc65f6606af92b9fbeb1dd48eade1651d18d66f756945f2974d3d9d87f6"

URI_x86_64_v2_rust-pbkdf2+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+alloc-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+alloc-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+alloc-devel.sha256sum] = "e60307b6584998a609f832bd5919125366628e87c1f7176c831855c35e6395a5"

URI_x86_64_v2_rust-pbkdf2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+default-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+default-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+default-devel.sha256sum] = "a0719e2d2976b7201c53fedc44f14c9029871fd0b4ed2813a6d8eda009e3684e"

URI_x86_64_v2_rust-pbkdf2+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+getrandom-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+getrandom-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+getrandom-devel.sha256sum] = "c836d599fc642bbfa0a43fe5fc3714237b09879d7ebb9da7399574b5a2f344e8"

URI_x86_64_v2_rust-pbkdf2+hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+hmac-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+hmac-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+hmac-devel.sha256sum] = "7e7e605b6d255b293aebbb8cfed99fd6277086f9b184ca66e4db2bf05ea4f41c"

URI_x86_64_v2_rust-pbkdf2+kdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+kdf-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+kdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+kdf-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+kdf-devel.sha256sum] = "54a044002a915b5192aefff3741d81180d4db15a7bff8f31fadc518e613676df"

URI_x86_64_v2_rust-pbkdf2+mcf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+mcf-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+mcf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+mcf-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+mcf-devel.sha256sum] = "4139eb7b9c9d57f1f54071c136b3ac3e639e0c1511592f626138639f68098ea5"

URI_x86_64_v2_rust-pbkdf2+password-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+password-hash-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+password-hash-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+password-hash-devel.sha256sum] = "30820de7ab175119bd3f4604c80804d14db229e2bbd191539c70da3bb1cfb657"

URI_x86_64_v2_rust-pbkdf2+phc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+phc-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+phc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+phc-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+phc-devel.sha256sum] = "dc5eb6a12d6073efdd48aa48226d8674031cb3aeb12986f9742d843957a7c2eb"

URI_x86_64_v2_rust-pbkdf2+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+rand_core-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+rand_core-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+rand_core-devel.sha256sum] = "a9648324108845b9563cf45932265895e14ec50034fc1fe0b2522709162f8c6a"

URI_x86_64_v2_rust-pbkdf2+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+sha2-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+sha2-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+sha2-devel.sha256sum] = "57222f7c125cc2cc2f6fe7509dfe168b8501fa34852b11e8e63ae4dd5ee0fe76"

URI_x86_64_v2_rust-pbkdf2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2-devel.sha256sum] = "be6a8965618979825ca0a683f74e891d3eff3e6b6f85085be0cf3ff1c535c5ab"

URI_aarch64_rust-pbkdf2+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+alloc-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+alloc-devel}"
SRC_URI[aarch64_rust-pbkdf2+alloc-devel.sha256sum] = "1f2ff1285dbc314348fe2ced150055472b4d7e46b741c3def70dfcab7e05b501"

URI_aarch64_rust-pbkdf2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+default-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+default-devel}"
SRC_URI[aarch64_rust-pbkdf2+default-devel.sha256sum] = "87da68dc9b0f7042a2a8bc97cf99a5035a008c716585f7564e2cf0243fc6257b"

URI_aarch64_rust-pbkdf2+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+getrandom-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+getrandom-devel}"
SRC_URI[aarch64_rust-pbkdf2+getrandom-devel.sha256sum] = "db928b8d6075c57d36fa7f5395740d0cb4a2ec0496f871c0beb6ef81915872d3"

URI_aarch64_rust-pbkdf2+hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+hmac-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+hmac-devel}"
SRC_URI[aarch64_rust-pbkdf2+hmac-devel.sha256sum] = "9e34c452321cb6440dcf8898c54c7ab40f1a0dd49eadf0eed8e834f219abd4c9"

URI_aarch64_rust-pbkdf2+kdf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+kdf-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2+kdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+kdf-devel}"
SRC_URI[aarch64_rust-pbkdf2+kdf-devel.sha256sum] = "602a78771b370d08d8f3b2f5de34478f7d293f2f0f7b1cf9e3f3050181aefe4a"

URI_aarch64_rust-pbkdf2+mcf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+mcf-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2+mcf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+mcf-devel}"
SRC_URI[aarch64_rust-pbkdf2+mcf-devel.sha256sum] = "eff12b663c2febe3811ae04004fa53494b5017bcf7330e9e0e5552efb7a80a0f"

URI_aarch64_rust-pbkdf2+password-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+password-hash-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+password-hash-devel}"
SRC_URI[aarch64_rust-pbkdf2+password-hash-devel.sha256sum] = "a8f6b8ea79a0be81ddf530e32be2a1bf606fd603c2b1f8e074cfa8af9198ba09"

URI_aarch64_rust-pbkdf2+phc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+phc-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2+phc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+phc-devel}"
SRC_URI[aarch64_rust-pbkdf2+phc-devel.sha256sum] = "95116b7217fac1f306f555a04f9f91f00ce6f6014c63343e1b8ac7d0d93b8aaa"

URI_aarch64_rust-pbkdf2+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+rand_core-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+rand_core-devel}"
SRC_URI[aarch64_rust-pbkdf2+rand_core-devel.sha256sum] = "c66655b95f92b43f99868add44eb0cd29ae48491fa9978586707f1f15d335f60"

URI_aarch64_rust-pbkdf2+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+sha2-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+sha2-devel}"
SRC_URI[aarch64_rust-pbkdf2+sha2-devel.sha256sum] = "d5606dc12649a3439209f3024176e7e9a615e368ca4970c085a15a12d3c1376c"

URI_aarch64_rust-pbkdf2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2-devel}"
SRC_URI[aarch64_rust-pbkdf2-devel.sha256sum] = "27227b430ed41496033ae9e5044dcf12ff5261e4dfccd0cdac00914165fe6ca3"

RDEPENDS:rust-pbkdf2+alloc-devel = " \
 cargo \
 rust-mcf+alloc-devel \
 rust-mcf+base64-devel \
 rust-mcf-devel \
 rust-password-hash+alloc-devel \
 rust-password-hash-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+default-devel = " \
 cargo \
 rust-pbkdf2+hmac-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+getrandom-devel = " \
 cargo \
 rust-password-hash+getrandom-devel \
 rust-password-hash-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+hmac-devel = " \
 cargo \
 rust-hmac-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+kdf-devel = " \
 cargo \
 rust-kdf+default-devel \
 rust-pbkdf2+sha2-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+mcf-devel = " \
 cargo \
 rust-mcf+base64-devel \
 rust-mcf-devel \
 rust-pbkdf2+password-hash-devel \
 rust-pbkdf2+sha2-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+password-hash-devel = " \
 cargo \
 rust-password-hash-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+phc-devel = " \
 cargo \
 rust-password-hash+phc-devel \
 rust-password-hash-devel \
 rust-pbkdf2+sha2-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+rand_core-devel = " \
 cargo \
 rust-password-hash+rand_core-devel \
 rust-password-hash-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+sha2-devel = " \
 cargo \
 rust-pbkdf2+hmac-devel \
 rust-pbkdf2-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-pbkdf2-devel = " \
 cargo \
 rust \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
