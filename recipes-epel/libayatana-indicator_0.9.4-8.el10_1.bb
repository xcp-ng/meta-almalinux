# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libayatana-indicator"
PV = "0.9.4"
PR = "8.el10_1"
PACKAGES = " \
 libayatana-indicator-gtk3 \
 libayatana-indicator-gtk3-devel \
 libayatana-indicator-tools-gtk3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libayatana-indicator-0.9.4-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac38d56ed4556e53dae814452b8051f39dd2da18f72809b4b110b86e3eff8f27"

URI_x86_64_v2_libayatana-indicator-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-indicator-gtk3-0.9.4-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-indicator-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-indicator-gtk3}"
SRC_URI[x86_64_v2_libayatana-indicator-gtk3.sha256sum] = "2e839053250d529a246353a16652824dc2bbfcacd538c53f6dc53613054606c4"

URI_x86_64_v2_libayatana-indicator-gtk3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-indicator-gtk3-devel-0.9.4-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-indicator-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-indicator-gtk3-devel}"
SRC_URI[x86_64_v2_libayatana-indicator-gtk3-devel.sha256sum] = "d007dad6f5c7bde8b58f4a006ee4066682a7e1239c6386267936d114fc824759"

URI_x86_64_v2_libayatana-indicator-tools-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-indicator-tools-gtk3-0.9.4-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-indicator-tools-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-indicator-tools-gtk3}"
SRC_URI[x86_64_v2_libayatana-indicator-tools-gtk3.sha256sum] = "c1974205a858704851a5b909316177387db8442f0f10569c1b2d2a94052d52a9"

URI_aarch64_libayatana-indicator-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-indicator-gtk3-0.9.4-8.el10_1.aarch64.rpm;name=aarch64_libayatana-indicator-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-indicator-gtk3}"
SRC_URI[aarch64_libayatana-indicator-gtk3.sha256sum] = "95fc950da9db7dddd5273ab1340a62f0eaabd0c5e85065c7ce2459b5e8cdb596"

URI_aarch64_libayatana-indicator-gtk3-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-indicator-gtk3-devel-0.9.4-8.el10_1.aarch64.rpm;name=aarch64_libayatana-indicator-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-indicator-gtk3-devel}"
SRC_URI[aarch64_libayatana-indicator-gtk3-devel.sha256sum] = "495505f18f007f995dcfa5995c7743ab1319998b6844e1ec9c60d98878172a83"

URI_aarch64_libayatana-indicator-tools-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-indicator-tools-gtk3-0.9.4-8.el10_1.aarch64.rpm;name=aarch64_libayatana-indicator-tools-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-indicator-tools-gtk3}"
SRC_URI[aarch64_libayatana-indicator-tools-gtk3.sha256sum] = "d83bd1d0d833222f90c5d453df7db1bc2b37c1a36e77f331aca79d82b6c1c0c5"

RDEPENDS:libayatana-indicator-gtk3 = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libayatana-ido-gtk3 \
 "
RDEPENDS:libayatana-indicator-gtk3-devel = " \
 gtk3-devel \
 libayatana-ido-gtk3-devel \
 libayatana-indicator-gtk3 \
 pkgconf-pkg-config \
 "
RDEPENDS:libayatana-indicator-tools-gtk3 = " \
 libayatana-indicator-gtk3 \
 "
