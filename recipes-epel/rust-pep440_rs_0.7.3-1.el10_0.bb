# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pep440_rs"
PV = "0.7.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-pep440_rs+default-devel \
 rust-pep440_rs+rkyv-devel \
 rust-pep440_rs+tracing-devel \
 rust-pep440_rs+version-ranges-devel \
 rust-pep440_rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pep440_rs-0.7.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "322c9ad222583ee55f71433cd19190d597bdb6bd8be6a4a86d5102870cdd2af5"

URI_x86_64_v2_rust-pep440_rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep440_rs+default-devel-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep440_rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep440_rs+default-devel}"
SRC_URI[x86_64_v2_rust-pep440_rs+default-devel.sha256sum] = "997a37f75de7a2874fa4af0a6ae52113d1df5a0a09ff8a1ee80a1190d7c15b4c"

URI_x86_64_v2_rust-pep440_rs+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep440_rs+rkyv-devel-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep440_rs+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep440_rs+rkyv-devel}"
SRC_URI[x86_64_v2_rust-pep440_rs+rkyv-devel.sha256sum] = "f3edc6fe124c15f1f56d1de404da08b17d4ec3884dc9de7db5eef03171fe1c2e"

URI_x86_64_v2_rust-pep440_rs+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep440_rs+tracing-devel-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep440_rs+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep440_rs+tracing-devel}"
SRC_URI[x86_64_v2_rust-pep440_rs+tracing-devel.sha256sum] = "0a4c93a61d0d509edf79ec6bdc7de84440e83c2ee0e407627e9ab7fa941217fe"

URI_x86_64_v2_rust-pep440_rs+version-ranges-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep440_rs+version-ranges-devel-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep440_rs+version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep440_rs+version-ranges-devel}"
SRC_URI[x86_64_v2_rust-pep440_rs+version-ranges-devel.sha256sum] = "f005d2d01d4dacbca6d340a9cd6180213156c2281268ad9d5df583526ffe2304"

URI_x86_64_v2_rust-pep440_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep440_rs-devel-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep440_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep440_rs-devel}"
SRC_URI[x86_64_v2_rust-pep440_rs-devel.sha256sum] = "a67173ee6a305d4028947b17c6f118069a065f80479efc491e0fc9beda93b260"

URI_aarch64_rust-pep440_rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep440_rs+default-devel-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-pep440_rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep440_rs+default-devel}"
SRC_URI[aarch64_rust-pep440_rs+default-devel.sha256sum] = "4f0886f41d64a1e10d98c73989182e0287d36e7970e3cc8297f4f6498a403c4b"

URI_aarch64_rust-pep440_rs+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep440_rs+rkyv-devel-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-pep440_rs+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep440_rs+rkyv-devel}"
SRC_URI[aarch64_rust-pep440_rs+rkyv-devel.sha256sum] = "e75473a39d58dea2cce1011adbcc15033eb87f3cc8ee73f3b3d3610b713c2c88"

URI_aarch64_rust-pep440_rs+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep440_rs+tracing-devel-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-pep440_rs+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep440_rs+tracing-devel}"
SRC_URI[aarch64_rust-pep440_rs+tracing-devel.sha256sum] = "a64ef857e15739d5f713145b1dca5388ad118664d62d122b4bb6559a718d821c"

URI_aarch64_rust-pep440_rs+version-ranges-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep440_rs+version-ranges-devel-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-pep440_rs+version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep440_rs+version-ranges-devel}"
SRC_URI[aarch64_rust-pep440_rs+version-ranges-devel.sha256sum] = "50ef13b05a5118b48b0597f220b10c5e8baf7eb41078b730753eb23f2752e816"

URI_aarch64_rust-pep440_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep440_rs-devel-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-pep440_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep440_rs-devel}"
SRC_URI[aarch64_rust-pep440_rs-devel.sha256sum] = "6d33f8c0fc7f7e5148456475a5ed32948c07ac5c8564e12a45e52a3b296bf628"

RDEPENDS:rust-pep440_rs+default-devel = " \
 cargo \
 rust-pep440_rs-devel \
 "
RDEPENDS:rust-pep440_rs+rkyv-devel = " \
 cargo \
 rust-pep440_rs-devel \
 rust-rkyv+default-devel \
 "
RDEPENDS:rust-pep440_rs+tracing-devel = " \
 cargo \
 rust-pep440_rs-devel \
 rust-tracing+default-devel \
 "
RDEPENDS:rust-pep440_rs+version-ranges-devel = " \
 cargo \
 rust-pep440_rs-devel \
 rust-version-ranges+default-devel \
 "
RDEPENDS:rust-pep440_rs-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-unicode-width+default-devel \
 rust-unscanny+default-devel \
 "
