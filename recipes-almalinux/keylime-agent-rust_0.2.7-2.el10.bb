# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keylime-agent-rust"
PV = "0.2.7"
PR = "2.el10"
PACKAGES = " \
 keylime-agent-rust \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/keylime-agent-rust-0.2.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ba04a8d91764a7544c40ee91d73af8a7e7f3a4a7ff9a27f7532e5a1bdb90d5e"

URI_x86_64_v2_keylime-agent-rust = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-0.2.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-agent-rust;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-agent-rust}"
SRC_URI[x86_64_v2_keylime-agent-rust.sha256sum] = "b97894eddf37e31948aa17a20a7c61983d8fe2040fb8e894c77b50e83a7d43a7"

URI_aarch64_keylime-agent-rust = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-agent-rust-0.2.7-2.el10.aarch64.rpm;name=aarch64_keylime-agent-rust;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-agent-rust}"
SRC_URI[aarch64_keylime-agent-rust.sha256sum] = "f7b5c877c29343cf77c28ea6c5657a8a59cc60c5d2de5802d78eab348e9a7e32"

RDEPENDS:keylime-agent-rust = " \
 bash \
 glibc \
 keylime-base \
 libgcc \
 openssl-libs \
 tpm2-tss \
 util-linux-core \
 "
