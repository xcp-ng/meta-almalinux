# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "discount"
PV = "2.2.7"
PR = "9.el10_0"
PACKAGES = " \
 discount \
 libmarkdown \
 libmarkdown-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/discount-2.2.7-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53b0ff0786ba2606db6d986afeabbb0d0d55c5cbe491fd65f1dfd83e832ac98d"

URI_x86_64_v2_discount = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/discount-2.2.7-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_discount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_discount}"
SRC_URI[x86_64_v2_discount.sha256sum] = "f13dff385a5a238007eb7fa3f36d238b05e320e6e141a16826900ab9a900a0c4"

URI_x86_64_v2_libmarkdown = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmarkdown-2.2.7-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmarkdown;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmarkdown}"
SRC_URI[x86_64_v2_libmarkdown.sha256sum] = "acc5fd45411d3aa1b2a76a7a4fc951242ae72af3574e6a6af0130f427d976ab3"

URI_x86_64_v2_libmarkdown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmarkdown-devel-2.2.7-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmarkdown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmarkdown-devel}"
SRC_URI[x86_64_v2_libmarkdown-devel.sha256sum] = "6c6e4df1b8b3c0f8e384f9d8407f4cc79d4f0b6133bce22c70fa800aad3faa42"

URI_aarch64_discount = "${EPEL_MIRROR}/aarch64/Packages/d/discount-2.2.7-9.el10_0.aarch64.rpm;name=aarch64_discount;unpack=0"
SRC_URI:append = " ${URI_aarch64_discount}"
SRC_URI[aarch64_discount.sha256sum] = "d6e5c2a0346a8427f66c1b655d2e558cf1c5ea0b908a1e0371d946a0bc8bef57"

URI_aarch64_libmarkdown = "${EPEL_MIRROR}/aarch64/Packages/l/libmarkdown-2.2.7-9.el10_0.aarch64.rpm;name=aarch64_libmarkdown;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmarkdown}"
SRC_URI[aarch64_libmarkdown.sha256sum] = "6ab989bddd60416852e71e93cb29b9ccd8a3ecd5cc1d32addfb52b2b558bb406"

URI_aarch64_libmarkdown-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmarkdown-devel-2.2.7-9.el10_0.aarch64.rpm;name=aarch64_libmarkdown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmarkdown-devel}"
SRC_URI[aarch64_libmarkdown-devel.sha256sum] = "d14084237f6fe21f4ce31218bf60505233136508f8f2347e4d25e44647622992"

RDEPENDS:discount = " \
 glibc \
 libmarkdown \
 "
RDEPENDS:libmarkdown = " \
 glibc \
 "
RDEPENDS:libmarkdown-devel = " \
 libmarkdown \
 pkgconf-pkg-config \
 "
