# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tokodon"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 tokodon \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tokodon-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f15d7cdfeb1955817d96313c42aab03cc52ae11f71e40b66bed505218fa83353"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tokodon-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tokodon;unpack=0"
SRC_URI[x86_64_v2_tokodon.sha256sum] = "f07d2e029d78678ded8e9ed066211e01f59b0d739f88a85d051f9f7e49c5858f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tokodon-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_tokodon;unpack=0"
SRC_URI[aarch64_tokodon.sha256sum] = "42d663c6a34599d71453fbdd3e9021ac4f79f23c9a33848adb1eee3f438d8b62"

RDEPENDS:tokodon = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-purpose \
 kf6-sonnet \
 kunifiedpush \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 qt6-qtwebview \
 qtkeychain-qt6 \
 "
