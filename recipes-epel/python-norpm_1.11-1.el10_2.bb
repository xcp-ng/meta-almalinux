# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-norpm"
PV = "1.11"
PR = "1.el10_2"
PACKAGES = " \
 python3-norpm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-norpm-1.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "103b42dcded212b7ed4106d45117f782aef1594e322b99f8f4c5dbd7c565c706"

URI_x86_64_v2_python3-norpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-norpm-1.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-norpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-norpm}"
SRC_URI[x86_64_v2_python3-norpm.sha256sum] = "e5e274f69742f97d396708338f90e66604df297e6c50a664aece126938273ce4"

URI_aarch64_python3-norpm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-norpm-1.11-1.el10_2.noarch.rpm;name=aarch64_python3-norpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-norpm}"
SRC_URI[aarch64_python3-norpm.sha256sum] = "f7b6b1882b8ced353be07dc6bdc2677bcc689b4203c3f0e96ba6fb1e4f397be2"

RDEPENDS:python3-norpm = " \
 python3 \
 python3-lark \
 "
