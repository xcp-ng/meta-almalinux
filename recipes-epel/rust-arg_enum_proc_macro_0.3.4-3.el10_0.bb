# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arg_enum_proc_macro"
PV = "0.3.4"
PR = "3.el10_0"
PACKAGES = " \
 rust-arg_enum_proc_macro+default-devel \
 rust-arg_enum_proc_macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arg_enum_proc_macro-0.3.4-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eadcd85091767d2c167a4a2b488c42e459b7e2242d53405da73e7dd40fe62884"

URI_x86_64_v2_rust-arg_enum_proc_macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arg_enum_proc_macro+default-devel-0.3.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arg_enum_proc_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arg_enum_proc_macro+default-devel}"
SRC_URI[x86_64_v2_rust-arg_enum_proc_macro+default-devel.sha256sum] = "5ccaa278a8896bbcc2173d087799ba5911c37db09ec60296feef920686b5b497"

URI_x86_64_v2_rust-arg_enum_proc_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arg_enum_proc_macro-devel-0.3.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arg_enum_proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arg_enum_proc_macro-devel}"
SRC_URI[x86_64_v2_rust-arg_enum_proc_macro-devel.sha256sum] = "557b0c64864f448f54aa5c50b1e736332510a94433efb409da44e322ca5d17a6"

URI_aarch64_rust-arg_enum_proc_macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arg_enum_proc_macro+default-devel-0.3.4-3.el10_0.noarch.rpm;name=aarch64_rust-arg_enum_proc_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arg_enum_proc_macro+default-devel}"
SRC_URI[aarch64_rust-arg_enum_proc_macro+default-devel.sha256sum] = "334c7def4989efcb09d8b5e406c15641246a8657fb8205e9bc53843419db4729"

URI_aarch64_rust-arg_enum_proc_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arg_enum_proc_macro-devel-0.3.4-3.el10_0.noarch.rpm;name=aarch64_rust-arg_enum_proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arg_enum_proc_macro-devel}"
SRC_URI[aarch64_rust-arg_enum_proc_macro-devel.sha256sum] = "89816288fbf8ca92980e690e8a1daec21b278d7188d775f0a048c630f099a6c1"

RDEPENDS:rust-arg_enum_proc_macro+default-devel = " \
 cargo \
 rust-arg_enum_proc_macro-devel \
 "
RDEPENDS:rust-arg_enum_proc_macro-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 "
