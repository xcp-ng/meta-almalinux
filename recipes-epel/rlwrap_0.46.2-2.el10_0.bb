# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rlwrap"
PV = "0.46.2"
PR = "2.el10_0"
PACKAGES = " \
 rlwrap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rlwrap-0.46.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96d1f8158b33ae736be0779bd862fa39589bc53ee74e57bea8955010fd580395"

URI_x86_64_v2_rlwrap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rlwrap-0.46.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rlwrap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rlwrap}"
SRC_URI[x86_64_v2_rlwrap.sha256sum] = "29b61351b06f8188f9d2dd90679a6e90c6130c56871899980c6d9a743cb46bbd"

URI_aarch64_rlwrap = "${EPEL_MIRROR}/aarch64/Packages/r/rlwrap-0.46.2-2.el10_0.aarch64.rpm;name=aarch64_rlwrap;unpack=0"
SRC_URI:append = " ${URI_aarch64_rlwrap}"
SRC_URI[aarch64_rlwrap.sha256sum] = "114571ed2880d93cfb7cb364cf7c266880aef427f61f97e2dafeb22db9adc1d7"

RDEPENDS:rlwrap = " \
 glibc \
 ncurses-libs \
 perl-AutoLoader \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Slurp \
 perl-Getopt-Std \
 perl-POSIX \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 python3 \
 readline \
 rlwrap \
 "
