# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-streebog"
PV = "0.10.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-streebog+default-devel \
 rust-streebog+oid-devel \
 rust-streebog+std-devel \
 rust-streebog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-streebog-0.10.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc26aaddaceb9f5add3f20d51b54dad7267def9db604da1d05423973e0aeca4c"

URI_x86_64_v2_rust-streebog+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streebog+default-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streebog+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streebog+default-devel}"
SRC_URI[x86_64_v2_rust-streebog+default-devel.sha256sum] = "570b451d9ccd58e50356d17c8fb23617bfc7384fedd3f7242f5103381c6b80e6"

URI_x86_64_v2_rust-streebog+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streebog+oid-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streebog+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streebog+oid-devel}"
SRC_URI[x86_64_v2_rust-streebog+oid-devel.sha256sum] = "80605c375a0c9f78dec1e2a5864cae5432d24e178a921446920242bbf3135db7"

URI_x86_64_v2_rust-streebog+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streebog+std-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streebog+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streebog+std-devel}"
SRC_URI[x86_64_v2_rust-streebog+std-devel.sha256sum] = "b7b1aec18f49a4000b34d32c40e2a3326dbe98cd6b1b8ab40adc14c9f71d4429"

URI_x86_64_v2_rust-streebog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streebog-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streebog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streebog-devel}"
SRC_URI[x86_64_v2_rust-streebog-devel.sha256sum] = "a1bbdbf126ebfc843874be174b5d4cd4e14835b8f22b4c3291271c345d67d979"

URI_aarch64_rust-streebog+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streebog+default-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-streebog+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streebog+default-devel}"
SRC_URI[aarch64_rust-streebog+default-devel.sha256sum] = "d9af7769b742e871a9f365f906d2cb6c623568d8c341f4cfbb6183af6e2acf77"

URI_aarch64_rust-streebog+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streebog+oid-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-streebog+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streebog+oid-devel}"
SRC_URI[aarch64_rust-streebog+oid-devel.sha256sum] = "682356b11a899baba4e38245a267eab361daa0e94a83829372d15c5f50dbb4c3"

URI_aarch64_rust-streebog+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streebog+std-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-streebog+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streebog+std-devel}"
SRC_URI[aarch64_rust-streebog+std-devel.sha256sum] = "b260d4c6b1e2435996e7dc24d888e4602651ed0f29e8b0a215c06492b9a3145e"

URI_aarch64_rust-streebog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streebog-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-streebog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streebog-devel}"
SRC_URI[aarch64_rust-streebog-devel.sha256sum] = "beaeab6bdceb0a295a693fe607def47badea26b202c2a96d4b51b4f67678c95d"

RDEPENDS:rust-streebog+default-devel = " \
 cargo \
 rust-streebog+std-devel \
 rust-streebog-devel \
 "
RDEPENDS:rust-streebog+oid-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-streebog-devel \
 "
RDEPENDS:rust-streebog+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-streebog-devel \
 "
RDEPENDS:rust-streebog-devel = " \
 cargo \
 rust-digest+default-devel \
 "
