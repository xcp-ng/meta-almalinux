# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ref-cast-impl"
PV = "1.0.27"
PR = "1.el10_3"
PACKAGES = " \
 rust-ref-cast-impl+default-devel \
 rust-ref-cast-impl-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ref-cast-impl-1.0.27-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "997a6aca7a7e878c7539d751025bad6cc384438bc0cda51f0e73bbd34bfd4d8b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast-impl+default-devel-1.0.27-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast-impl+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ref-cast-impl+default-devel.sha256sum] = "bd99e8e32b687711c58f00267a6481c9b64d3eacff46cd910c7f0f18882a7552"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast-impl-devel-1.0.27-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast-impl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ref-cast-impl-devel.sha256sum] = "52740f5b5c4806c071f0eecacb81a543b400167cf9600c93602e4e0606f8c865"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast-impl+default-devel-1.0.27-1.el10_3.noarch.rpm;name=aarch64_rust-ref-cast-impl+default-devel;unpack=0"
SRC_URI[aarch64_rust-ref-cast-impl+default-devel.sha256sum] = "9747fd8cd9f22c0e8a4336bcb2ee76963f20ae792de878e7e40cd1eb77c674da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast-impl-devel-1.0.27-1.el10_3.noarch.rpm;name=aarch64_rust-ref-cast-impl-devel;unpack=0"
SRC_URI[aarch64_rust-ref-cast-impl-devel.sha256sum] = "2d932127ed00d85ee0e695bbb84c112ff01bab02e90f39ddf2aa0ecca9b4a453"

RDEPENDS:rust-ref-cast-impl+default-devel = " \
 cargo \
 rust-ref-cast-impl-devel \
 "
RDEPENDS:rust-ref-cast-impl-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
