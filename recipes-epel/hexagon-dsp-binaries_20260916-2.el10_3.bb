# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hexagon-dsp-binaries"
PV = "20260916"
PR = "2.el10_3"
PACKAGES = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-arduino-monza \
 hexagon-dsp-binaries-qualcomm-db410c \
 hexagon-dsp-binaries-qualcomm-db820c \
 hexagon-dsp-binaries-qualcomm-eliza-mtp \
 hexagon-dsp-binaries-qualcomm-glymur-crd \
 hexagon-dsp-binaries-qualcomm-hamoa-iot-evk \
 hexagon-dsp-binaries-qualcomm-iq8275-evk \
 hexagon-dsp-binaries-qualcomm-iq9075-evk \
 hexagon-dsp-binaries-qualcomm-kaanapali-mtp \
 hexagon-dsp-binaries-qualcomm-mahua-crd \
 hexagon-dsp-binaries-qualcomm-purwa-iot-evk \
 hexagon-dsp-binaries-qualcomm-qcm6490-idp \
 hexagon-dsp-binaries-qualcomm-qcs615-ride \
 hexagon-dsp-binaries-qualcomm-qcs8300-ride \
 hexagon-dsp-binaries-qualcomm-sa8775p-ride \
 hexagon-dsp-binaries-qualcomm-sdm845-hdk \
 hexagon-dsp-binaries-qualcomm-shikra-cqm-evk \
 hexagon-dsp-binaries-qualcomm-shikra-cqs-evk \
 hexagon-dsp-binaries-qualcomm-shikra-iqs-evk \
 hexagon-dsp-binaries-qualcomm-sm8750-mtp \
 hexagon-dsp-binaries-radxa-dragon-q6a \
 hexagon-dsp-binaries-thundercomm-db845c \
 hexagon-dsp-binaries-thundercomm-rb1 \
 hexagon-dsp-binaries-thundercomm-rb2 \
 hexagon-dsp-binaries-thundercomm-rb3gen2 \
 hexagon-dsp-binaries-thundercomm-rb5 \
 hexagon-dsp-binaries-thundercomm-rubikpi3 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/hexagon-dsp-binaries-20260916-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "772b6dc55fd5bd06fa75f04441383a43b3d75342231641283146e23af13c5ab7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries.sha256sum] = "9cfe2fc2ba976f22f51c6ac67754b3d481cdc9611709c787ad272cd51542b581"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-arduino-monza-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-arduino-monza;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-arduino-monza.sha256sum] = "533a94abb00ec4733024e942354a7bee3c644d82581ddd073250271ca8bca402"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-db410c-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-db410c;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-db410c.sha256sum] = "d9fc9a1fc4fc9ee19c12f94be25e0c0296a8fb7774dcf0ffedebbb5d41597809"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-db820c-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-db820c;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-db820c.sha256sum] = "7d819b99d08f3492a4015c4188ee501e0715204c7e59e1c9339c7c38fa458cfc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-eliza-mtp-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-eliza-mtp;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-eliza-mtp.sha256sum] = "c3a96d71e6f5070d258c48d9503dbbf5b7eb622e36279558d343f807c18149bd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-glymur-crd-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-glymur-crd;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-glymur-crd.sha256sum] = "ff093af920bf5556765b3672fe18c0b99c4af3c44441394576db0e2d97b547fd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-hamoa-iot-evk-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-hamoa-iot-evk;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-hamoa-iot-evk.sha256sum] = "1e059bba1b0d0f43eb934fb2e9b061215f25ece6eaf813497d88dcbe29e91615"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-iq8275-evk-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-iq8275-evk;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-iq8275-evk.sha256sum] = "70d97e61d2ad23aefc297e99967bb8066025d039573ca5ac3cd6b0355ce5f4fd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-iq9075-evk-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-iq9075-evk;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-iq9075-evk.sha256sum] = "17fcad317a135e85454d50023ef61f827c747ae2e0c4be7dc4029000c2db4eec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-kaanapali-mtp-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-kaanapali-mtp;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-kaanapali-mtp.sha256sum] = "425918f62d0ee95958e3243613ab0761469e11e57d439c0b1fc0631926737c0e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-mahua-crd-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-mahua-crd;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-mahua-crd.sha256sum] = "09a01842abb95fdbf048324a8e6d451681b35a37872060325b3603bcbb75d0db"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-purwa-iot-evk-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-purwa-iot-evk;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-purwa-iot-evk.sha256sum] = "2d9e0e0c0079c1368c6e99600be0252ad9ffe718b552bf58b4560d130cc400f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-qcm6490-idp-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-qcm6490-idp;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-qcm6490-idp.sha256sum] = "8010e9671a91a5aa69aecb8e060756a8ae93c86e002a050f915d007b2dc2698d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-qcs615-ride-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-qcs615-ride;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-qcs615-ride.sha256sum] = "43c7f3b00b54d825a21459a38152b5c73d234a3d6714d6187330027d5125685b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-qcs8300-ride-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-qcs8300-ride;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-qcs8300-ride.sha256sum] = "91f6f46bd9013bbae4f27872e8a57a86bb0573d1aafe4811e95dfbf7767704d5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-sa8775p-ride-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-sa8775p-ride;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-sa8775p-ride.sha256sum] = "395c66eb821920b9c31613b9893bbc229b3c0922adaff10b90793563ce2f6492"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-sdm845-hdk-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-sdm845-hdk;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-sdm845-hdk.sha256sum] = "4bd62851ff8e8e85cfe2f37f54574cecd9c8bffcb4b42182baa2c2521b58ee5e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-shikra-cqm-evk-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqm-evk;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqm-evk.sha256sum] = "76a3bca7a3265803c975f9fda960041dc395330ec7e353bc183ae7bb78eeb973"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-shikra-cqs-evk-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqs-evk;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqs-evk.sha256sum] = "093c17b1c7025f7b4b27984bad2baf024091d5beecff3e3bb58424583af16890"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-shikra-iqs-evk-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-shikra-iqs-evk;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-shikra-iqs-evk.sha256sum] = "c84b949d9a6a470bbf99179107634617107e0da872bb0ab960cfcc2554b824a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-sm8750-mtp-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-sm8750-mtp;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-sm8750-mtp.sha256sum] = "4b857b26c5742215d74af2bc88dcb9de2544171bd8e5f7df79884b98cc41bb1a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-radxa-dragon-q6a-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-radxa-dragon-q6a;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-radxa-dragon-q6a.sha256sum] = "e38cdd9b484b28cac0af8a31ee5cbe85e7a508211205034a4127b532ea076a37"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-db845c-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-db845c;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-db845c.sha256sum] = "9d10f964c673fe31755c387f73c27e15ee5d5489f31146145b1026c5a5c971f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rb1-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rb1;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rb1.sha256sum] = "0c9a9d0babf02a08eef3fdd2a47b8de9b8cc1b132d04a11b08629acec26b23ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rb2-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rb2;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rb2.sha256sum] = "0ee1e30740e4885dd42edb554dd92181beff5775c44c118e413d3bb728b17326"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rb3gen2-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rb3gen2;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rb3gen2.sha256sum] = "c967e83f7000463d4efd6ee04662b3f31e937b631dbe31f855095ed40b9e8b12"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rb5-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rb5;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rb5.sha256sum] = "d415c54581104093fe77050c2d106651f5e4ecbd5db07188602a80e916ae300e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rubikpi3-20260916-2.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rubikpi3;unpack=0"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rubikpi3.sha256sum] = "968f9bf9d9d0f0a9a4e5f0c6d9dededc77171f040c19ee286a0b43671fffd0b1"

RDEPENDS:hexagon-dsp-binaries = " \
 "
RDEPENDS:hexagon-dsp-binaries-arduino-monza = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-qcs8300-ride \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-db410c = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-db820c = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-eliza-mtp = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-glymur-crd = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-hamoa-iot-evk = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-iq8275-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-qcs8300-ride \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-iq9075-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-sa8775p-ride \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-kaanapali-mtp = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-mahua-crd = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-glymur-crd \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-purwa-iot-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-hamoa-iot-evk \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-qcm6490-idp = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-thundercomm-rb3gen2 \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-qcs615-ride = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-qcs8300-ride = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-sa8775p-ride = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-sdm845-hdk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-thundercomm-db845c \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-shikra-cqm-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-shikra-cqs-evk \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-shikra-cqs-evk = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-shikra-iqs-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-shikra-cqs-evk \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-sm8750-mtp = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-radxa-dragon-q6a = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-db845c = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rb1 = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rb2 = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rb3gen2 = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rb5 = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rubikpi3 = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-thundercomm-rb3gen2 \
 qcom-firmware \
 "
