# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-breeze"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 breeze-cursor-theme \
 plasma-breeze \
 plasma-breeze-common \
 plasma-breeze-qt6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-breeze-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb8b2c0e8e36e3db5f7efe1bd1f7c66c4520ed99039d7883a0e62c28defddd70"

URI_x86_64_v2_breeze-cursor-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-cursor-theme-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-cursor-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-cursor-theme}"
SRC_URI[x86_64_v2_breeze-cursor-theme.sha256sum] = "d777bb26b64dfd86c697e198fca11430eadfb465c2ede5dcf0441f585b86e6fa"

URI_x86_64_v2_plasma-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-breeze}"
SRC_URI[x86_64_v2_plasma-breeze.sha256sum] = "8a62b66854fff2b5068e43211b4c0a4d6b11d4d7a060a98d8d061db3ca470c7a"

URI_x86_64_v2_plasma-breeze-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-common-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-breeze-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-breeze-common}"
SRC_URI[x86_64_v2_plasma-breeze-common.sha256sum] = "c10fd0f0d2d64757f2e5603e588f44075425676e981ad4715fd44b4abc5d829b"

URI_x86_64_v2_plasma-breeze-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-qt6-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-breeze-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-breeze-qt6}"
SRC_URI[x86_64_v2_plasma-breeze-qt6.sha256sum] = "0f55d1c166334f6e44c1d85c6416f31e8f94a8c5ae0a6bc277cba8aa61a18d04"

URI_aarch64_breeze-cursor-theme = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-cursor-theme-6.3.6-1.el10_0.noarch.rpm;name=aarch64_breeze-cursor-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-cursor-theme}"
SRC_URI[aarch64_breeze-cursor-theme.sha256sum] = "5ab1f1fc8a0e1fc737092d057fd0e6b1dd07352d42da8dc0b6cff340902852a1"

URI_aarch64_plasma-breeze = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-breeze}"
SRC_URI[aarch64_plasma-breeze.sha256sum] = "99497b747edf9cbe97395ae0e31e576fc44ab58959f51e76e19a012843419d2f"

URI_aarch64_plasma-breeze-common = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-common-6.3.6-1.el10_0.noarch.rpm;name=aarch64_plasma-breeze-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-breeze-common}"
SRC_URI[aarch64_plasma-breeze-common.sha256sum] = "c77eb9a382b2f3c6bc007d3b56a04c7b01f3d45b01c29e28aeb1abd196f9f62b"

URI_aarch64_plasma-breeze-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-qt6-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-breeze-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-breeze-qt6}"
SRC_URI[aarch64_plasma-breeze-qt6.sha256sum] = "41ceb0b482426e478350a4fe722bd1093816c6311c718be8a0c5a302ac1093b7"

RDEPENDS:breeze-cursor-theme = " \
 "
RDEPENDS:plasma-breeze = " \
 cmake-filesystem \
 glibc \
 kdecoration \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 libstdc++ \
 plasma-breeze-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:plasma-breeze-common = " \
 "
RDEPENDS:plasma-breeze-qt6 = " \
 glibc \
 kf6-frameworkintegration-libs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-kwindowsystem \
 libstdc++ \
 plasma-breeze-common \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
