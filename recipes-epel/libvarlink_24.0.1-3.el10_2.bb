# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvarlink"
PV = "24.0.1"
PR = "3.el10_2"
PACKAGES = " \
 libvarlink \
 libvarlink-devel \
 libvarlink-util \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libvarlink-24.0.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24b5d34f0ea117e36c5ac43e92543897409226116d04cb825d4dc46ed44363de"

URI_x86_64_v2_libvarlink = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvarlink-24.0.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvarlink;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvarlink}"
SRC_URI[x86_64_v2_libvarlink.sha256sum] = "b3eb397107ca1e23e630b352b533890c53c3e0dd1066737dc80c43a30fb14726"

URI_x86_64_v2_libvarlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvarlink-devel-24.0.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvarlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvarlink-devel}"
SRC_URI[x86_64_v2_libvarlink-devel.sha256sum] = "ce0291421ab7399c67340ec617db30b090bef4db1dc3b62177872712b529baef"

URI_x86_64_v2_libvarlink-util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvarlink-util-24.0.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvarlink-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvarlink-util}"
SRC_URI[x86_64_v2_libvarlink-util.sha256sum] = "c2b99e60b4d64ff1a397f747bdee14029ce4925f51c641be50071180eb0c0301"

URI_aarch64_libvarlink = "${EPEL_MIRROR}/aarch64/Packages/l/libvarlink-24.0.1-3.el10_2.aarch64.rpm;name=aarch64_libvarlink;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvarlink}"
SRC_URI[aarch64_libvarlink.sha256sum] = "ea46f5f8aac61cc52f6fccd85d8d6d3fd62878259c13ac5a17bcfc0bbd30adc3"

URI_aarch64_libvarlink-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libvarlink-devel-24.0.1-3.el10_2.aarch64.rpm;name=aarch64_libvarlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvarlink-devel}"
SRC_URI[aarch64_libvarlink-devel.sha256sum] = "61b0e28708587fc4224c442e6ecb08254cf26d660687fd7baff9d7e6aabccaa7"

URI_aarch64_libvarlink-util = "${EPEL_MIRROR}/aarch64/Packages/l/libvarlink-util-24.0.1-3.el10_2.aarch64.rpm;name=aarch64_libvarlink-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvarlink-util}"
SRC_URI[aarch64_libvarlink-util.sha256sum] = "907aa95828c1da96c26d12afdb0e3916b574d59e00e0f71f81b1e8d911ba2773"

RDEPENDS:libvarlink = " \
 glibc \
 libgcc \
 "
RDEPENDS:libvarlink-devel = " \
 libvarlink \
 pkgconf-pkg-config \
 "
RDEPENDS:libvarlink-util = " \
 glibc \
 libgcc \
 "
