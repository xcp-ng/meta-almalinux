# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pycdio"
PV = "2.1.1"
PR = "2.el10"
PACKAGES = " \
 python3-pycdio \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-pycdio-2.1.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bff80e64be6db8ae5d02c50dd9e95f8628b2b0974d001b37532346704fd83da"

URI_x86_64_v2_python3-pycdio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pycdio-2.1.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pycdio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pycdio}"
SRC_URI[x86_64_v2_python3-pycdio.sha256sum] = "ab3d4b67ba9a5176fb0308f68e0c2e7424d6dee94857debcacd5517ed9ed2caf"

URI_aarch64_python3-pycdio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pycdio-2.1.1-2.el10.aarch64.rpm;name=aarch64_python3-pycdio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pycdio}"
SRC_URI[aarch64_python3-pycdio.sha256sum] = "32f62a1c54103811eacf9a56f90676d6a3b556e10ffe19563900ff19de03ec33"

RDEPENDS:python3-pycdio = " \
 glibc \
 libcdio \
 python3 \
 "
