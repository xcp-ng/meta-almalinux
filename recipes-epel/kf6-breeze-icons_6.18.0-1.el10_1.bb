# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-breeze-icons"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 breeze-icon-theme \
 breeze-icon-theme-rcc \
 kf6-breeze-icons \
 kf6-breeze-icons-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-breeze-icons-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "17da07a2f4602dba3b5310dd45cd4d6f75ba7d43faf3f3eb9f3dc0774173e6a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-icon-theme-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-icon-theme;unpack=0"
SRC_URI[x86_64_v2_breeze-icon-theme.sha256sum] = "2e56fa0429ee6fc2027a03c9c96050c8c73f76967cd3a58a422e766310dcefca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-icon-theme-rcc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-icon-theme-rcc;unpack=0"
SRC_URI[x86_64_v2_breeze-icon-theme-rcc.sha256sum] = "2f44dfb82cd8bdcc4eb70b2750e1ff574061176ed896575790ca47ff3b7aacff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-breeze-icons-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-breeze-icons;unpack=0"
SRC_URI[x86_64_v2_kf6-breeze-icons.sha256sum] = "f50859e85009ef000edb0e9ffe304810765c4879fd1d31b67e919ba3e95db53f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-breeze-icons-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-breeze-icons-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-breeze-icons-devel.sha256sum] = "368f8313da719ecae3bfc862e00c1f66750767364081a5d8d2c9d5dbe0f54259"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/breeze-icon-theme-6.18.0-1.el10_1.noarch.rpm;name=aarch64_breeze-icon-theme;unpack=0"
SRC_URI[aarch64_breeze-icon-theme.sha256sum] = "74a51acd5bf076750abc5d6eb977e663f4104c1d2032e8fccf9b7be063451092"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/breeze-icon-theme-rcc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_breeze-icon-theme-rcc;unpack=0"
SRC_URI[aarch64_breeze-icon-theme-rcc.sha256sum] = "f0084cac218af9bb8e67433cdf5d2ff10bbaa98c4d64a2297a767d2e24020398"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-breeze-icons-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-breeze-icons;unpack=0"
SRC_URI[aarch64_kf6-breeze-icons.sha256sum] = "2e8d631a5f613da450d4919d858a660fdc7c448ee5ab02e891eebfefcea3ee5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-breeze-icons-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-breeze-icons-devel;unpack=0"
SRC_URI[aarch64_kf6-breeze-icons-devel.sha256sum] = "974a1faf7e85f10833f31c297c095496c8b59fa15f78a356ba223122bd414ff2"

RDEPENDS:breeze-icon-theme = " \
 almalinux-logos \
 bash \
 hicolor-icon-theme \
 "
RDEPENDS:breeze-icon-theme-rcc = " \
 "
RDEPENDS:kf6-breeze-icons = " \
 breeze-icon-theme \
 glibc \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-breeze-icons-devel = " \
 cmake-filesystem \
 kf6-breeze-icons \
 "
