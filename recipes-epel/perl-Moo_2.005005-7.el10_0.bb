# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Moo"
PV = "2.005005"
PR = "7.el10_0"
PACKAGES = " \
 perl-Moo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Moo-2.005005-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bbf66b84264c360e1834fcc8cc677201646bc98cff771c28876d5dbf6e141de"

URI_x86_64_v2_perl-Moo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Moo-2.005005-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Moo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Moo}"
SRC_URI[x86_64_v2_perl-Moo.sha256sum] = "567b123838c2fbadfff323fc72da2c52a7219268befe97a8ec6534937acb8780"

URI_aarch64_perl-Moo = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Moo-2.005005-7.el10_0.noarch.rpm;name=aarch64_perl-Moo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Moo}"
SRC_URI[aarch64_perl-Moo.sha256sum] = "a1a719a026586f9a42b06731d568fd9a728abaffaa6e8811d724c663df3b3beb"

RDEPENDS:perl-Moo = " \
 perl-Carp \
 perl-Class-Method-Modifiers \
 perl-Devel-GlobalDestruction \
 perl-Exporter \
 perl-Import-Into \
 perl-Module-Runtime \
 perl-Role-Tiny \
 perl-Scalar-List-Utils \
 perl-Sub-Quote \
 perl-libs \
 perl-mro \
 "
