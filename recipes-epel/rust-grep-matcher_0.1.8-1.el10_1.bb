# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-matcher"
PV = "0.1.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-grep-matcher+default-devel \
 rust-grep-matcher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-matcher-0.1.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9af43f85caac17fd65bb019db85c6d5926d01d42b3f26c6ee680c38e9a8cb713"

URI_x86_64_v2_rust-grep-matcher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-matcher+default-devel-0.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-matcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-matcher+default-devel}"
SRC_URI[x86_64_v2_rust-grep-matcher+default-devel.sha256sum] = "10cf986b84f2b8ec2c247f36559ee8b7ce4e1c8651a78ee82cb298ca2c8cd955"

URI_x86_64_v2_rust-grep-matcher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-matcher-devel-0.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-matcher-devel}"
SRC_URI[x86_64_v2_rust-grep-matcher-devel.sha256sum] = "156a3bdb3b03782f5cd4ab4e2fa3f364a0b6807953bd02de5ae9c6ed865868db"

URI_aarch64_rust-grep-matcher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-matcher+default-devel-0.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-grep-matcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-matcher+default-devel}"
SRC_URI[aarch64_rust-grep-matcher+default-devel.sha256sum] = "b8b84e946112e9c8a1481d29241d7a447995faf964fe35783c9b4b080888d954"

URI_aarch64_rust-grep-matcher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-matcher-devel-0.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-grep-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-matcher-devel}"
SRC_URI[aarch64_rust-grep-matcher-devel.sha256sum] = "6520bc9072999fdf1ec042ca1898ce94dcad7fba3afb2a83b11bbfc0bf6a5067"

RDEPENDS:rust-grep-matcher+default-devel = " \
 cargo \
 rust-grep-matcher-devel \
 "
RDEPENDS:rust-grep-matcher-devel = " \
 cargo \
 rust-memchr+default-devel \
 "
