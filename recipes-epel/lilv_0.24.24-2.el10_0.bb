# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lilv"
PV = "0.24.24"
PR = "2.el10_0"
PACKAGES = " \
 lilv \
 lilv-devel \
 lilv-libs \
 python3-lilv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lilv-0.24.24-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb7dabf5b4a277e215b4931ae9d1ccd26dbc314f4469295ee01b1845a0072e18"

URI_x86_64_v2_lilv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lilv-0.24.24-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lilv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lilv}"
SRC_URI[x86_64_v2_lilv.sha256sum] = "2f2e10245d25fcb213f01bc5aa1409685fe5f92a92b09451057777c24b8ae0be"

URI_x86_64_v2_lilv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lilv-devel-0.24.24-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lilv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lilv-devel}"
SRC_URI[x86_64_v2_lilv-devel.sha256sum] = "568c794cf27b36559459e12dc6c2006679a271a4f92f4afbb5a4f4b1626b1b24"

URI_x86_64_v2_lilv-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lilv-libs-0.24.24-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lilv-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lilv-libs}"
SRC_URI[x86_64_v2_lilv-libs.sha256sum] = "be6252c8e0bf5d9b4aa57a5bde7bd8f22c7d884999e9f8f741bb5b439bb55c25"

URI_x86_64_v2_python3-lilv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lilv-0.24.24-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lilv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lilv}"
SRC_URI[x86_64_v2_python3-lilv.sha256sum] = "73800657b33cf266766f2b66bd1e71dc084e424c91da87a572dcbad041bcc473"

URI_aarch64_lilv = "${EPEL_MIRROR}/aarch64/Packages/l/lilv-0.24.24-2.el10_0.aarch64.rpm;name=aarch64_lilv;unpack=0"
SRC_URI:append = " ${URI_aarch64_lilv}"
SRC_URI[aarch64_lilv.sha256sum] = "b297b54589a51e341c9057bdba387f88dbcb02583513f528c2c8748a2f479803"

URI_aarch64_lilv-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lilv-devel-0.24.24-2.el10_0.aarch64.rpm;name=aarch64_lilv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lilv-devel}"
SRC_URI[aarch64_lilv-devel.sha256sum] = "be507f582f6cd33c290c2f6edf3e8e7cc5cf6be691b3b89f23d5ea3c7cbf7f69"

URI_aarch64_lilv-libs = "${EPEL_MIRROR}/aarch64/Packages/l/lilv-libs-0.24.24-2.el10_0.aarch64.rpm;name=aarch64_lilv-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lilv-libs}"
SRC_URI[aarch64_lilv-libs.sha256sum] = "71a7e8e2d2d09e4cf77c637ffe9768e16059c9836601e00b65436970f9c7f42e"

URI_aarch64_python3-lilv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lilv-0.24.24-2.el10_0.aarch64.rpm;name=aarch64_python3-lilv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lilv}"
SRC_URI[aarch64_python3-lilv.sha256sum] = "02df373e2c5b270d20994a82847002d55c03983f1c711748da238f92ab32f66f"

RDEPENDS:lilv = " \
 glibc \
 libsndfile \
 lilv-libs \
 lv2 \
 "
RDEPENDS:lilv-devel = " \
 lilv-libs \
 lv2-devel \
 pkgconf-pkg-config \
 serd-devel \
 sord-devel \
 sratom-devel \
 zix-devel \
 "
RDEPENDS:lilv-libs = " \
 glibc \
 serd \
 sord \
 sratom \
 zix \
 "
RDEPENDS:python3-lilv = " \
 lilv-libs \
 python3 \
 "
