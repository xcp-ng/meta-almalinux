# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dracut"
PV = "107"
PR = "3.el10"
PACKAGES = " \
 dracut \
 dracut-caps \
 dracut-config-generic \
 dracut-config-rescue \
 dracut-live \
 dracut-network \
 dracut-squash \
 dracut-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dracut-107-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58a85a63127ae7d3879c753f57719ec1e60ee741c81945ec443ab43c9cdca8a6"

URI_x86_64_v2_dracut = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-107-3.el10.x86_64_v2.rpm;name=x86_64_v2_dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut}"
SRC_URI[x86_64_v2_dracut.sha256sum] = "16089c4fdfbd059832f9e2daf0735a916ad9066797c09b3f9029551329f0a56e"

URI_x86_64_v2_dracut-caps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dracut-caps-107-3.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-caps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-caps}"
SRC_URI[x86_64_v2_dracut-caps.sha256sum] = "9c42df4351f2399a6a1f02a14ba74a67c3761fa3f555be7d7ae23cf1673d42cd"

URI_x86_64_v2_dracut-config-generic = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-config-generic-107-3.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-config-generic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-config-generic}"
SRC_URI[x86_64_v2_dracut-config-generic.sha256sum] = "51c198479759d2009cfb4c0626cfae0e84127908ff50a7a65318933b8fe3af19"

URI_x86_64_v2_dracut-config-rescue = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-config-rescue-107-3.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-config-rescue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-config-rescue}"
SRC_URI[x86_64_v2_dracut-config-rescue.sha256sum] = "c26da1867588b21c5aa55549e5775169370c0e718cc6580db180217d42acc27c"

URI_x86_64_v2_dracut-live = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dracut-live-107-3.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-live;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-live}"
SRC_URI[x86_64_v2_dracut-live.sha256sum] = "e50d17f1c4859c82517dbee83815ef9d6364ba888b4634d9b5e6af4f23f97547"

URI_x86_64_v2_dracut-network = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-network-107-3.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-network;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-network}"
SRC_URI[x86_64_v2_dracut-network.sha256sum] = "7f8002f6e87f6215ba53c1944e36960d9341dfd035a18818652415925fa5b246"

URI_x86_64_v2_dracut-squash = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-squash-107-3.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-squash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-squash}"
SRC_URI[x86_64_v2_dracut-squash.sha256sum] = "d786a6b2d3e0bcf0f3075ef669e64e63eb636fb39695d9659f7175c5e6d5419d"

URI_x86_64_v2_dracut-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-tools-107-3.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-tools}"
SRC_URI[x86_64_v2_dracut-tools.sha256sum] = "e8faa675b20df0d04510484e595954dc39f054f5d3664f59fdcfa99c486b8efd"

URI_aarch64_dracut = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-107-3.el10.aarch64.rpm;name=aarch64_dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut}"
SRC_URI[aarch64_dracut.sha256sum] = "115e711ffd0ac5cf50416ab7b33446c6561fb9665c61067e0129b9cea6fc0f37"

URI_aarch64_dracut-caps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dracut-caps-107-3.el10.aarch64.rpm;name=aarch64_dracut-caps;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-caps}"
SRC_URI[aarch64_dracut-caps.sha256sum] = "baffa2d66e9e2b964a34608a84a7bad99f0e5d3af6370102874440616da14ff1"

URI_aarch64_dracut-config-generic = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-config-generic-107-3.el10.aarch64.rpm;name=aarch64_dracut-config-generic;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-config-generic}"
SRC_URI[aarch64_dracut-config-generic.sha256sum] = "1605d053712407665268825760a964bf981e890d7055b98c30ce59e8bc637c2c"

URI_aarch64_dracut-config-rescue = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-config-rescue-107-3.el10.aarch64.rpm;name=aarch64_dracut-config-rescue;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-config-rescue}"
SRC_URI[aarch64_dracut-config-rescue.sha256sum] = "6716c94f3b747abd316835e66297d83bcba4f065ba6f70d93b30fc14523165d4"

URI_aarch64_dracut-live = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dracut-live-107-3.el10.aarch64.rpm;name=aarch64_dracut-live;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-live}"
SRC_URI[aarch64_dracut-live.sha256sum] = "172c54d7499d465d235efd49a7c84caa7c9c8e001a9d53d0c9848d9de193d589"

URI_aarch64_dracut-network = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-network-107-3.el10.aarch64.rpm;name=aarch64_dracut-network;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-network}"
SRC_URI[aarch64_dracut-network.sha256sum] = "9e85d525a4f06e52d9ad0b66d43164c7ee44d13927460c66ea46cb6db58fc44c"

URI_aarch64_dracut-squash = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-squash-107-3.el10.aarch64.rpm;name=aarch64_dracut-squash;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-squash}"
SRC_URI[aarch64_dracut-squash.sha256sum] = "04e91732a8abfc96f199ceefb04cbfa9ebf7055a55969dd8921a7d124945df47"

URI_aarch64_dracut-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-tools-107-3.el10.aarch64.rpm;name=aarch64_dracut-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-tools}"
SRC_URI[aarch64_dracut-tools.sha256sum] = "604d033bc4a923abd013cc66f0597d68bdff0e563146ac8da897661d74bfb6f4"

RDEPENDS:dracut = " \
 bash \
 cpio \
 filesystem \
 findutils \
 glibc \
 grep \
 gzip \
 kmod \
 kmod-libs \
 libgcc \
 libkcapi-hmaccalc \
 openssl-libs \
 procps-ng \
 sed \
 systemd \
 systemd-udev \
 util-linux \
 virtual/coreutils \
 xz \
 "
RDEPENDS:dracut-caps = " \
 bash \
 dracut \
 libcap \
 "
RDEPENDS:dracut-config-generic = " \
 dracut \
 "
RDEPENDS:dracut-config-rescue = " \
 bash \
 dracut \
 "
RDEPENDS:dracut-live = " \
 bash \
 curl \
 device-mapper \
 dracut \
 dracut-network \
 gzip \
 parted \
 tar \
 virtual/coreutils \
 "
RDEPENDS:dracut-network = " \
 NetworkManager \
 bash \
 dracut \
 iproute \
 iputils \
 jq \
 "
RDEPENDS:dracut-squash = " \
 bash \
 dracut \
 erofs-utils \
 "
RDEPENDS:dracut-tools = " \
 bash \
 dracut \
 "
