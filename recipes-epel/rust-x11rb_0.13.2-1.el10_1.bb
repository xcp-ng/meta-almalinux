# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-x11rb"
PV = "0.13.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-x11rb+all-extensions-devel \
 rust-x11rb+allow-unsafe-code-devel \
 rust-x11rb+as-raw-xcb-connection-devel \
 rust-x11rb+composite-devel \
 rust-x11rb+cursor-devel \
 rust-x11rb+damage-devel \
 rust-x11rb+dbe-devel \
 rust-x11rb+default-devel \
 rust-x11rb+dl-libxcb-devel \
 rust-x11rb+dpms-devel \
 rust-x11rb+dri2-devel \
 rust-x11rb+dri3-devel \
 rust-x11rb+extra-traits-devel \
 rust-x11rb+glx-devel \
 rust-x11rb+image-devel \
 rust-x11rb+libc-devel \
 rust-x11rb+libloading-devel \
 rust-x11rb+once_cell-devel \
 rust-x11rb+present-devel \
 rust-x11rb+randr-devel \
 rust-x11rb+raw-window-handle-devel \
 rust-x11rb+record-devel \
 rust-x11rb+render-devel \
 rust-x11rb+request-parsing-devel \
 rust-x11rb+res-devel \
 rust-x11rb+resource_manager-devel \
 rust-x11rb+screensaver-devel \
 rust-x11rb+shape-devel \
 rust-x11rb+shm-devel \
 rust-x11rb+sync-devel \
 rust-x11rb+tracing-devel \
 rust-x11rb+xcursor-devel \
 rust-x11rb+xevie-devel \
 rust-x11rb+xf86dri-devel \
 rust-x11rb+xf86vidmode-devel \
 rust-x11rb+xfixes-devel \
 rust-x11rb+xinerama-devel \
 rust-x11rb+xinput-devel \
 rust-x11rb+xkb-devel \
 rust-x11rb+xprint-devel \
 rust-x11rb+xselinux-devel \
 rust-x11rb+xtest-devel \
 rust-x11rb+xv-devel \
 rust-x11rb+xvmc-devel \
 rust-x11rb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-x11rb-0.13.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da98da5dea2d3cef1e4297ed5d24ff9ea903448e1091f0b561be7fd140434551"

URI_x86_64_v2_rust-x11rb+all-extensions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+all-extensions-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+all-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+all-extensions-devel}"
SRC_URI[x86_64_v2_rust-x11rb+all-extensions-devel.sha256sum] = "924aaeaa9a5f6561c17b5adc828688db23dd2e7a5a1b0fb0a3f0c0e29ca4e15b"

URI_x86_64_v2_rust-x11rb+allow-unsafe-code-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+allow-unsafe-code-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+allow-unsafe-code-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+allow-unsafe-code-devel}"
SRC_URI[x86_64_v2_rust-x11rb+allow-unsafe-code-devel.sha256sum] = "4d0f773d2169294a878449848cc7c610efa21043d861e77c51ff2ab4d987bbfd"

URI_x86_64_v2_rust-x11rb+as-raw-xcb-connection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+as-raw-xcb-connection-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+as-raw-xcb-connection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+as-raw-xcb-connection-devel}"
SRC_URI[x86_64_v2_rust-x11rb+as-raw-xcb-connection-devel.sha256sum] = "6609e344fef51b3ec3a840bcd2e632677b4bd628809b474e799f9c8c58f97c96"

URI_x86_64_v2_rust-x11rb+composite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+composite-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+composite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+composite-devel}"
SRC_URI[x86_64_v2_rust-x11rb+composite-devel.sha256sum] = "d342b6f016ee0e0520b3670e506736a3c02bd3636d3d186e910ef671000c4b05"

URI_x86_64_v2_rust-x11rb+cursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+cursor-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+cursor-devel}"
SRC_URI[x86_64_v2_rust-x11rb+cursor-devel.sha256sum] = "c1e645bee6d54ed4f069984ba7f2ead5f6bf4fe44f81445260b9a6bd7b3cafe7"

URI_x86_64_v2_rust-x11rb+damage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+damage-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+damage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+damage-devel}"
SRC_URI[x86_64_v2_rust-x11rb+damage-devel.sha256sum] = "a8a01196b8b47765ef46d3664de1bc490eeda1d7e07605df1d58448029de512f"

URI_x86_64_v2_rust-x11rb+dbe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dbe-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dbe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dbe-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dbe-devel.sha256sum] = "cdd2d320d5325d49780a4631227c49b08dc368bc7fec394d9634ff29f66fb877"

URI_x86_64_v2_rust-x11rb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+default-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+default-devel}"
SRC_URI[x86_64_v2_rust-x11rb+default-devel.sha256sum] = "528a8c2bfbf85ae099cf358ba3bbb07ca3fd51a1eaa9a172690bbfa0fa1c9330"

URI_x86_64_v2_rust-x11rb+dl-libxcb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dl-libxcb-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dl-libxcb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dl-libxcb-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dl-libxcb-devel.sha256sum] = "592b673b75b45d5ddddc8c3e02d06a4cef2ce2430073813537db34f7a910c9f7"

URI_x86_64_v2_rust-x11rb+dpms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dpms-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dpms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dpms-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dpms-devel.sha256sum] = "b978a85e348600f3c7d3f8f17f54785948f11e4c1e0fedc6e8176c106966e091"

URI_x86_64_v2_rust-x11rb+dri2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dri2-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dri2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dri2-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dri2-devel.sha256sum] = "6eac37a4400ecec7ac0ea2d44c544d5156fcecaa3db5d4ebe7e248fe66d6f35d"

URI_x86_64_v2_rust-x11rb+dri3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dri3-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dri3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dri3-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dri3-devel.sha256sum] = "8a175029552322337b2a6a780b832ddf6c7557cb47482b92da4aaade78b5d283"

URI_x86_64_v2_rust-x11rb+extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+extra-traits-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+extra-traits-devel}"
SRC_URI[x86_64_v2_rust-x11rb+extra-traits-devel.sha256sum] = "da448fa96edf5fc8ba28525e8d9099b9d2a4ea6cf36345962801e687b837397e"

URI_x86_64_v2_rust-x11rb+glx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+glx-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+glx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+glx-devel}"
SRC_URI[x86_64_v2_rust-x11rb+glx-devel.sha256sum] = "5497d1f36dc67479e5e86601b242c731fd96ecfbdf90dcca351dc2c26cd83a87"

URI_x86_64_v2_rust-x11rb+image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+image-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+image-devel}"
SRC_URI[x86_64_v2_rust-x11rb+image-devel.sha256sum] = "b51def095948ba421c1ffd023a31bdc1dc9a1b8d5328c7ab8fd225dfae36f5bf"

URI_x86_64_v2_rust-x11rb+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+libc-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+libc-devel}"
SRC_URI[x86_64_v2_rust-x11rb+libc-devel.sha256sum] = "3bfa266fb8ef3cdcd54ece9c717dd59f8b71af3afaab7916e88272bda5aeb5a3"

URI_x86_64_v2_rust-x11rb+libloading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+libloading-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+libloading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+libloading-devel}"
SRC_URI[x86_64_v2_rust-x11rb+libloading-devel.sha256sum] = "a2c1998ebc986be66d8f2551ec081b1d39975f144bdd4078d42d59a831206e8b"

URI_x86_64_v2_rust-x11rb+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+once_cell-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+once_cell-devel}"
SRC_URI[x86_64_v2_rust-x11rb+once_cell-devel.sha256sum] = "c542a6242e7d4425ef32d5c7c728be842c135111dfbf2e23ca1e11efaf84687a"

URI_x86_64_v2_rust-x11rb+present-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+present-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+present-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+present-devel}"
SRC_URI[x86_64_v2_rust-x11rb+present-devel.sha256sum] = "e9c305fd74b1cbb44394dc75ddeaf26bcc2453efed80dc3b58b577d01e1e0ef0"

URI_x86_64_v2_rust-x11rb+randr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+randr-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+randr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+randr-devel}"
SRC_URI[x86_64_v2_rust-x11rb+randr-devel.sha256sum] = "d46bc4b43265cde186ab8baaa0319d90109bdb4b5b2f2e74511656df37dee28a"

URI_x86_64_v2_rust-x11rb+raw-window-handle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+raw-window-handle-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+raw-window-handle-devel}"
SRC_URI[x86_64_v2_rust-x11rb+raw-window-handle-devel.sha256sum] = "6845eb2613ecc4ece728246a4deecb7cea1d7504fe979ac0f0e9c345d50ebbae"

URI_x86_64_v2_rust-x11rb+record-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+record-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+record-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+record-devel}"
SRC_URI[x86_64_v2_rust-x11rb+record-devel.sha256sum] = "928dd0b0fd2b0b86ce7881656a9b2fa10b36a858db4670c2fe81485e5547f61f"

URI_x86_64_v2_rust-x11rb+render-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+render-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+render-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+render-devel}"
SRC_URI[x86_64_v2_rust-x11rb+render-devel.sha256sum] = "5e1e89c24aee61597a32b7794e092f7c1f7afd5e7de81d344e7b7bae5557296d"

URI_x86_64_v2_rust-x11rb+request-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+request-parsing-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+request-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+request-parsing-devel}"
SRC_URI[x86_64_v2_rust-x11rb+request-parsing-devel.sha256sum] = "efddcedc59917e32fcbb684c31e1f7e516c265b20f83cfe1c5809d82ec798281"

URI_x86_64_v2_rust-x11rb+res-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+res-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+res-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+res-devel}"
SRC_URI[x86_64_v2_rust-x11rb+res-devel.sha256sum] = "6b1ae67d3e27a3fc46bd25aab552a86f08ba16297ecd931b01b3e91b3432d397"

URI_x86_64_v2_rust-x11rb+resource_manager-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+resource_manager-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+resource_manager-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+resource_manager-devel}"
SRC_URI[x86_64_v2_rust-x11rb+resource_manager-devel.sha256sum] = "9de3df7aa5bfba71f0afae10b0a698298267086276455fb1fc6773b0009f3fa4"

URI_x86_64_v2_rust-x11rb+screensaver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+screensaver-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+screensaver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+screensaver-devel}"
SRC_URI[x86_64_v2_rust-x11rb+screensaver-devel.sha256sum] = "fffae95fdb87933b005d1d1da2834d66b31174be8ca08b44f60b406b15e0e0c1"

URI_x86_64_v2_rust-x11rb+shape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+shape-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+shape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+shape-devel}"
SRC_URI[x86_64_v2_rust-x11rb+shape-devel.sha256sum] = "0850ebb0dfa172daf319fee6b350caee112bdc8378c0b0400551b7f035b374cb"

URI_x86_64_v2_rust-x11rb+shm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+shm-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+shm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+shm-devel}"
SRC_URI[x86_64_v2_rust-x11rb+shm-devel.sha256sum] = "6ed499ce7e841a60d7518e77f2040d65548e9315f485a2f044d42c75fd903d97"

URI_x86_64_v2_rust-x11rb+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+sync-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+sync-devel}"
SRC_URI[x86_64_v2_rust-x11rb+sync-devel.sha256sum] = "d1f9553dee62742329fd7e5e2597303bcab24c8e8702b345ecd45bc275a6c6b6"

URI_x86_64_v2_rust-x11rb+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+tracing-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+tracing-devel}"
SRC_URI[x86_64_v2_rust-x11rb+tracing-devel.sha256sum] = "7e2e7089f64bfc18689f8c4ae6519b5fc24aa5e56e135c86dbc40b35ec7a157d"

URI_x86_64_v2_rust-x11rb+xcursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xcursor-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xcursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xcursor-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xcursor-devel.sha256sum] = "771f1b63187b0f30ed8c864d2db2ec5431bdd4e055c14f20248bc101f6ef3358"

URI_x86_64_v2_rust-x11rb+xevie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xevie-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xevie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xevie-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xevie-devel.sha256sum] = "8e1f02c6e6214a73b9e2b477a5d9ac93087ec38cbda29462469303af6842d48b"

URI_x86_64_v2_rust-x11rb+xf86dri-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xf86dri-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xf86dri-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xf86dri-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xf86dri-devel.sha256sum] = "8b8a3660c64ab57771c59b9ff7ae51352ca33a9b64672a997b9fbdc0d1d2cb4c"

URI_x86_64_v2_rust-x11rb+xf86vidmode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xf86vidmode-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xf86vidmode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xf86vidmode-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xf86vidmode-devel.sha256sum] = "699e5aa828465fafc7132b57fe7e9ef6a71c57714343013c9ba795d0d4c5e7a0"

URI_x86_64_v2_rust-x11rb+xfixes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xfixes-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xfixes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xfixes-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xfixes-devel.sha256sum] = "b3b542aea4347774cc03380639b87d6c4674ce2491a407c7179940deaa26db36"

URI_x86_64_v2_rust-x11rb+xinerama-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xinerama-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xinerama-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xinerama-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xinerama-devel.sha256sum] = "e6ba8bf9a5e7a017e7cea8c94f0868e9d09bda36a776a40402c7c626276c28f1"

URI_x86_64_v2_rust-x11rb+xinput-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xinput-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xinput-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xinput-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xinput-devel.sha256sum] = "3af17586485c527dd147963d81eec2e8a891838b2168541f1665653fb7b23f27"

URI_x86_64_v2_rust-x11rb+xkb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xkb-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xkb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xkb-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xkb-devel.sha256sum] = "aedace94d0d816dee1e96c972566758e5b930a83750d63a5bb5dd1d00f61d787"

URI_x86_64_v2_rust-x11rb+xprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xprint-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xprint-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xprint-devel.sha256sum] = "84b264d5d9e1d3349793f63acce55ea6e74929e5373c9eeb7e5218cfa72d5b4e"

URI_x86_64_v2_rust-x11rb+xselinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xselinux-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xselinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xselinux-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xselinux-devel.sha256sum] = "ee4a0a820f55d309071376b9199061f44115b63158a9839b76714b715bd18552"

URI_x86_64_v2_rust-x11rb+xtest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xtest-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xtest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xtest-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xtest-devel.sha256sum] = "31517d4692e5cf8434d69e3d9e6caaa8a7a72c5cbf50a259e5e7159ecca2d193"

URI_x86_64_v2_rust-x11rb+xv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xv-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xv-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xv-devel.sha256sum] = "64cea95df84730bb29fcf41c875de81fc3c6fd762809fd86c9ebd97e49e3f312"

URI_x86_64_v2_rust-x11rb+xvmc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xvmc-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xvmc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xvmc-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xvmc-devel.sha256sum] = "ba62b69769fda4fd5e606be481867de3cc382121f6362ba3b6e4ccd2882cf887"

URI_x86_64_v2_rust-x11rb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-devel}"
SRC_URI[x86_64_v2_rust-x11rb-devel.sha256sum] = "0f745f8c412a3a598bf7067cc62a5192225380d38fdba2a3c192c6f390b12ca8"

URI_aarch64_rust-x11rb+all-extensions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+all-extensions-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+all-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+all-extensions-devel}"
SRC_URI[aarch64_rust-x11rb+all-extensions-devel.sha256sum] = "767bf578d25f220479947b03e15f69355569deabb87574b64d603276c6213085"

URI_aarch64_rust-x11rb+allow-unsafe-code-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+allow-unsafe-code-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+allow-unsafe-code-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+allow-unsafe-code-devel}"
SRC_URI[aarch64_rust-x11rb+allow-unsafe-code-devel.sha256sum] = "4d81b5b5d7b7edf3efaaf67cd7133c382dd07db178170096f625e9773d098bbe"

URI_aarch64_rust-x11rb+as-raw-xcb-connection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+as-raw-xcb-connection-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+as-raw-xcb-connection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+as-raw-xcb-connection-devel}"
SRC_URI[aarch64_rust-x11rb+as-raw-xcb-connection-devel.sha256sum] = "05713d1a84486c8badcc8c866b79bc2cbf61b761e685221970df5e1fd227d7d2"

URI_aarch64_rust-x11rb+composite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+composite-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+composite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+composite-devel}"
SRC_URI[aarch64_rust-x11rb+composite-devel.sha256sum] = "9636deae432bb4065b468b6f42e53366e658ad8a1a4867cbe02a1c051ccbada0"

URI_aarch64_rust-x11rb+cursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+cursor-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+cursor-devel}"
SRC_URI[aarch64_rust-x11rb+cursor-devel.sha256sum] = "46f0452645ec1aab3f4011199d0832d7dc196abe31cb1bbf8b74983dda682c60"

URI_aarch64_rust-x11rb+damage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+damage-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+damage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+damage-devel}"
SRC_URI[aarch64_rust-x11rb+damage-devel.sha256sum] = "d581fc9eb853795063b49bcf4d8cc044278bc7ef51527475f4602a76b91a1df7"

URI_aarch64_rust-x11rb+dbe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dbe-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+dbe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dbe-devel}"
SRC_URI[aarch64_rust-x11rb+dbe-devel.sha256sum] = "542ca36eeb106c2f8b52e4ffaa2f6d590b47d1178fc304edf84de5748a80928b"

URI_aarch64_rust-x11rb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+default-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+default-devel}"
SRC_URI[aarch64_rust-x11rb+default-devel.sha256sum] = "ddad9d5774efe640518bc572e2569afd03246983d236ed2dfa5d50b29ce42603"

URI_aarch64_rust-x11rb+dl-libxcb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dl-libxcb-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+dl-libxcb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dl-libxcb-devel}"
SRC_URI[aarch64_rust-x11rb+dl-libxcb-devel.sha256sum] = "040daea187f5424b46677a76a8c24f269999d4953b208f0e8e706b0d6f10fa20"

URI_aarch64_rust-x11rb+dpms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dpms-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+dpms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dpms-devel}"
SRC_URI[aarch64_rust-x11rb+dpms-devel.sha256sum] = "40cad5b5abded7efe8bdca40933655147785506103bd72c5dae67de3b5f80aba"

URI_aarch64_rust-x11rb+dri2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dri2-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+dri2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dri2-devel}"
SRC_URI[aarch64_rust-x11rb+dri2-devel.sha256sum] = "9d3d95348b4c7d9c770d225841aa3f7b954cd96ca23bc1ad70a8a27965c429ce"

URI_aarch64_rust-x11rb+dri3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dri3-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+dri3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dri3-devel}"
SRC_URI[aarch64_rust-x11rb+dri3-devel.sha256sum] = "fcb558b7770ef68e49224a35b4e41a537f4f63de029002aeb5b3991b24f5038d"

URI_aarch64_rust-x11rb+extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+extra-traits-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+extra-traits-devel}"
SRC_URI[aarch64_rust-x11rb+extra-traits-devel.sha256sum] = "98aa7fe5b02c74217a05c58b0c6745c01163985c101c1c716cb6a03e4dd8aafd"

URI_aarch64_rust-x11rb+glx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+glx-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+glx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+glx-devel}"
SRC_URI[aarch64_rust-x11rb+glx-devel.sha256sum] = "73c0eeaea83688b359a74488c0e2802b7a785be92961526a6a99c89058561c61"

URI_aarch64_rust-x11rb+image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+image-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+image-devel}"
SRC_URI[aarch64_rust-x11rb+image-devel.sha256sum] = "a3502485b6d1f78394c28b76a43f384f998b42732bf3713b489f4c0eaea887d6"

URI_aarch64_rust-x11rb+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+libc-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+libc-devel}"
SRC_URI[aarch64_rust-x11rb+libc-devel.sha256sum] = "304fd0278ae18bec40585ef2e3a7efae3c9bcdf49ccf20a748ac042108566c05"

URI_aarch64_rust-x11rb+libloading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+libloading-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+libloading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+libloading-devel}"
SRC_URI[aarch64_rust-x11rb+libloading-devel.sha256sum] = "b6a561bedfb0cb4fe3f95d6e1c0ab341b29760d5557941b7fbe9428928252147"

URI_aarch64_rust-x11rb+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+once_cell-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+once_cell-devel}"
SRC_URI[aarch64_rust-x11rb+once_cell-devel.sha256sum] = "2a5df83ae649a0afd352e5e150095188a1c31685e6a730ef4d28c3c032414332"

URI_aarch64_rust-x11rb+present-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+present-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+present-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+present-devel}"
SRC_URI[aarch64_rust-x11rb+present-devel.sha256sum] = "10ff1977cd47ce73891f7674883a8e3cad7e438b4d5671af403531ae4e08bfcc"

URI_aarch64_rust-x11rb+randr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+randr-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+randr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+randr-devel}"
SRC_URI[aarch64_rust-x11rb+randr-devel.sha256sum] = "453ad5b308ad8a0a09d91922bec5628f4dd9407ff417ec509eafe441946ffb2f"

URI_aarch64_rust-x11rb+raw-window-handle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+raw-window-handle-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+raw-window-handle-devel}"
SRC_URI[aarch64_rust-x11rb+raw-window-handle-devel.sha256sum] = "13131a67c177dccb8d83af76a9e8f9e520947a1dc4d7c32cb0e728232a67a935"

URI_aarch64_rust-x11rb+record-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+record-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+record-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+record-devel}"
SRC_URI[aarch64_rust-x11rb+record-devel.sha256sum] = "c821a7ba9c2272157f3c9d2892708878cb058cc888c9e0abcf9fc77b98f5ca01"

URI_aarch64_rust-x11rb+render-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+render-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+render-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+render-devel}"
SRC_URI[aarch64_rust-x11rb+render-devel.sha256sum] = "83ce115b38ed85a792ab4c8a33feed12ca2092301a28f8b45a773dea1f09466a"

URI_aarch64_rust-x11rb+request-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+request-parsing-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+request-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+request-parsing-devel}"
SRC_URI[aarch64_rust-x11rb+request-parsing-devel.sha256sum] = "e3f32e1fd0d193f0775a05caad6f795b7f86610aa8286fa415a2325235e29dad"

URI_aarch64_rust-x11rb+res-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+res-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+res-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+res-devel}"
SRC_URI[aarch64_rust-x11rb+res-devel.sha256sum] = "f4dfd647763865ea79795f5517cea83a7e883ac431f650df02bbf6fcc8cef34e"

URI_aarch64_rust-x11rb+resource_manager-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+resource_manager-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+resource_manager-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+resource_manager-devel}"
SRC_URI[aarch64_rust-x11rb+resource_manager-devel.sha256sum] = "c660fa023ecd21fd8422608bff794a50d9fadc461ec2804a52ce62aa8b90c08a"

URI_aarch64_rust-x11rb+screensaver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+screensaver-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+screensaver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+screensaver-devel}"
SRC_URI[aarch64_rust-x11rb+screensaver-devel.sha256sum] = "f927f2e50fb84ee5c358f2d347ac2d2386e4d78b26fd1745521a2919334352d4"

URI_aarch64_rust-x11rb+shape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+shape-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+shape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+shape-devel}"
SRC_URI[aarch64_rust-x11rb+shape-devel.sha256sum] = "7a91d535947c958e345789a8d0d215b4d985fc03a8d26741991630d3a0a76f73"

URI_aarch64_rust-x11rb+shm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+shm-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+shm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+shm-devel}"
SRC_URI[aarch64_rust-x11rb+shm-devel.sha256sum] = "363542900905b28d3ee663b5aa0f7fe0f3915e1263bf0c6427699599bf94b1d6"

URI_aarch64_rust-x11rb+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+sync-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+sync-devel}"
SRC_URI[aarch64_rust-x11rb+sync-devel.sha256sum] = "e0ad05ee70bf959085cd64f1e32158873c815c12d7e69c27ec55871df10a7fe3"

URI_aarch64_rust-x11rb+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+tracing-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+tracing-devel}"
SRC_URI[aarch64_rust-x11rb+tracing-devel.sha256sum] = "79df83d9bca9d1101c683fece590ba6deeb6895d8cbfb950a0c8290f769b2420"

URI_aarch64_rust-x11rb+xcursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xcursor-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+xcursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xcursor-devel}"
SRC_URI[aarch64_rust-x11rb+xcursor-devel.sha256sum] = "22f3d77170790f1e8766176ffde9e9c54661e1d8ae61ae083fc96da72c98e7a3"

URI_aarch64_rust-x11rb+xevie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xevie-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+xevie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xevie-devel}"
SRC_URI[aarch64_rust-x11rb+xevie-devel.sha256sum] = "11532ca8e465f08473dfe302cc44064d1ce99aaf748e9b8e629b0bd93cc2326e"

URI_aarch64_rust-x11rb+xf86dri-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xf86dri-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+xf86dri-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xf86dri-devel}"
SRC_URI[aarch64_rust-x11rb+xf86dri-devel.sha256sum] = "20ef9ec2d6504d8841d6044024ff4991666e40dfe379abb23c7dfccd99960e27"

URI_aarch64_rust-x11rb+xf86vidmode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xf86vidmode-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+xf86vidmode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xf86vidmode-devel}"
SRC_URI[aarch64_rust-x11rb+xf86vidmode-devel.sha256sum] = "cd5bb4c518529fe0d4767a2a857ab3c597c72273ec12892cacc0c902c4c90d52"

URI_aarch64_rust-x11rb+xfixes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xfixes-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+xfixes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xfixes-devel}"
SRC_URI[aarch64_rust-x11rb+xfixes-devel.sha256sum] = "550785849acc717b48ac447c129861e3abb81a7fa1f86fb0c5f3e3127b8298bc"

URI_aarch64_rust-x11rb+xinerama-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xinerama-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+xinerama-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xinerama-devel}"
SRC_URI[aarch64_rust-x11rb+xinerama-devel.sha256sum] = "48c54bcb0009c34630dca66d60cc3c6252c4672f8121479647c9d31504f98cc2"

URI_aarch64_rust-x11rb+xinput-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xinput-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+xinput-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xinput-devel}"
SRC_URI[aarch64_rust-x11rb+xinput-devel.sha256sum] = "015c20ef2f38c3a13da0809ee0e11f0ef83204fd5b5e1e3599cc1275a854459d"

URI_aarch64_rust-x11rb+xkb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xkb-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+xkb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xkb-devel}"
SRC_URI[aarch64_rust-x11rb+xkb-devel.sha256sum] = "bd4005dca669590591c37b3e9a13552cb4478f2953768159effcf317a0b5ea88"

URI_aarch64_rust-x11rb+xprint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xprint-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+xprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xprint-devel}"
SRC_URI[aarch64_rust-x11rb+xprint-devel.sha256sum] = "6672fdb405910c5a66853be48f39ecbe9bdd088f5bd089bc4fc7d7c1ce3171d6"

URI_aarch64_rust-x11rb+xselinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xselinux-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+xselinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xselinux-devel}"
SRC_URI[aarch64_rust-x11rb+xselinux-devel.sha256sum] = "e1abe5b340fccc225220f013a6bce8ca3f7e4351e93bc49852744e38fcf89098"

URI_aarch64_rust-x11rb+xtest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xtest-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+xtest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xtest-devel}"
SRC_URI[aarch64_rust-x11rb+xtest-devel.sha256sum] = "c46939e74068a8634cdbe0d19a85927f5262f675a51e23b2adf39031709f0420"

URI_aarch64_rust-x11rb+xv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xv-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+xv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xv-devel}"
SRC_URI[aarch64_rust-x11rb+xv-devel.sha256sum] = "759de1753fca347d06295e65113f853fa928739bb47d87d8917ca7ff895b8cf3"

URI_aarch64_rust-x11rb+xvmc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xvmc-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb+xvmc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xvmc-devel}"
SRC_URI[aarch64_rust-x11rb+xvmc-devel.sha256sum] = "c21695e408d67d83e97049af17a83738ce4cd432366d4537269adb5048b51a7d"

URI_aarch64_rust-x11rb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-x11rb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-devel}"
SRC_URI[aarch64_rust-x11rb-devel.sha256sum] = "954a34c12ef47c4c1cf1a54779446834431a977cf796f8433684d6a807795a6f"

RDEPENDS:rust-x11rb+all-extensions-devel = " \
 cargo \
 rust-x11rb+composite-devel \
 rust-x11rb+damage-devel \
 rust-x11rb+dbe-devel \
 rust-x11rb+dpms-devel \
 rust-x11rb+dri2-devel \
 rust-x11rb+dri3-devel \
 rust-x11rb+glx-devel \
 rust-x11rb+present-devel \
 rust-x11rb+randr-devel \
 rust-x11rb+record-devel \
 rust-x11rb+render-devel \
 rust-x11rb+res-devel \
 rust-x11rb+screensaver-devel \
 rust-x11rb+shape-devel \
 rust-x11rb+shm-devel \
 rust-x11rb+sync-devel \
 rust-x11rb+xevie-devel \
 rust-x11rb+xf86dri-devel \
 rust-x11rb+xf86vidmode-devel \
 rust-x11rb+xfixes-devel \
 rust-x11rb+xinerama-devel \
 rust-x11rb+xinput-devel \
 rust-x11rb+xkb-devel \
 rust-x11rb+xprint-devel \
 rust-x11rb+xselinux-devel \
 rust-x11rb+xtest-devel \
 rust-x11rb+xv-devel \
 rust-x11rb+xvmc-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+all-extensions-devel \
 "
RDEPENDS:rust-x11rb+allow-unsafe-code-devel = " \
 cargo \
 rust-x11rb+as-raw-xcb-connection-devel \
 rust-x11rb+libc-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+as-raw-xcb-connection-devel = " \
 cargo \
 rust-as-raw-xcb-connection+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+composite-devel = " \
 cargo \
 rust-x11rb+xfixes-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+composite-devel \
 "
RDEPENDS:rust-x11rb+cursor-devel = " \
 cargo \
 rust-x11rb+render-devel \
 rust-x11rb+resource_manager-devel \
 rust-x11rb+xcursor-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+damage-devel = " \
 cargo \
 rust-x11rb+xfixes-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+damage-devel \
 "
RDEPENDS:rust-x11rb+dbe-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+dbe-devel \
 "
RDEPENDS:rust-x11rb+default-devel = " \
 cargo \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+dl-libxcb-devel = " \
 cargo \
 rust-x11rb+allow-unsafe-code-devel \
 rust-x11rb+libloading-devel \
 rust-x11rb+once_cell-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+dpms-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+dpms-devel \
 "
RDEPENDS:rust-x11rb+dri2-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+dri2-devel \
 "
RDEPENDS:rust-x11rb+dri3-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+dri3-devel \
 "
RDEPENDS:rust-x11rb+extra-traits-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+extra-traits-devel \
 "
RDEPENDS:rust-x11rb+glx-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+glx-devel \
 "
RDEPENDS:rust-x11rb+image-devel = " \
 cargo \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+libloading-devel = " \
 cargo \
 rust-libloading+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+present-devel = " \
 cargo \
 rust-x11rb+randr-devel \
 rust-x11rb+sync-devel \
 rust-x11rb+xfixes-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+present-devel \
 "
RDEPENDS:rust-x11rb+randr-devel = " \
 cargo \
 rust-x11rb+render-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+randr-devel \
 "
RDEPENDS:rust-x11rb+raw-window-handle-devel = " \
 cargo \
 rust-raw-window-handle0.5+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+record-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+record-devel \
 "
RDEPENDS:rust-x11rb+render-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+render-devel \
 "
RDEPENDS:rust-x11rb+request-parsing-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+request-parsing-devel \
 "
RDEPENDS:rust-x11rb+res-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+res-devel \
 "
RDEPENDS:rust-x11rb+resource_manager-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+resource_manager-devel \
 "
RDEPENDS:rust-x11rb+screensaver-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+screensaver-devel \
 "
RDEPENDS:rust-x11rb+shape-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+shape-devel \
 "
RDEPENDS:rust-x11rb+shm-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+shm-devel \
 "
RDEPENDS:rust-x11rb+sync-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+sync-devel \
 "
RDEPENDS:rust-x11rb+tracing-devel = " \
 cargo \
 rust-tracing-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+xcursor-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-xcursor+default-devel \
 "
RDEPENDS:rust-x11rb+xevie-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xevie-devel \
 "
RDEPENDS:rust-x11rb+xf86dri-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xf86dri-devel \
 "
RDEPENDS:rust-x11rb+xf86vidmode-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xf86vidmode-devel \
 "
RDEPENDS:rust-x11rb+xfixes-devel = " \
 cargo \
 rust-x11rb+render-devel \
 rust-x11rb+shape-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+xfixes-devel \
 "
RDEPENDS:rust-x11rb+xinerama-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xinerama-devel \
 "
RDEPENDS:rust-x11rb+xinput-devel = " \
 cargo \
 rust-x11rb+xfixes-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+xinput-devel \
 "
RDEPENDS:rust-x11rb+xkb-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xkb-devel \
 "
RDEPENDS:rust-x11rb+xprint-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xprint-devel \
 "
RDEPENDS:rust-x11rb+xselinux-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xselinux-devel \
 "
RDEPENDS:rust-x11rb+xtest-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xtest-devel \
 "
RDEPENDS:rust-x11rb+xv-devel = " \
 cargo \
 rust-x11rb+shm-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+xv-devel \
 "
RDEPENDS:rust-x11rb+xvmc-devel = " \
 cargo \
 rust-x11rb+xv-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+xvmc-devel \
 "
RDEPENDS:rust-x11rb-devel = " \
 cargo \
 rust \
 rust-gethostname+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+std-devel \
 rust-rustix+system-devel \
 rust-rustix-devel \
 rust-x11rb-protocol+std-devel \
 rust-x11rb-protocol-devel \
 "
