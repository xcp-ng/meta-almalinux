# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyfakefs"
PV = "5.7.4"
PR = "1.el10_0"
PACKAGES = " \
 python3-pyfakefs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyfakefs-5.7.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bbc630a3b2ffad7c16f45e448816dbcae2f3db2afc6d4670d28a664f391be03"

URI_x86_64_v2_python3-pyfakefs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyfakefs-5.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyfakefs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyfakefs}"
SRC_URI[x86_64_v2_python3-pyfakefs.sha256sum] = "64b20925fb6e25373d975b865efa0609dac7c7b7aa289538a30e249a036b10c9"

URI_aarch64_python3-pyfakefs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyfakefs-5.7.4-1.el10_0.noarch.rpm;name=aarch64_python3-pyfakefs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyfakefs}"
SRC_URI[aarch64_python3-pyfakefs.sha256sum] = "4dd8c169dd669f46c7fad72732228a9398559907acedfb42a5a5d12946d6eed9"

RDEPENDS:python3-pyfakefs = " \
 python3 \
 python3-pytest \
 "
