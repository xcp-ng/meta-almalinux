# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wmidi"
PV = "4.0.10"
PR = "2.el10_0"
PACKAGES = " \
 rust-wmidi+default-devel \
 rust-wmidi+std-devel \
 rust-wmidi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wmidi-4.0.10-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cad362d4055d280e65fb560e18c0d38ae963dc453e99e6820ace92023ba3928c"

URI_x86_64_v2_rust-wmidi+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wmidi+default-devel-4.0.10-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wmidi+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wmidi+default-devel}"
SRC_URI[x86_64_v2_rust-wmidi+default-devel.sha256sum] = "0c6d6b5bb99df0b8ede238711775b4d372997701cda231d814913104e1f21428"

URI_x86_64_v2_rust-wmidi+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wmidi+std-devel-4.0.10-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wmidi+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wmidi+std-devel}"
SRC_URI[x86_64_v2_rust-wmidi+std-devel.sha256sum] = "ec6bba3dcde2ab977957fba242023586183535a9afa64dc2ebe3d6247fb1ee0c"

URI_x86_64_v2_rust-wmidi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wmidi-devel-4.0.10-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wmidi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wmidi-devel}"
SRC_URI[x86_64_v2_rust-wmidi-devel.sha256sum] = "322bffed38fbbada6078461dcf93a9750a11effce399359f6d26dd9531ee5568"

URI_aarch64_rust-wmidi+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wmidi+default-devel-4.0.10-2.el10_0.noarch.rpm;name=aarch64_rust-wmidi+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wmidi+default-devel}"
SRC_URI[aarch64_rust-wmidi+default-devel.sha256sum] = "edab59dd54da2bbb0a86f63dbfe87f8b90a520feca3dedba8c6763b43498b9fc"

URI_aarch64_rust-wmidi+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wmidi+std-devel-4.0.10-2.el10_0.noarch.rpm;name=aarch64_rust-wmidi+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wmidi+std-devel}"
SRC_URI[aarch64_rust-wmidi+std-devel.sha256sum] = "e181e93b2fa7f002461ad41c5c5ece16d469ed41a32fd2974f693d8decbf10a0"

URI_aarch64_rust-wmidi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wmidi-devel-4.0.10-2.el10_0.noarch.rpm;name=aarch64_rust-wmidi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wmidi-devel}"
SRC_URI[aarch64_rust-wmidi-devel.sha256sum] = "62bf5c94b1cd63976ec5d938eb043b715d57d4388e98bffdedd181d5e512a777"

RDEPENDS:rust-wmidi+default-devel = " \
 cargo \
 rust-wmidi+std-devel \
 rust-wmidi-devel \
 "
RDEPENDS:rust-wmidi+std-devel = " \
 cargo \
 rust-wmidi-devel \
 "
RDEPENDS:rust-wmidi-devel = " \
 cargo \
 "
