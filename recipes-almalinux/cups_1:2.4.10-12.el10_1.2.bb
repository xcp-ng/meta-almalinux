# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cups"
PE = "1"
PV = "2.4.10"
PR = "12.el10_1.2"
PACKAGES = " \
 cups \
 cups-client \
 cups-devel \
 cups-filesystem \
 cups-ipptool \
 cups-libs \
 cups-lpd \
 cups-printerapp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cups-2.4.10-12.el10_1.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "baeaa1ecb7100551502daf58f9a2d6c1aad9b22c13fdec17bb287ba1b2cf6af3"

URI_x86_64_v2_cups = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-2.4.10-12.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_cups;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups}"
SRC_URI[x86_64_v2_cups.sha256sum] = "be00525b2726d6e27686c748b46034306dbdcc67e138416627159e4ca0eded56"

URI_x86_64_v2_cups-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-client-2.4.10-12.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_cups-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-client}"
SRC_URI[x86_64_v2_cups-client.sha256sum] = "a676beb3451120f31d06191c0572659348fd4207e186947c4c35f0db4d2189aa"

URI_x86_64_v2_cups-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-devel-2.4.10-12.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_cups-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-devel}"
SRC_URI[x86_64_v2_cups-devel.sha256sum] = "46f5f1bf43107232b4e0e2dcf4d30036bc8b1a3563c88a61ec424c07cb63bd72"

URI_x86_64_v2_cups-filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cups-filesystem-2.4.10-12.el10_1.2.noarch.rpm;name=x86_64_v2_cups-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-filesystem}"
SRC_URI[x86_64_v2_cups-filesystem.sha256sum] = "2a2039a662a6fe9de47333d28b998bc81d16a0c388691c25aa0f7aeef35b878d"

URI_x86_64_v2_cups-ipptool = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-ipptool-2.4.10-12.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_cups-ipptool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-ipptool}"
SRC_URI[x86_64_v2_cups-ipptool.sha256sum] = "8ed75aec33ec6bf956c03037491a692aca14880ff7ccff9acc19c5a771eaae54"

URI_x86_64_v2_cups-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cups-libs-2.4.10-12.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_cups-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-libs}"
SRC_URI[x86_64_v2_cups-libs.sha256sum] = "c567984fb538d45c05172b904df69b289cfbd490d92f466e9eb0ac9b20d9a2dd"

URI_x86_64_v2_cups-lpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-lpd-2.4.10-12.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_cups-lpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-lpd}"
SRC_URI[x86_64_v2_cups-lpd.sha256sum] = "59a919fb07d8c4d363d183acf0d2a54310b1960d07818258b76cfd548222923b"

URI_x86_64_v2_cups-printerapp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-printerapp-2.4.10-12.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_cups-printerapp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-printerapp}"
SRC_URI[x86_64_v2_cups-printerapp.sha256sum] = "ea1b6e2217e6fd36e06c8cfe4ca8e37496b6c95cc3ae137c9f073a4939502738"

URI_aarch64_cups = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-2.4.10-12.el10_1.2.aarch64.rpm;name=aarch64_cups;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups}"
SRC_URI[aarch64_cups.sha256sum] = "a64e0524453e0f75fdfd66cccbc71419a28b97678e8528727f0c84712be82169"

URI_aarch64_cups-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-client-2.4.10-12.el10_1.2.aarch64.rpm;name=aarch64_cups-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-client}"
SRC_URI[aarch64_cups-client.sha256sum] = "1628afbc951dc52a03ed5ff80bb4e61e2c451a605804ca6a20c35a0ae42bdd52"

URI_aarch64_cups-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-devel-2.4.10-12.el10_1.2.aarch64.rpm;name=aarch64_cups-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-devel}"
SRC_URI[aarch64_cups-devel.sha256sum] = "4a4b98bf553dbb25807febe1526604ace68dcc33e8b89d3c8577c4feac91a3b6"

URI_aarch64_cups-filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cups-filesystem-2.4.10-12.el10_1.2.noarch.rpm;name=aarch64_cups-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-filesystem}"
SRC_URI[aarch64_cups-filesystem.sha256sum] = "2a2039a662a6fe9de47333d28b998bc81d16a0c388691c25aa0f7aeef35b878d"

URI_aarch64_cups-ipptool = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-ipptool-2.4.10-12.el10_1.2.aarch64.rpm;name=aarch64_cups-ipptool;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-ipptool}"
SRC_URI[aarch64_cups-ipptool.sha256sum] = "ab38941e644e191e3206f6b8946a43a4788bc6acc4fd2dd0399b3b5c2f006af2"

URI_aarch64_cups-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cups-libs-2.4.10-12.el10_1.2.aarch64.rpm;name=aarch64_cups-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-libs}"
SRC_URI[aarch64_cups-libs.sha256sum] = "fa7be7b942a5d5e58d31d507b702cb28ca3414f3d2ddc71c395a3ac187119c06"

URI_aarch64_cups-lpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-lpd-2.4.10-12.el10_1.2.aarch64.rpm;name=aarch64_cups-lpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-lpd}"
SRC_URI[aarch64_cups-lpd.sha256sum] = "dd9c2d4187474166e129669adc8e80d6cad6c83a98d44157c55d5cf1be741a7c"

URI_aarch64_cups-printerapp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-printerapp-2.4.10-12.el10_1.2.aarch64.rpm;name=aarch64_cups-printerapp;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-printerapp}"
SRC_URI[aarch64_cups-printerapp.sha256sum] = "353afe93167263ebd23285f2b5aae4a7a67b051d70e1f6b80daf1d6cfac7172c"

RDEPENDS:cups = " \
 acl \
 audit-libs \
 avahi-libs \
 bash \
 cups-client \
 cups-filesystem \
 cups-filters \
 cups-libs \
 dbus \
 dbus-libs \
 glibc \
 grep \
 krb5-libs \
 libacl \
 libgcc \
 libselinux \
 libstdc++ \
 libusb1 \
 pam-libs \
 python3 \
 sed \
 systemd \
 systemd-libs \
 "
RDEPENDS:cups-client = " \
 alternatives \
 bash \
 cups-libs \
 glibc \
 "
RDEPENDS:cups-devel = " \
 avahi-devel \
 bash \
 cups-libs \
 gnutls-devel \
 krb5-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:cups-filesystem = " \
 "
RDEPENDS:cups-ipptool = " \
 avahi \
 avahi-libs \
 cups-libs \
 glibc \
 "
RDEPENDS:cups-libs = " \
 avahi-libs \
 cups-filesystem \
 glibc \
 gnutls \
 krb5-libs \
 zlib-ng-compat \
 "
RDEPENDS:cups-lpd = " \
 bash \
 cups \
 cups-libs \
 glibc \
 "
RDEPENDS:cups-printerapp = " \
 avahi \
 avahi-libs \
 cups-libs \
 glibc \
 pam-libs \
 "
