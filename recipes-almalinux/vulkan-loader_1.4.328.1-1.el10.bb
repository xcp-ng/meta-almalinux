# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-loader"
PV = "1.4.328.1"
PR = "1.el10"
PACKAGES = " \
 vulkan-loader \
 vulkan-loader-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-loader-1.4.328.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "596ea5f113abb865c90ca9182cf0d1abb6b070605c74802a1301410b0b99bc60"

URI_x86_64_v2_vulkan-loader = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-loader-1.4.328.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-loader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-loader}"
SRC_URI[x86_64_v2_vulkan-loader.sha256sum] = "435b34272c6f1788ce015d6243ef6806fd43d8a98f15428b9570ff0b202d6486"

URI_x86_64_v2_vulkan-loader-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-loader-devel-1.4.328.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-loader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-loader-devel}"
SRC_URI[x86_64_v2_vulkan-loader-devel.sha256sum] = "ed3df1a03a39231ad2b05fa59000955e4f9b43664d64f2bde680874321257e0d"

URI_aarch64_vulkan-loader = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-loader-1.4.328.1-1.el10.aarch64.rpm;name=aarch64_vulkan-loader;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-loader}"
SRC_URI[aarch64_vulkan-loader.sha256sum] = "27bca7147663b4baaa754097da86cb9bac764b6c5c3fccbab563586978920fb2"

URI_aarch64_vulkan-loader-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-loader-devel-1.4.328.1-1.el10.aarch64.rpm;name=aarch64_vulkan-loader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-loader-devel}"
SRC_URI[aarch64_vulkan-loader-devel.sha256sum] = "7a5f9c669e1cf61cea94da91227d48ed8aba055319f6cfd4535e8e699ef6d59f"

RDEPENDS:vulkan-loader = " \
 glibc \
 "
RDEPENDS:vulkan-loader-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 vulkan-headers \
 vulkan-loader \
 "
