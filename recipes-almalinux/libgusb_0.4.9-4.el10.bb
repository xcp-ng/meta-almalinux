# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgusb"
PV = "0.4.9"
PR = "4.el10"
PACKAGES = " \
 libgusb \
 libgusb-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libgusb-0.4.9-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "836cfe97740a043ed977f5dc9552eca2dcbe36a05bb85978f0403432632727ce"

URI_x86_64_v2_libgusb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgusb-0.4.9-4.el10.x86_64_v2.rpm;name=x86_64_v2_libgusb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgusb}"
SRC_URI[x86_64_v2_libgusb.sha256sum] = "d7de9119c062c846ffdcd4413b23a7ebe63bced9a1ab05548a9e010204c130a5"

URI_x86_64_v2_libgusb-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgusb-devel-0.4.9-4.el10.x86_64_v2.rpm;name=x86_64_v2_libgusb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgusb-devel}"
SRC_URI[x86_64_v2_libgusb-devel.sha256sum] = "9ea03d571a784280564ee7a23fb08a11dd519252c321f0812709a32502dbbea0"

URI_aarch64_libgusb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgusb-0.4.9-4.el10.aarch64.rpm;name=aarch64_libgusb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgusb}"
SRC_URI[aarch64_libgusb.sha256sum] = "4bf51c8baeffe71707859bbd64b37105fae97a4c65913a2310065a012255db9d"

URI_aarch64_libgusb-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgusb-devel-0.4.9-4.el10.aarch64.rpm;name=aarch64_libgusb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgusb-devel}"
SRC_URI[aarch64_libgusb-devel.sha256sum] = "91a7f2c415aa62a70f4fe047f49165229c6e4a32916d1d48a4c2afb67603de2e"

RDEPENDS:libgusb = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 libusb1 \
 "
RDEPENDS:libgusb-devel = " \
 glib2 \
 glib2-devel \
 glibc \
 json-glib \
 json-glib-devel \
 libgcc \
 libgusb \
 libusb1-devel \
 pkgconf-pkg-config \
 "
