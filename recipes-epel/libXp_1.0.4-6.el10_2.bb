# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXp"
PV = "1.0.4"
PR = "6.el10_2"
PACKAGES = " \
 libXp \
 libXp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libXp-1.0.4-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35f84856d80081f70ab5b781d1303c197cf8cd3c4e8579d44725e7e20d15ece7"

URI_x86_64_v2_libXp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXp-1.0.4-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXp}"
SRC_URI[x86_64_v2_libXp.sha256sum] = "be5bb061e00d6645872a1820e1122759bdccdf0fd1dd8f5c35028dd387181952"

URI_x86_64_v2_libXp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXp-devel-1.0.4-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXp-devel}"
SRC_URI[x86_64_v2_libXp-devel.sha256sum] = "63734e4b9e764bb48fd6b0fca0203892acc84fff5b606824ec0e9d25701d50a6"

URI_aarch64_libXp = "${EPEL_MIRROR}/aarch64/Packages/l/libXp-1.0.4-6.el10_2.aarch64.rpm;name=aarch64_libXp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXp}"
SRC_URI[aarch64_libXp.sha256sum] = "701ec5a6c5b86f1e424ea6d740a8188519256829f778f61ad6645203ab5756b9"

URI_aarch64_libXp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXp-devel-1.0.4-6.el10_2.aarch64.rpm;name=aarch64_libXp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXp-devel}"
SRC_URI[aarch64_libXp-devel.sha256sum] = "fd5bb903cc21283c5ea288ab4ef2e0ca39d2d10686bf9030de6d68aafd98c7f9"

RDEPENDS:libXp = " \
 glibc \
 libX11 \
 libXau \
 libXext \
 "
RDEPENDS:libXp-devel = " \
 libX11-devel \
 libXau-devel \
 libXext-devel \
 libXp \
 libXp-devel \
 pkgconf-pkg-config \
 "
