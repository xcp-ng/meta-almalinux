# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deadpool-runtime"
PV = "0.3.1"
PR = "2.el10_3"
PACKAGES = " \
 rust-deadpool-runtime+default-devel \
 rust-deadpool-runtime+smol_2-devel \
 rust-deadpool-runtime+tokio_1-devel \
 rust-deadpool-runtime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deadpool-runtime-0.3.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ccc540264607ad704eed53a51bb0de3aa56a9543fa879783e3bd2b6295cdb44"

URI_x86_64_v2_rust-deadpool-runtime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-runtime+default-devel-0.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-runtime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-runtime+default-devel}"
SRC_URI[x86_64_v2_rust-deadpool-runtime+default-devel.sha256sum] = "158dde1f4e2e3047d2cc3a4e2718448261a01b991576010b92c8b91fc61cd821"

URI_x86_64_v2_rust-deadpool-runtime+smol_2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-runtime+smol_2-devel-0.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-runtime+smol_2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-runtime+smol_2-devel}"
SRC_URI[x86_64_v2_rust-deadpool-runtime+smol_2-devel.sha256sum] = "8314691a08c3e6571d5eadee1bf470c35486536ab743756b288857fc4e598418"

URI_x86_64_v2_rust-deadpool-runtime+tokio_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-runtime+tokio_1-devel-0.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-runtime+tokio_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-runtime+tokio_1-devel}"
SRC_URI[x86_64_v2_rust-deadpool-runtime+tokio_1-devel.sha256sum] = "d4d2c23ad9c4f560a2e980f1caa4ab6c0dc5f80ec887aec11addac2e71148405"

URI_x86_64_v2_rust-deadpool-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-runtime-devel-0.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-runtime-devel}"
SRC_URI[x86_64_v2_rust-deadpool-runtime-devel.sha256sum] = "5ef187096ba051db11cc89ef113e7f704991713549852f90ea3f04d1c3cd7a5c"

URI_aarch64_rust-deadpool-runtime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-runtime+default-devel-0.3.1-2.el10_3.noarch.rpm;name=aarch64_rust-deadpool-runtime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-runtime+default-devel}"
SRC_URI[aarch64_rust-deadpool-runtime+default-devel.sha256sum] = "f3a0e69de4ea5636161d6f0e5c38ce3934ce3a86067ed1eb6916dba3e6b54b0d"

URI_aarch64_rust-deadpool-runtime+smol_2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-runtime+smol_2-devel-0.3.1-2.el10_3.noarch.rpm;name=aarch64_rust-deadpool-runtime+smol_2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-runtime+smol_2-devel}"
SRC_URI[aarch64_rust-deadpool-runtime+smol_2-devel.sha256sum] = "cc1c7670d0747d3c0503324934b3bf76e5b276448defa1bee89ccbcacfec6358"

URI_aarch64_rust-deadpool-runtime+tokio_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-runtime+tokio_1-devel-0.3.1-2.el10_3.noarch.rpm;name=aarch64_rust-deadpool-runtime+tokio_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-runtime+tokio_1-devel}"
SRC_URI[aarch64_rust-deadpool-runtime+tokio_1-devel.sha256sum] = "196d365546e2f2f9c7345e4f888b8750e863c4e17e6be5487147cf406de8f231"

URI_aarch64_rust-deadpool-runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-runtime-devel-0.3.1-2.el10_3.noarch.rpm;name=aarch64_rust-deadpool-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-runtime-devel}"
SRC_URI[aarch64_rust-deadpool-runtime-devel.sha256sum] = "bcbadb24af39616f737d8648dca98abbdcba3cca79e48d78fba8516977d868bf"

RDEPENDS:rust-deadpool-runtime+default-devel = " \
 cargo \
 rust-deadpool-runtime-devel \
 "
RDEPENDS:rust-deadpool-runtime+smol_2-devel = " \
 cargo \
 rust-async-io+default-devel \
 rust-blocking+default-devel \
 rust-deadpool-runtime-devel \
 rust-futures-lite+default-devel \
 "
RDEPENDS:rust-deadpool-runtime+tokio_1-devel = " \
 cargo \
 rust-deadpool-runtime-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-deadpool-runtime-devel = " \
 cargo \
 rust \
 "
