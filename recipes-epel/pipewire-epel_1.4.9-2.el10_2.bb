# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipewire-epel"
PV = "1.4.9"
PR = "2.el10_2"
PACKAGES = " \
 pipewire-module-filter-chain-lv2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pipewire-epel-1.4.9-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b68702f3ec15fae388b440eb6603480925f9ec7efbafa3e52d605b5305a16c6"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - pipewire-module-filter-chain-lv2: pipewire-libs(x86-64) = 1.4.9-1.el10

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - pipewire-module-filter-chain-lv2: pipewire-libs(aarch-64) = 1.4.9-1.el10

URI_x86_64_v2_pipewire-module-filter-chain-lv2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pipewire-module-filter-chain-lv2-1.4.9-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pipewire-module-filter-chain-lv2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-module-filter-chain-lv2}"
SRC_URI[x86_64_v2_pipewire-module-filter-chain-lv2.sha256sum] = "9bcc60941b4c65893eb0dccec5b5e28a144077663db6b4eb976c98177ff9c688"

URI_aarch64_pipewire-module-filter-chain-lv2 = "${EPEL_MIRROR}/aarch64/Packages/p/pipewire-module-filter-chain-lv2-1.4.9-2.el10_2.aarch64.rpm;name=aarch64_pipewire-module-filter-chain-lv2;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-module-filter-chain-lv2}"
SRC_URI[aarch64_pipewire-module-filter-chain-lv2.sha256sum] = "3551e37a8f71607e618cc7cc65281323c1e7106ee14affc0fa5c7e46bd75386b"

RDEPENDS:pipewire-module-filter-chain-lv2 = " \
 glibc \
 lilv-libs \
 "
