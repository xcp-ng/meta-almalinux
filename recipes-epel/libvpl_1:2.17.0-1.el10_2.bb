# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvpl"
PE = "1"
PV = "2.17.0"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 libvpl \
 libvpl-devel \
 libvpl-samples \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/l/libvpl-2.17.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e180a0373760397f6ab667091c72799efb83cf156d68ef08df37fb5d3f22d0c"

URI_x86_64_v2_libvpl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-2.17.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl}"
SRC_URI[x86_64_v2_libvpl.sha256sum] = "ade2124f5d47aecd756f8837d2a3b6b247d3239d42c489f5d3c5ab8d9d492761"

URI_x86_64_v2_libvpl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-devel-2.17.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-devel}"
SRC_URI[x86_64_v2_libvpl-devel.sha256sum] = "b11087440aec4e4e0938064fbc5b15edce0a460bcc4c4438f9d48d0a803a6564"

URI_x86_64_v2_libvpl-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-samples-2.17.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-samples}"
SRC_URI[x86_64_v2_libvpl-samples.sha256sum] = "48afe463b4e4f7998bae20a2ee34baeaeb4e64964b1507d06ca51dafa92c8c4e"

RDEPENDS:libvpl = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libvpl-devel = " \
 cmake-filesystem \
 libvpl \
 pkgconf-pkg-config \
 "
RDEPENDS:libvpl-samples = " \
 libvpl-devel \
 "
