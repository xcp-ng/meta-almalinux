# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-similar"
PV = "3.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-similar+bstr-devel \
 rust-similar+bytes-devel \
 rust-similar+default-devel \
 rust-similar+hashbrown-devel \
 rust-similar+inline-devel \
 rust-similar+serde-devel \
 rust-similar+std-devel \
 rust-similar+text-devel \
 rust-similar+unicode-devel \
 rust-similar+unicode-segmentation-devel \
 rust-similar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-similar-3.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1660932a35a296ecf6844546a185baaeda2bf9b384d9b675385dfa57fc024dad"

URI_x86_64_v2_rust-similar+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+bstr-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+bstr-devel}"
SRC_URI[x86_64_v2_rust-similar+bstr-devel.sha256sum] = "570aeb9575f2cf44b82c6af78eafc44f6cafc1a68804da83e260284676069689"

URI_x86_64_v2_rust-similar+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+bytes-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+bytes-devel}"
SRC_URI[x86_64_v2_rust-similar+bytes-devel.sha256sum] = "cb45950833544f4153144ab00bc6ca6aa6e2eb7852d168b8c8126769ff38adee"

URI_x86_64_v2_rust-similar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+default-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+default-devel}"
SRC_URI[x86_64_v2_rust-similar+default-devel.sha256sum] = "85faf0cef991c93d7fa4645023c3cb3583ababdabad139f65d3222d14ee71b6c"

URI_x86_64_v2_rust-similar+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+hashbrown-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-similar+hashbrown-devel.sha256sum] = "9cb7898cc6219b44fcf8d121f586f7ef1e0f8a0dc59bdd921b81040966d7d382"

URI_x86_64_v2_rust-similar+inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+inline-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+inline-devel}"
SRC_URI[x86_64_v2_rust-similar+inline-devel.sha256sum] = "8bc33cbfdee874c5dabb1446c34ffc1c15eb032f7d42cf0e6ef504e2a3f60276"

URI_x86_64_v2_rust-similar+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+serde-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+serde-devel}"
SRC_URI[x86_64_v2_rust-similar+serde-devel.sha256sum] = "4b70c83e59aadf34daaac0efe2141df6dc96d2b5119478ae191e34d6017c151e"

URI_x86_64_v2_rust-similar+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+std-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+std-devel}"
SRC_URI[x86_64_v2_rust-similar+std-devel.sha256sum] = "01ec9319476f27f6b6acba5ee4cc86d538507aa72018b41f055a9d7f26ac78b2"

URI_x86_64_v2_rust-similar+text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+text-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+text-devel}"
SRC_URI[x86_64_v2_rust-similar+text-devel.sha256sum] = "adbe724a9644f412be2181524305f52662003992987c60f0f2e0017dd0d70cdd"

URI_x86_64_v2_rust-similar+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+unicode-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+unicode-devel}"
SRC_URI[x86_64_v2_rust-similar+unicode-devel.sha256sum] = "4be01342b53f59e68027c4dc0e65a322939d3e38fe9ab07152612181c4c00452"

URI_x86_64_v2_rust-similar+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+unicode-segmentation-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-similar+unicode-segmentation-devel.sha256sum] = "9bf9a85eeb7c8b3879b341fe2346bf7927767c435e66551a453daf2bd70ecb9f"

URI_x86_64_v2_rust-similar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar-devel}"
SRC_URI[x86_64_v2_rust-similar-devel.sha256sum] = "d88fdfd4118d70da9441b1aed86b04a0fb59d9ce6cd88644aa6f4caf49270d57"

URI_aarch64_rust-similar+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+bstr-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-similar+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+bstr-devel}"
SRC_URI[aarch64_rust-similar+bstr-devel.sha256sum] = "900a7305d7e677dc609c912b803c453781e9b8a375a9a6e98e0f25cae97f5952"

URI_aarch64_rust-similar+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+bytes-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-similar+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+bytes-devel}"
SRC_URI[aarch64_rust-similar+bytes-devel.sha256sum] = "537b9326cb2248ec416fee9c8f725bde7032af33f2a129233b2206b6d95d64ba"

URI_aarch64_rust-similar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+default-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-similar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+default-devel}"
SRC_URI[aarch64_rust-similar+default-devel.sha256sum] = "f58f558b67e0df0eecfd75e0f70f825874b75dbe3b36e48e21a2c9b10ad4a485"

URI_aarch64_rust-similar+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+hashbrown-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-similar+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+hashbrown-devel}"
SRC_URI[aarch64_rust-similar+hashbrown-devel.sha256sum] = "547c316cdc18c62fa9b82a3a77a603463d1303b7a18b1080f5cbee18627a17b1"

URI_aarch64_rust-similar+inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+inline-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-similar+inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+inline-devel}"
SRC_URI[aarch64_rust-similar+inline-devel.sha256sum] = "73728355e47265b72da62fc3869e8408acdd0d996d740d43bf2bb39bd9d06541"

URI_aarch64_rust-similar+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+serde-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-similar+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+serde-devel}"
SRC_URI[aarch64_rust-similar+serde-devel.sha256sum] = "c4a50291508494308556d1bec4e3aa02585610c1ce36e193d5d2d8912e9b7398"

URI_aarch64_rust-similar+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+std-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-similar+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+std-devel}"
SRC_URI[aarch64_rust-similar+std-devel.sha256sum] = "350ee941c35f94f437375a3a8e79be2fcd448acf889d3619cd8d4c7911e94c2d"

URI_aarch64_rust-similar+text-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+text-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-similar+text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+text-devel}"
SRC_URI[aarch64_rust-similar+text-devel.sha256sum] = "2050b112fd366c86aa27498574a86604776e0c6910ae447c4abadbeda31cad8a"

URI_aarch64_rust-similar+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+unicode-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-similar+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+unicode-devel}"
SRC_URI[aarch64_rust-similar+unicode-devel.sha256sum] = "6e22c962a888214032287656644b20bf503dd0a50fbccc86c77f17703317bf51"

URI_aarch64_rust-similar+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+unicode-segmentation-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-similar+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-similar+unicode-segmentation-devel.sha256sum] = "9acdf39712fe781e9d491af951c4b1522cb76fd7bf4b8ddd2663f4b1291669b4"

URI_aarch64_rust-similar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-similar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar-devel}"
SRC_URI[aarch64_rust-similar-devel.sha256sum] = "615ba5447ae5fb11539686f0e97aa6c3ad907fbd7553c96e8713181778416237"

RDEPENDS:rust-similar+bstr-devel = " \
 cargo \
 rust-bstr-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+bytes-devel = " \
 cargo \
 rust-similar+bstr-devel \
 rust-similar+text-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+default-devel = " \
 cargo \
 rust-similar+std-devel \
 rust-similar+text-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+inline-devel = " \
 cargo \
 rust-similar+text-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+serde-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+std-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+text-devel = " \
 cargo \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+unicode-devel = " \
 cargo \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-similar+text-devel \
 rust-similar+unicode-segmentation-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+unicode-segmentation-devel = " \
 cargo \
 rust-similar-devel \
 rust-unicode-segmentation+default-devel \
 "
RDEPENDS:rust-similar-devel = " \
 cargo \
 rust \
 "
