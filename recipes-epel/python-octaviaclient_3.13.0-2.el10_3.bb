# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-octaviaclient"
PV = "3.13.0"
PR = "2.el10_3"
PACKAGES = " \
 python3-octaviaclient \
 python3-octaviaclient-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-octaviaclient-3.13.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e7a51f64a1ceec15e226e76304d04ebdf0bc3bd7c936658180f2cadfeeb260f"

URI_x86_64_v2_python3-octaviaclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-octaviaclient-3.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-octaviaclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-octaviaclient}"
SRC_URI[x86_64_v2_python3-octaviaclient.sha256sum] = "51193af3a23dc54ebdfe444dd518c9827cadf1c78cee97a0539914fce209d69b"

URI_x86_64_v2_python3-octaviaclient-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-octaviaclient-tests-3.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-octaviaclient-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-octaviaclient-tests}"
SRC_URI[x86_64_v2_python3-octaviaclient-tests.sha256sum] = "32675b8b4d8ebd19b5b3ba4d1267a2b789a6311b7e6e61a6b2b2223afdf95ba0"

URI_aarch64_python3-octaviaclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-octaviaclient-3.13.0-2.el10_3.noarch.rpm;name=aarch64_python3-octaviaclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-octaviaclient}"
SRC_URI[aarch64_python3-octaviaclient.sha256sum] = "bf242123e506c726e40330d51cad1ca1496b61f397f12de7a838868638ed278a"

URI_aarch64_python3-octaviaclient-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-octaviaclient-tests-3.13.0-2.el10_3.noarch.rpm;name=aarch64_python3-octaviaclient-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-octaviaclient-tests}"
SRC_URI[aarch64_python3-octaviaclient-tests.sha256sum] = "b4a8717602c3b759aec33e541509ac68bbf1a0caf9e85b88485aac0cf3d25c4d"

RDEPENDS:python3-octaviaclient = " \
 python3 \
 python3-cliff \
 python3-keystoneauth1 \
 python3-openstackclient \
 python3-osc-lib \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-requests \
 "
RDEPENDS:python3-octaviaclient-tests = " \
 python3 \
 python3-fixtures \
 python3-octaviaclient \
 python3-openstackclient \
 python3-osc-lib \
 python3-oslo-log \
 python3-stestr \
 python3-subunit \
 python3-testtools \
 python3-webob \
 "
