# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree_magic_db"
PV = "3.0.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree_magic_db+default-devel \
 rust-tree_magic_db-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree_magic_db-3.0.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82a917858fcdafeee7b31d7fd92aec79d30e08a9e1541f68462a7251f7a4d2c9"

URI_x86_64_v2_rust-tree_magic_db+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree_magic_db+default-devel-3.0.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree_magic_db+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree_magic_db+default-devel}"
SRC_URI[x86_64_v2_rust-tree_magic_db+default-devel.sha256sum] = "46336ec01de9438757a1268ca2f1575cf7a4312ee66541807308dea7e88e2d5e"

URI_x86_64_v2_rust-tree_magic_db-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree_magic_db-devel-3.0.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree_magic_db-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree_magic_db-devel}"
SRC_URI[x86_64_v2_rust-tree_magic_db-devel.sha256sum] = "f0974fe3961a1347f5af5c4159f1f0f1d0029b83f66515cfeedf05861ef0165f"

URI_aarch64_rust-tree_magic_db+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree_magic_db+default-devel-3.0.1-2.el10_0.noarch.rpm;name=aarch64_rust-tree_magic_db+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree_magic_db+default-devel}"
SRC_URI[aarch64_rust-tree_magic_db+default-devel.sha256sum] = "84e527fa19db96c360bc275a17cc4d9faf9545ec737e9ffccf6e807411092d57"

URI_aarch64_rust-tree_magic_db-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree_magic_db-devel-3.0.1-2.el10_0.noarch.rpm;name=aarch64_rust-tree_magic_db-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree_magic_db-devel}"
SRC_URI[aarch64_rust-tree_magic_db-devel.sha256sum] = "5184528b9e033ee95ed50362cfed39a6cbfa9c66c72519db0a17d767660e5d3f"

RDEPENDS:rust-tree_magic_db+default-devel = " \
 cargo \
 rust-tree_magic_db-devel \
 "
RDEPENDS:rust-tree_magic_db-devel = " \
 cargo \
 "
