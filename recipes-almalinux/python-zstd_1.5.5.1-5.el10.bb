# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-zstd"
PV = "1.5.5.1"
PR = "5.el10"
PACKAGES = " \
 python3-zstd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-zstd-1.5.5.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b99eb65db53ebd5f5f51283ce4e798f77a27dfc0ef4ba1516910ee31bb63e9c"

URI_x86_64_v2_python3-zstd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-zstd-1.5.5.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-zstd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zstd}"
SRC_URI[x86_64_v2_python3-zstd.sha256sum] = "4634cbc9770ac950e222ca53a72bcb2dca8a8634f2146359ff19f267409b22c7"

URI_aarch64_python3-zstd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-zstd-1.5.5.1-5.el10.aarch64.rpm;name=aarch64_python3-zstd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zstd}"
SRC_URI[aarch64_python3-zstd.sha256sum] = "f21699b39dded1eba787bfabea4da1df9e48b7272a1fe4887d62c7b096cb875c"

RDEPENDS:python3-zstd = " \
 glibc \
 libzstd \
 python3 \
 "
