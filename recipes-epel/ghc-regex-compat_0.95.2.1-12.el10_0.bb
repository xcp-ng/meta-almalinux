# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-regex-compat"
PV = "0.95.2.1"
PR = "12.el10_0"
PACKAGES = " \
 ghc-regex-compat \
 ghc-regex-compat-devel \
 ghc-regex-compat-doc \
 ghc-regex-compat-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-regex-compat-0.95.2.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a7fbc5c617b1540f132b4062ee90c17094c1dfbabd28eb2568adc0082d96966"

URI_x86_64_v2_ghc-regex-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-compat-0.95.2.1-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-compat}"
SRC_URI[x86_64_v2_ghc-regex-compat.sha256sum] = "79150de5918f6e145a118a3e91f27f2bc1df718a932e1e4aae2b905ff2fd3250"

URI_x86_64_v2_ghc-regex-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-compat-devel-0.95.2.1-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-compat-devel}"
SRC_URI[x86_64_v2_ghc-regex-compat-devel.sha256sum] = "49f3b4fc525d31fb80e6a84ba3f58fbcecd5a4384a885bcc6a8a588ecc70b19e"

URI_x86_64_v2_ghc-regex-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-compat-doc-0.95.2.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-regex-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-compat-doc}"
SRC_URI[x86_64_v2_ghc-regex-compat-doc.sha256sum] = "b498b653503b81786f2ba9a68f30b5584ff656ffb4cd837cefd73dfc322470c3"

URI_x86_64_v2_ghc-regex-compat-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-compat-prof-0.95.2.1-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-compat-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-compat-prof}"
SRC_URI[x86_64_v2_ghc-regex-compat-prof.sha256sum] = "aac6790081ad3a4446d0736a24ea45ce08b8c487eed8b3b69c5b7919cc3356a2"

URI_aarch64_ghc-regex-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-compat-0.95.2.1-12.el10_0.aarch64.rpm;name=aarch64_ghc-regex-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-compat}"
SRC_URI[aarch64_ghc-regex-compat.sha256sum] = "9aa5d74a4af3b9de5cde5ce264ecf609337d836447d25c03647a017a34050fa6"

URI_aarch64_ghc-regex-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-compat-devel-0.95.2.1-12.el10_0.aarch64.rpm;name=aarch64_ghc-regex-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-compat-devel}"
SRC_URI[aarch64_ghc-regex-compat-devel.sha256sum] = "a24e78c7bbc744d6d220471b9050a498546986c967de07a86ab2df02b8bcedba"

URI_aarch64_ghc-regex-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-compat-doc-0.95.2.1-12.el10_0.noarch.rpm;name=aarch64_ghc-regex-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-compat-doc}"
SRC_URI[aarch64_ghc-regex-compat-doc.sha256sum] = "dc27c4e6b130818e9b6c702e7980addbe299e8b71dff057014c4b5d14feec6cb"

URI_aarch64_ghc-regex-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-compat-prof-0.95.2.1-12.el10_0.aarch64.rpm;name=aarch64_ghc-regex-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-compat-prof}"
SRC_URI[aarch64_ghc-regex-compat-prof.sha256sum] = "b7d2860c0844b646550f0de64bc33dc1bdcc5d1ea885a696f428aa281d791726"

RDEPENDS:ghc-regex-compat = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-regex-base \
 ghc-regex-posix \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-regex-compat-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-regex-base-devel \
 ghc-regex-compat \
 ghc-regex-posix-devel \
 "
RDEPENDS:ghc-regex-compat-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-regex-compat-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-regex-base-prof \
 ghc-regex-compat-devel \
 ghc-regex-posix-prof \
 "
