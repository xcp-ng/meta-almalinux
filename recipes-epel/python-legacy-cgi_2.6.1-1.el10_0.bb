# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-legacy-cgi"
PV = "2.6.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-legacy-cgi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-legacy-cgi-2.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9d1f6c0f65da07a48ef13b5d37502566978d2a9964f4a2af675c044b33d6aaa"

URI_x86_64_v2_python3-legacy-cgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-legacy-cgi-2.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-legacy-cgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-legacy-cgi}"
SRC_URI[x86_64_v2_python3-legacy-cgi.sha256sum] = "fa9e4c7f44ee199af6d8c8ab651a95b1b5588dc63381f760f2d248fd1523cf68"

URI_aarch64_python3-legacy-cgi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-legacy-cgi-2.6.1-1.el10_0.noarch.rpm;name=aarch64_python3-legacy-cgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-legacy-cgi}"
SRC_URI[aarch64_python3-legacy-cgi.sha256sum] = "3a2d60d2632c70b685ef3aa7e677d8706b57c7089b9d3e1ab0ffa69e9aaec37f"

RDEPENDS:python3-legacy-cgi = " \
 python3 \
 "
