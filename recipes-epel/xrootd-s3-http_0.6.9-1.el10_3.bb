# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xrootd-s3-http"
PV = "0.6.9"
PR = "1.el10_3"
PACKAGES = " \
 xrootd-s3-http \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xrootd-s3-http-0.6.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56c454db530e72d5f60a150a3814f307f5d83b4fe8388188617bff51141a1618"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - xrootd-s3-http: libXrdServer.so.6()(64bit)
# - xrootd-s3-http: libXrdUtils.so.6()(64bit)
# - xrootd-s3-http: xrootd-server

URI_x86_64_v2_xrootd-s3-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-s3-http-0.6.9-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-s3-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-s3-http}"
SRC_URI[x86_64_v2_xrootd-s3-http.sha256sum] = "9e9513fedf4bbd41431d78a37e92b911effb88f440b0d26e6405564ba42e4b8c"

URI_aarch64_xrootd-s3-http = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-s3-http-0.6.9-1.el10_3.aarch64.rpm;name=aarch64_xrootd-s3-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-s3-http}"
SRC_URI[aarch64_xrootd-s3-http.sha256sum] = "a253f87997d3d8e8121f7bfefdd70dcaa9b1f6e0deb62e2bc019e34a13854ff2"

RDEPENDS:xrootd-s3-http:x86_64_v2 = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 tinyxml2 \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:xrootd-s3-http:aarch64 = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 tinyxml2 \
 virtual/libcurl.so.4___64bit_ \
 xrootd-libs \
 xrootd-server \
 xrootd-server-libs \
"
