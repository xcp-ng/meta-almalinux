# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rusqlite"
PV = "0.31.0"
PR = "6.el10_1"
PACKAGES = " \
 rust-rusqlite+array-devel \
 rust-rusqlite+backup-devel \
 rust-rusqlite+blob-devel \
 rust-rusqlite+buildtime_bindgen-devel \
 rust-rusqlite+chrono-devel \
 rust-rusqlite+collation-devel \
 rust-rusqlite+column_decltype-devel \
 rust-rusqlite+csv-devel \
 rust-rusqlite+csvtab-devel \
 rust-rusqlite+default-devel \
 rust-rusqlite+extra_check-devel \
 rust-rusqlite+functions-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite+i128_blob-devel \
 rust-rusqlite+limits-devel \
 rust-rusqlite+load_extension-devel \
 rust-rusqlite+modern-full-devel \
 rust-rusqlite+modern_sqlite-devel \
 rust-rusqlite+release_memory-devel \
 rust-rusqlite+serde_json-devel \
 rust-rusqlite+serialize-devel \
 rust-rusqlite+series-devel \
 rust-rusqlite+session-devel \
 rust-rusqlite+time-devel \
 rust-rusqlite+trace-devel \
 rust-rusqlite+unlock_notify-devel \
 rust-rusqlite+url-devel \
 rust-rusqlite+uuid-devel \
 rust-rusqlite+vtab-devel \
 rust-rusqlite+window-devel \
 rust-rusqlite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rusqlite-0.31.0-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68ee152c1dfc5ceec7534918ec1a48ba65a0b9b10ff8afa4a6d7789d83d00668"

URI_x86_64_v2_rust-rusqlite+array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+array-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+array-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+array-devel.sha256sum] = "7a226f87c63333e20f53aa017cd9d8bb783ebe741a379b91e53a5e7dd4ba2962"

URI_x86_64_v2_rust-rusqlite+backup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+backup-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+backup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+backup-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+backup-devel.sha256sum] = "6b2b4568a827ae530c95cf3defeac154b50309d8d946e819d222f9c8d334d848"

URI_x86_64_v2_rust-rusqlite+blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+blob-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+blob-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+blob-devel.sha256sum] = "2c449c94032c3fd7ef9655246d4f4207801bea90d6e424a73657ce944f0af8d9"

URI_x86_64_v2_rust-rusqlite+buildtime_bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+buildtime_bindgen-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+buildtime_bindgen-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+buildtime_bindgen-devel.sha256sum] = "a965685c048364dca2531a03773106736041280d21c1734a9515fea4791595dd"

URI_x86_64_v2_rust-rusqlite+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+chrono-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+chrono-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+chrono-devel.sha256sum] = "a1584221657642e69158ddf955f1b1043bb4076263945697e7a1c2ef4d09522b"

URI_x86_64_v2_rust-rusqlite+collation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+collation-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+collation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+collation-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+collation-devel.sha256sum] = "b3c6a1460ba2dfa2c6524493d49d29e3f010c6432f5676e70b88085bd064db26"

URI_x86_64_v2_rust-rusqlite+column_decltype-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+column_decltype-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+column_decltype-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+column_decltype-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+column_decltype-devel.sha256sum] = "1cd4bb71d07324751b48ffa634fb6a177c71e3b818cb5a921483618accf6cacb"

URI_x86_64_v2_rust-rusqlite+csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+csv-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+csv-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+csv-devel.sha256sum] = "c14a0b4a2fed4d40482e06e3d4657dabaed3677ff0fb96174d8754b27df5ec27"

URI_x86_64_v2_rust-rusqlite+csvtab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+csvtab-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+csvtab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+csvtab-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+csvtab-devel.sha256sum] = "7098aa1aaa4845fce58c3119c1ad1613c28d62a3207ec4d624da5e4457881831"

URI_x86_64_v2_rust-rusqlite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+default-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+default-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+default-devel.sha256sum] = "7967090af838d9b832b9fb8938cf1730bc177e9313d5512ada6c61073df440d5"

URI_x86_64_v2_rust-rusqlite+extra_check-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+extra_check-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+extra_check-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+extra_check-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+extra_check-devel.sha256sum] = "5f9f613ee2827aac0785eef8e5c13e4dd86d7455c186b8ab7571b94c3b0fe454"

URI_x86_64_v2_rust-rusqlite+functions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+functions-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+functions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+functions-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+functions-devel.sha256sum] = "0f2a8a7d1edd7ddf36a2c1100a55debb1a77a05a785bc9ea717185cca080674f"

URI_x86_64_v2_rust-rusqlite+hooks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+hooks-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+hooks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+hooks-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+hooks-devel.sha256sum] = "a45a2ccc6aca84e847b5e8f85d82297d94a1edf27527da9d2c84483867ff9785"

URI_x86_64_v2_rust-rusqlite+i128_blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+i128_blob-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+i128_blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+i128_blob-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+i128_blob-devel.sha256sum] = "117e27a97e60eee9b98dd91e48c5cf0aaf216228e12150d7fceaf4e674f7857c"

URI_x86_64_v2_rust-rusqlite+limits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+limits-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+limits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+limits-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+limits-devel.sha256sum] = "3db0cc37c16edce37e3e9fa253cfac7b4106aab6a476fddadc296a107238a4b5"

URI_x86_64_v2_rust-rusqlite+load_extension-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+load_extension-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+load_extension-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+load_extension-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+load_extension-devel.sha256sum] = "ad0243aef8f275064b7d01318570e38fbe15497b5a9a45faa73a749550ba8435"

URI_x86_64_v2_rust-rusqlite+modern-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+modern-full-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+modern-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+modern-full-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+modern-full-devel.sha256sum] = "7d436b004051e0bf53b6a5b24f80087246ce82a15c1f2185f8eb204579c20f42"

URI_x86_64_v2_rust-rusqlite+modern_sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+modern_sqlite-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+modern_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+modern_sqlite-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+modern_sqlite-devel.sha256sum] = "0eb5acb840dc170c0345c7ff08796ba31de41694a561149ad0ccf3315273951d"

URI_x86_64_v2_rust-rusqlite+release_memory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+release_memory-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+release_memory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+release_memory-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+release_memory-devel.sha256sum] = "1a34d1be43ae14b10263eae487974185b6ffa68d1bfe19f328a201b69fe449be"

URI_x86_64_v2_rust-rusqlite+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+serde_json-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+serde_json-devel.sha256sum] = "a3fb3798c77fc33658422099311662a8d1c8b86c7b608fc81ab5d7ffacaf643f"

URI_x86_64_v2_rust-rusqlite+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+serialize-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+serialize-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+serialize-devel.sha256sum] = "735936a76422acd9442cfe9ba52997d500c2b63cde768f242aac94b3c68421ae"

URI_x86_64_v2_rust-rusqlite+series-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+series-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+series-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+series-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+series-devel.sha256sum] = "38d6d49d4e22063a32cd177e5d422f18e586112b1f2c3485ea49fd431071ea7a"

URI_x86_64_v2_rust-rusqlite+session-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+session-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+session-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+session-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+session-devel.sha256sum] = "87fd4d825c81ced70c00a30c8e371a04268bf99ff276f765dd6baebf3687af10"

URI_x86_64_v2_rust-rusqlite+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+time-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+time-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+time-devel.sha256sum] = "9f98e780b85d21e2518a85564212411850264978e3764408047df7dba14d4458"

URI_x86_64_v2_rust-rusqlite+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+trace-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+trace-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+trace-devel.sha256sum] = "97a0ccaab438c9a91460bdc11368036d8a83cbde87ab9a347242ad81e9709c97"

URI_x86_64_v2_rust-rusqlite+unlock_notify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+unlock_notify-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+unlock_notify-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+unlock_notify-devel.sha256sum] = "4114a292bc05be024dcac80863b279282dd0159a96f82d55464502455c34fe3b"

URI_x86_64_v2_rust-rusqlite+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+url-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+url-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+url-devel.sha256sum] = "4625984367cd2b374fd0c15306ec9e2e5bb6b33db7f7ce693d6dcddeffdb8cef"

URI_x86_64_v2_rust-rusqlite+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+uuid-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+uuid-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+uuid-devel.sha256sum] = "535d416ba93062b1160f470effbc40c9dc6f3dd7f7e87d39a40380afce8a4bd9"

URI_x86_64_v2_rust-rusqlite+vtab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+vtab-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+vtab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+vtab-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+vtab-devel.sha256sum] = "4dd3fa9f2517eb948ea9f4489186addc54e9879e358db2f3e65bdf3b3ef89751"

URI_x86_64_v2_rust-rusqlite+window-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+window-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+window-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+window-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+window-devel.sha256sum] = "a8117278b72c73f5f167214d394cac72f849c5feb0f4996e55fa67a9affc8c81"

URI_x86_64_v2_rust-rusqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite-devel-0.31.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite-devel}"
SRC_URI[x86_64_v2_rust-rusqlite-devel.sha256sum] = "e1b40baa4e4bae7f23e2727c056da45de989f6bb172be4d6d6c60f2ab4513c5f"

URI_aarch64_rust-rusqlite+array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+array-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+array-devel}"
SRC_URI[aarch64_rust-rusqlite+array-devel.sha256sum] = "4830f0802b3820f9ec3f6556e8fc7754e9546c2bd1ad0642b71607ce6b7bcade"

URI_aarch64_rust-rusqlite+backup-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+backup-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+backup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+backup-devel}"
SRC_URI[aarch64_rust-rusqlite+backup-devel.sha256sum] = "a3b9eb1897b04c378ac72c205bdb2870a6a033ce93ee9e552a26ebc7c1096922"

URI_aarch64_rust-rusqlite+blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+blob-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+blob-devel}"
SRC_URI[aarch64_rust-rusqlite+blob-devel.sha256sum] = "4b545a71beb10f35be45e7ac8724ecfb788a7d043abad402a740783ef4c60878"

URI_aarch64_rust-rusqlite+buildtime_bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+buildtime_bindgen-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+buildtime_bindgen-devel}"
SRC_URI[aarch64_rust-rusqlite+buildtime_bindgen-devel.sha256sum] = "ca70cc7c21816bef17a069057ae1657447ec6df50cf44dac425aaae7ce9ea3b9"

URI_aarch64_rust-rusqlite+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+chrono-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+chrono-devel}"
SRC_URI[aarch64_rust-rusqlite+chrono-devel.sha256sum] = "c2d524cff92b7d13451133770272cb754822ec737a6f0e55fecfde3dd0ecbfac"

URI_aarch64_rust-rusqlite+collation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+collation-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+collation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+collation-devel}"
SRC_URI[aarch64_rust-rusqlite+collation-devel.sha256sum] = "503f160a3ce4b24cf0ecbdbbb42e52312eaec316181a13c7f048a0ea5fca24e2"

URI_aarch64_rust-rusqlite+column_decltype-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+column_decltype-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+column_decltype-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+column_decltype-devel}"
SRC_URI[aarch64_rust-rusqlite+column_decltype-devel.sha256sum] = "4bc0c5b0d96487856ca573cedbd9db78329f4e28e5904e63038d0eb7874282bb"

URI_aarch64_rust-rusqlite+csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+csv-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+csv-devel}"
SRC_URI[aarch64_rust-rusqlite+csv-devel.sha256sum] = "912de4dc18d86c2dab34609a5640118c30cdaf9c817fee1754138b7a17cd4e10"

URI_aarch64_rust-rusqlite+csvtab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+csvtab-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+csvtab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+csvtab-devel}"
SRC_URI[aarch64_rust-rusqlite+csvtab-devel.sha256sum] = "4e33db4760e76b57d17590bb7ab4a8907efe7f07447152d57573a50154b3f08a"

URI_aarch64_rust-rusqlite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+default-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+default-devel}"
SRC_URI[aarch64_rust-rusqlite+default-devel.sha256sum] = "58cfa3e25732f50ed750742c67e0da647e4545812807e8c4fca3424fd09204d6"

URI_aarch64_rust-rusqlite+extra_check-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+extra_check-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+extra_check-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+extra_check-devel}"
SRC_URI[aarch64_rust-rusqlite+extra_check-devel.sha256sum] = "cb92819cc1e10a40572ed91cbbafde44896fb32877588535118224bf8e3a7cec"

URI_aarch64_rust-rusqlite+functions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+functions-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+functions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+functions-devel}"
SRC_URI[aarch64_rust-rusqlite+functions-devel.sha256sum] = "2cf0ec2f9ac46983d3a15d396c44d1de6ec1732edaca2669aa8f2c767dd52a59"

URI_aarch64_rust-rusqlite+hooks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+hooks-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+hooks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+hooks-devel}"
SRC_URI[aarch64_rust-rusqlite+hooks-devel.sha256sum] = "30923c60f0ec788f61c42d6d032d54b5091e20b1b18f52f6deee5f1491ce042e"

URI_aarch64_rust-rusqlite+i128_blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+i128_blob-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+i128_blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+i128_blob-devel}"
SRC_URI[aarch64_rust-rusqlite+i128_blob-devel.sha256sum] = "1e7a7a837796559aadac8f54567ef3dc60d1ede682d7d5d7d6e35bff6195def7"

URI_aarch64_rust-rusqlite+limits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+limits-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+limits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+limits-devel}"
SRC_URI[aarch64_rust-rusqlite+limits-devel.sha256sum] = "b5ba92ae48a8cf4a582ccd8d208eb82d4f4743583791fc99e56815043bcc5511"

URI_aarch64_rust-rusqlite+load_extension-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+load_extension-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+load_extension-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+load_extension-devel}"
SRC_URI[aarch64_rust-rusqlite+load_extension-devel.sha256sum] = "e089f71f64e77318dbcfa0302c7f3a70eceda37c0e93c2a3b889741976827c1b"

URI_aarch64_rust-rusqlite+modern-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+modern-full-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+modern-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+modern-full-devel}"
SRC_URI[aarch64_rust-rusqlite+modern-full-devel.sha256sum] = "7e3a6f8d60df0a4b6d6f79ff03bf8a086a715c9aeaf43873ee0ee3650476001f"

URI_aarch64_rust-rusqlite+modern_sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+modern_sqlite-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+modern_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+modern_sqlite-devel}"
SRC_URI[aarch64_rust-rusqlite+modern_sqlite-devel.sha256sum] = "75c64743f9756566a9b6bd64101efff5904112fd635b9d97a3316dfa93ceef80"

URI_aarch64_rust-rusqlite+release_memory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+release_memory-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+release_memory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+release_memory-devel}"
SRC_URI[aarch64_rust-rusqlite+release_memory-devel.sha256sum] = "bec38bd51ec37456a064043ed2c9853253b1e1970f2764d0e4047e9c142814b3"

URI_aarch64_rust-rusqlite+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+serde_json-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+serde_json-devel}"
SRC_URI[aarch64_rust-rusqlite+serde_json-devel.sha256sum] = "70f8355988e0ed5f6fd2fc3b1fb47cd0013e84317b95405bab8ae3ba967fcb80"

URI_aarch64_rust-rusqlite+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+serialize-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+serialize-devel}"
SRC_URI[aarch64_rust-rusqlite+serialize-devel.sha256sum] = "f1b8f11a9f8dd41bd6693fa6d394ee586ca5994cb324f93fd9e79bdfbac95746"

URI_aarch64_rust-rusqlite+series-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+series-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+series-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+series-devel}"
SRC_URI[aarch64_rust-rusqlite+series-devel.sha256sum] = "355c2d992c15850678200e74fccb8b442949086b76f55695bbc32dfcae3d3941"

URI_aarch64_rust-rusqlite+session-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+session-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+session-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+session-devel}"
SRC_URI[aarch64_rust-rusqlite+session-devel.sha256sum] = "65e3d5292323fab4c1fad287cbe7cc0396ca1e2e45306f21d67c9710d47e189a"

URI_aarch64_rust-rusqlite+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+time-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+time-devel}"
SRC_URI[aarch64_rust-rusqlite+time-devel.sha256sum] = "9fa25a5f30690acf825c9e8742339cb492ed3a59399da6c65804926088352f28"

URI_aarch64_rust-rusqlite+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+trace-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+trace-devel}"
SRC_URI[aarch64_rust-rusqlite+trace-devel.sha256sum] = "a8f5901815a09d5a0a8dc738ffd5e07e65fb739e11bde7762e9cab5699f258ea"

URI_aarch64_rust-rusqlite+unlock_notify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+unlock_notify-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+unlock_notify-devel}"
SRC_URI[aarch64_rust-rusqlite+unlock_notify-devel.sha256sum] = "15f10c194b005ae21c1fd5bfd4e127464c5766abe40555c83a774695385ad222"

URI_aarch64_rust-rusqlite+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+url-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+url-devel}"
SRC_URI[aarch64_rust-rusqlite+url-devel.sha256sum] = "5e391a47e377d68ee0c955303c8cf4dd9b91dbf47bc3799f3dfcc14d7c381544"

URI_aarch64_rust-rusqlite+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+uuid-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+uuid-devel}"
SRC_URI[aarch64_rust-rusqlite+uuid-devel.sha256sum] = "3ba99290aba1c87bdb1f41505fc742560d9fe0de5cc5830ae459ec55681b1233"

URI_aarch64_rust-rusqlite+vtab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+vtab-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+vtab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+vtab-devel}"
SRC_URI[aarch64_rust-rusqlite+vtab-devel.sha256sum] = "375d07efe75b5822f924b40b0cbc6a668f0fb5c28d808a72803161b9f96bed09"

URI_aarch64_rust-rusqlite+window-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+window-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite+window-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+window-devel}"
SRC_URI[aarch64_rust-rusqlite+window-devel.sha256sum] = "253379c47edefa4a4b6b6f8ae43d35d6f39edcd1ad317d37726400b3342b03ee"

URI_aarch64_rust-rusqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite-devel-0.31.0-6.el10_1.noarch.rpm;name=aarch64_rust-rusqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite-devel}"
SRC_URI[aarch64_rust-rusqlite-devel.sha256sum] = "fb698ca4e3ea69ca1b6ae3fc8be98b665d6d89c8301687b8730a3caffd891753"

RDEPENDS:rust-rusqlite+array-devel = " \
 cargo \
 rust-rusqlite+vtab-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+backup-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+blob-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+buildtime_bindgen-devel = " \
 cargo \
 rust-libsqlite3-sys+buildtime_bindgen-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+collation-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+column_decltype-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+csv-devel = " \
 cargo \
 rust-csv+default-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+csvtab-devel = " \
 cargo \
 rust-rusqlite+csv-devel \
 rust-rusqlite+vtab-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+default-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+extra_check-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+functions-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+hooks-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+i128_blob-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+limits-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+load_extension-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+modern-full-devel = " \
 cargo \
 rust-rusqlite+array-devel \
 rust-rusqlite+backup-devel \
 rust-rusqlite+blob-devel \
 rust-rusqlite+chrono-devel \
 rust-rusqlite+collation-devel \
 rust-rusqlite+column_decltype-devel \
 rust-rusqlite+csvtab-devel \
 rust-rusqlite+extra_check-devel \
 rust-rusqlite+functions-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite+i128_blob-devel \
 rust-rusqlite+limits-devel \
 rust-rusqlite+load_extension-devel \
 rust-rusqlite+modern_sqlite-devel \
 rust-rusqlite+serde_json-devel \
 rust-rusqlite+series-devel \
 rust-rusqlite+time-devel \
 rust-rusqlite+trace-devel \
 rust-rusqlite+unlock_notify-devel \
 rust-rusqlite+url-devel \
 rust-rusqlite+uuid-devel \
 rust-rusqlite+vtab-devel \
 rust-rusqlite+window-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+modern_sqlite-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+release_memory-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+serde_json-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-rusqlite+serialize-devel = " \
 cargo \
 rust-rusqlite+modern_sqlite-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+series-devel = " \
 cargo \
 rust-rusqlite+vtab-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+session-devel = " \
 cargo \
 rust-libsqlite3-sys+session-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+time-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-rusqlite+trace-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+unlock_notify-devel = " \
 cargo \
 rust-libsqlite3-sys+unlock_notify-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+url-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-url+default-devel \
 "
RDEPENDS:rust-rusqlite+uuid-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-rusqlite+vtab-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+window-devel = " \
 cargo \
 rust-rusqlite+functions-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-fallible-iterator+default-devel \
 rust-fallible-streaming-iterator+default-devel \
 rust-hashlink+default-devel \
 rust-libsqlite3-sys+default-devel \
 rust-smallvec+default-devel \
 "
