# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mce-inject"
PV = "0^20241112git"
PR = "1.el10_1"
PACKAGES = " \
 mce-inject \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mce-inject-0^20241112git-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fc9f0dc2bdc0fcae8447a128bfb293ac08af9a38ba7b15fdd5fd7ce1c2b70fc"

URI_x86_64_v2_mce-inject = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mce-inject-0^20241112git-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mce-inject;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mce-inject}"
SRC_URI[x86_64_v2_mce-inject.sha256sum] = "cbcbd71234350371ad7abfdbd4dc91e52b7ca9965dfa21c26e4a9de99c0d9527"

URI_aarch64_mce-inject = "${EPEL_MIRROR}/aarch64/Packages/m/mce-inject-0^20241112git-1.el10_1.aarch64.rpm;name=aarch64_mce-inject;unpack=0"
SRC_URI:append = " ${URI_aarch64_mce-inject}"
SRC_URI[aarch64_mce-inject.sha256sum] = "0e7dc59392d35141b4f07bb10f72307cc7c3e33d1935785504b86f90a2eec745"

RDEPENDS:mce-inject = " \
 glibc \
 "
