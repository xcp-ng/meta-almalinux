# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-foldhash"
PV = "0.2.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-foldhash+default-devel \
 rust-foldhash+std-devel \
 rust-foldhash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-foldhash-0.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73992467c835ba2e70e6cc895de7468d86734767fb996974ca5414def3863a89"

URI_x86_64_v2_rust-foldhash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash+default-devel-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash+default-devel}"
SRC_URI[x86_64_v2_rust-foldhash+default-devel.sha256sum] = "1fbb5a6378c663455eed1e0be4b12428a0d769e35fd33c9bb6daac04f07d3921"

URI_x86_64_v2_rust-foldhash+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash+std-devel-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash+std-devel}"
SRC_URI[x86_64_v2_rust-foldhash+std-devel.sha256sum] = "9eb958436071855496a6daf283a82ac9d2f2c285b9bcf74fdf919024fc26c5e9"

URI_x86_64_v2_rust-foldhash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash-devel-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash-devel}"
SRC_URI[x86_64_v2_rust-foldhash-devel.sha256sum] = "b7ba92c69ca7c3da38e136d002d269d2bd2289abdcc137af2b123a963588689b"

URI_aarch64_rust-foldhash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash+default-devel-0.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-foldhash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash+default-devel}"
SRC_URI[aarch64_rust-foldhash+default-devel.sha256sum] = "1384a6be1a16be3995abc03eeffb10bdf6e16a9e9c5ccd63fb461bc07a6f4f34"

URI_aarch64_rust-foldhash+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash+std-devel-0.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-foldhash+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash+std-devel}"
SRC_URI[aarch64_rust-foldhash+std-devel.sha256sum] = "0bdab1ebea4564f54bb60d7bfdf8de22ba94978919a9e97bf86a12bc3b28153e"

URI_aarch64_rust-foldhash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash-devel-0.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-foldhash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash-devel}"
SRC_URI[aarch64_rust-foldhash-devel.sha256sum] = "5a3930833efb5aacde73e53414ac3e3902d69e92bfadb535fd6630ac0e1d3de5"

RDEPENDS:rust-foldhash+default-devel = " \
 cargo \
 rust-foldhash+std-devel \
 rust-foldhash-devel \
 "
RDEPENDS:rust-foldhash+std-devel = " \
 cargo \
 rust-foldhash-devel \
 "
RDEPENDS:rust-foldhash-devel = " \
 cargo \
 rust \
 "
