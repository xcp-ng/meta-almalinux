# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "superlu_dist"
PE = "1"
PV = "8.2.0"
PR = "10.el10_2"
PACKAGES = " \
 superlu_dist-doc \
 superlu_dist-mpich \
 superlu_dist-mpich-devel \
 superlu_dist-openmpi \
 superlu_dist-openmpi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/superlu_dist-8.2.0-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "817156b9f847c33912619512869d7ecbc27d2dd5615c492d3e2bb1dcf733da45"

URI_x86_64_v2_superlu_dist-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-doc-8.2.0-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_superlu_dist-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-doc}"
SRC_URI[x86_64_v2_superlu_dist-doc.sha256sum] = "e9dcf40c419869dce282ed92f4fb7e080f388a0eb17d979a0a7c2eae8482ac60"

URI_x86_64_v2_superlu_dist-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-mpich-8.2.0-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_superlu_dist-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-mpich}"
SRC_URI[x86_64_v2_superlu_dist-mpich.sha256sum] = "426ff836b5231fb2457c8d898f408ea24ee6421da6bd12e72c9ca6d0861373ae"

URI_x86_64_v2_superlu_dist-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-mpich-devel-8.2.0-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_superlu_dist-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-mpich-devel}"
SRC_URI[x86_64_v2_superlu_dist-mpich-devel.sha256sum] = "da7123c9a78cd2981edfad54e29ef9b6f4e69fc23922afc0fd5857b70c6360db"

URI_x86_64_v2_superlu_dist-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-openmpi-8.2.0-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_superlu_dist-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-openmpi}"
SRC_URI[x86_64_v2_superlu_dist-openmpi.sha256sum] = "6e54c03eaceede5fc5880419a7c5266eb3609ddcbf946e6dcc9668532c23e64a"

URI_x86_64_v2_superlu_dist-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-openmpi-devel-8.2.0-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_superlu_dist-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-openmpi-devel}"
SRC_URI[x86_64_v2_superlu_dist-openmpi-devel.sha256sum] = "9a33dfa910905a9317f0fe8dec9b1118a1c68d40d0afb5b6cfa65b5f222b13bc"

URI_aarch64_superlu_dist-doc = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-doc-8.2.0-10.el10_2.noarch.rpm;name=aarch64_superlu_dist-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-doc}"
SRC_URI[aarch64_superlu_dist-doc.sha256sum] = "237db92e899ef4a035d2a1e0dc5fb575dc4f7a0a4a387751c91ae94c366d874b"

URI_aarch64_superlu_dist-mpich = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-mpich-8.2.0-10.el10_2.aarch64.rpm;name=aarch64_superlu_dist-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-mpich}"
SRC_URI[aarch64_superlu_dist-mpich.sha256sum] = "f9ced1b014339c1437de30a3fd814448b14e519a520beeb7d546b8fd91f714c8"

URI_aarch64_superlu_dist-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-mpich-devel-8.2.0-10.el10_2.aarch64.rpm;name=aarch64_superlu_dist-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-mpich-devel}"
SRC_URI[aarch64_superlu_dist-mpich-devel.sha256sum] = "b827eb718aa0909166244cda2a178aca3a0bc10ec356d295404300f8262739fa"

URI_aarch64_superlu_dist-openmpi = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-openmpi-8.2.0-10.el10_2.aarch64.rpm;name=aarch64_superlu_dist-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-openmpi}"
SRC_URI[aarch64_superlu_dist-openmpi.sha256sum] = "64d1e50f36dc2a96b6ae6c830e9404c710948f153a60aef13be6a31c041fda63"

URI_aarch64_superlu_dist-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-openmpi-devel-8.2.0-10.el10_2.aarch64.rpm;name=aarch64_superlu_dist-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-openmpi-devel}"
SRC_URI[aarch64_superlu_dist-openmpi-devel.sha256sum] = "1c06f9d763a6fe295fd9edbec8e057770a4a6031fab78e628e2aa974f1035521"

RDEPENDS:superlu_dist-doc = " \
 "
RDEPENDS:superlu_dist-mpich = " \
 flexiblas-netlib \
 gcc-gfortran \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 metis \
 mpich \
 ptscotch-mpich \
 "
RDEPENDS:superlu_dist-mpich-devel = " \
 mpich-devel \
 ptscotch-mpich-devel \
 ptscotch-mpich-devel-parmetis \
 superlu_dist-mpich \
 "
RDEPENDS:superlu_dist-openmpi = " \
 flexiblas-netlib \
 gcc-gfortran \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 metis \
 openmpi \
 ptscotch-openmpi \
 "
RDEPENDS:superlu_dist-openmpi-devel = " \
 openmpi-devel \
 superlu_dist-openmpi \
 "
