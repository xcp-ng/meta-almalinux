# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bash-completion"
PE = "1"
PV = "2.11"
PR = "16.el10"
PACKAGES = " \
 bash-completion \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/bash-completion-2.11-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1447cedc46abc1774682de98986ca42ccba0afc2a099db1b2ebab3517f08e417"

URI_x86_64_v2_bash-completion = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bash-completion-2.11-16.el10.noarch.rpm;name=x86_64_v2_bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bash-completion}"
SRC_URI[x86_64_v2_bash-completion.sha256sum] = "8f72586cb581dd5dffa1117cedc7adac41f97a3aa9211c3f101fc8ef7058209d"

URI_aarch64_bash-completion = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bash-completion-2.11-16.el10.noarch.rpm;name=aarch64_bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_bash-completion}"
SRC_URI[aarch64_bash-completion.sha256sum] = "8f72586cb581dd5dffa1117cedc7adac41f97a3aa9211c3f101fc8ef7058209d"

RDEPENDS:bash-completion = " \
 bash \
 pkgconf-pkg-config \
 "
