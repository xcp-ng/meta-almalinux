# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zbus_names"
PV = "4.3.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-zbus_names+default-devel \
 rust-zbus_names-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zbus_names-4.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "411e3c38d4fa03b78eaad9c19409b6b69f2461ace9053367c17f9d5da8f68daf"

URI_x86_64_v2_rust-zbus_names+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_names+default-devel-4.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_names+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_names+default-devel}"
SRC_URI[x86_64_v2_rust-zbus_names+default-devel.sha256sum] = "78fe3b6fb48a8078160d9dea775462e7c70b9df254f43ce135b0e1c17be4e02f"

URI_x86_64_v2_rust-zbus_names-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_names-devel-4.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_names-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_names-devel}"
SRC_URI[x86_64_v2_rust-zbus_names-devel.sha256sum] = "f61c2480d5e3680278e7a841e96273f9beb411c0de3863413862b99ec0c0a9d4"

URI_aarch64_rust-zbus_names+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_names+default-devel-4.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-zbus_names+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_names+default-devel}"
SRC_URI[aarch64_rust-zbus_names+default-devel.sha256sum] = "ee7c49fcb92ad16e5800bb6da66161cc38a362596bd26fb7676e8c138554fc3d"

URI_aarch64_rust-zbus_names-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_names-devel-4.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-zbus_names-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_names-devel}"
SRC_URI[aarch64_rust-zbus_names-devel.sha256sum] = "a11175e0a73515ad88a7c22541a92a2b46a0c86c7b08e19b5c484ead97417fd1"

RDEPENDS:rust-zbus_names+default-devel = " \
 cargo \
 rust-zbus_names-devel \
 "
RDEPENDS:rust-zbus_names-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-winnow+default-devel \
 rust-zvariant+default-devel \
 rust-zvariant+enumflags2-devel \
 "
