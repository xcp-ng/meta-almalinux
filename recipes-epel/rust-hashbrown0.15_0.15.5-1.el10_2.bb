# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashbrown0.15"
PV = "0.15.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-hashbrown0.15+allocator-api2-devel \
 rust-hashbrown0.15+default-devel \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15+equivalent-devel \
 rust-hashbrown0.15+inline-more-devel \
 rust-hashbrown0.15+raw-entry-devel \
 rust-hashbrown0.15+rayon-devel \
 rust-hashbrown0.15+serde-devel \
 rust-hashbrown0.15-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hashbrown0.15-0.15.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "decaa9cea93cf9c4dc2530e95fa68912abc3da743ba0c59a2a6d0a7e30a4a19b"

URI_x86_64_v2_rust-hashbrown0.15+allocator-api2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.15+allocator-api2-devel-0.15.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.15+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.15+allocator-api2-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.15+allocator-api2-devel.sha256sum] = "7f4344fbd0c9ff4578d93670f7206815efb4ec8b88b98b98dbf6bd3c48d9e5a5"

URI_x86_64_v2_rust-hashbrown0.15+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.15+default-devel-0.15.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.15+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.15+default-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.15+default-devel.sha256sum] = "aeba413fb13757bd21e588f24503f70f9099eebe3dae10eb1c8445052a2cc3d2"
RPROVIDES:rust-hashbrown0.15+default-devel:x86_64_v2 = "virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~"

URI_x86_64_v2_rust-hashbrown0.15+default-hasher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.15+default-hasher-devel-0.15.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.15+default-hasher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.15+default-hasher-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.15+default-hasher-devel.sha256sum] = "21106d6fa27e48a75c1383d6b4bca868fe42c38f7697bce4499609b3a6cd3e10"
RPROVIDES:rust-hashbrown0.15+default-hasher-devel:x86_64_v2 = "virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~"

URI_x86_64_v2_rust-hashbrown0.15+equivalent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.15+equivalent-devel-0.15.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.15+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.15+equivalent-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.15+equivalent-devel.sha256sum] = "31591cf6f27bd7dc1c959627ffd67df4d67eacc8ed7b1330c5381694cae19c67"

URI_x86_64_v2_rust-hashbrown0.15+inline-more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.15+inline-more-devel-0.15.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.15+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.15+inline-more-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.15+inline-more-devel.sha256sum] = "0c0e4861feedd3c1e3dc8d11ecd71211227f0b665e42d8fb7d65d47e71b4fc08"
RPROVIDES:rust-hashbrown0.15+inline-more-devel:x86_64_v2 = "virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~"

URI_x86_64_v2_rust-hashbrown0.15+raw-entry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.15+raw-entry-devel-0.15.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.15+raw-entry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.15+raw-entry-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.15+raw-entry-devel.sha256sum] = "57e690eece6c764dc3fcf1598bd36123efb84cd15af8d1a8af9113a85c0d4d92"

URI_x86_64_v2_rust-hashbrown0.15+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.15+rayon-devel-0.15.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.15+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.15+rayon-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.15+rayon-devel.sha256sum] = "9b10eef786f4366224400949b07d353caca00cbe8fda796040fc39490eebd75b"

URI_x86_64_v2_rust-hashbrown0.15+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.15+serde-devel-0.15.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.15+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.15+serde-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.15+serde-devel.sha256sum] = "3ca7518b4e8e1a8a5319b890a3bfebd405f18bc456c3e43d9e860decd1a8ea41"

URI_x86_64_v2_rust-hashbrown0.15-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.15-devel-0.15.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.15-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.15-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.15-devel.sha256sum] = "be1ebc60b951b2c13a82d64ba0e9e540b785d9c4f8f69a115934fc6f9214eb2a"
RPROVIDES:rust-hashbrown0.15-devel:x86_64_v2 = "virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~ virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"

URI_aarch64_rust-hashbrown0.15+allocator-api2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.15+allocator-api2-devel-0.15.5-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown0.15+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.15+allocator-api2-devel}"
SRC_URI[aarch64_rust-hashbrown0.15+allocator-api2-devel.sha256sum] = "855d23c1801222cc167ffd09be12a1e632edde8f386855b35c5f7f58def97d7b"

URI_aarch64_rust-hashbrown0.15+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.15+default-devel-0.15.5-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown0.15+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.15+default-devel}"
SRC_URI[aarch64_rust-hashbrown0.15+default-devel.sha256sum] = "20682a5467f550dbc765469a7470a72e46250cd98a4bac908bc022167ba306ec"
RPROVIDES:rust-hashbrown0.15+default-devel:aarch64 = "virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~"

URI_aarch64_rust-hashbrown0.15+default-hasher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.15+default-hasher-devel-0.15.5-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown0.15+default-hasher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.15+default-hasher-devel}"
SRC_URI[aarch64_rust-hashbrown0.15+default-hasher-devel.sha256sum] = "2606f617114972c24b98dbe39b571d7377ff46420b982d6ceb79a8bf1537d51f"
RPROVIDES:rust-hashbrown0.15+default-hasher-devel:aarch64 = "virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~"

URI_aarch64_rust-hashbrown0.15+equivalent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.15+equivalent-devel-0.15.5-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown0.15+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.15+equivalent-devel}"
SRC_URI[aarch64_rust-hashbrown0.15+equivalent-devel.sha256sum] = "de7fc03282a1d3b9e2dc20388e2067b17f1e4a44b8155d26a349b61fbb9e1523"

URI_aarch64_rust-hashbrown0.15+inline-more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.15+inline-more-devel-0.15.5-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown0.15+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.15+inline-more-devel}"
SRC_URI[aarch64_rust-hashbrown0.15+inline-more-devel.sha256sum] = "9bf15545c0b36bf73fcca8d8fab5f6efb40bd2abd6907458c588a9582eaa95f8"
RPROVIDES:rust-hashbrown0.15+inline-more-devel:aarch64 = "virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~"

URI_aarch64_rust-hashbrown0.15+raw-entry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.15+raw-entry-devel-0.15.5-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown0.15+raw-entry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.15+raw-entry-devel}"
SRC_URI[aarch64_rust-hashbrown0.15+raw-entry-devel.sha256sum] = "06b41d2178aad9725c4c61a5ba6c061c05f6748ca2f613dbaf9fc0b860d6edf3"

URI_aarch64_rust-hashbrown0.15+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.15+rayon-devel-0.15.5-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown0.15+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.15+rayon-devel}"
SRC_URI[aarch64_rust-hashbrown0.15+rayon-devel.sha256sum] = "d920fc702342561b42fef364d8615b870b785ca7fe8d4cc9fcbc97dab08c73c4"

URI_aarch64_rust-hashbrown0.15+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.15+serde-devel-0.15.5-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown0.15+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.15+serde-devel}"
SRC_URI[aarch64_rust-hashbrown0.15+serde-devel.sha256sum] = "44c7f3895ff523023543d382fa8ba43a81960229daee1e97efc1a0c7aa7e44bd"

URI_aarch64_rust-hashbrown0.15-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.15-devel-0.15.5-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown0.15-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.15-devel}"
SRC_URI[aarch64_rust-hashbrown0.15-devel.sha256sum] = "46035c6bd439d52c5d7af7a2180e9cf016e0f1a38c12c9a35a34c150f6713348"
RPROVIDES:rust-hashbrown0.15-devel:aarch64 = "virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~ virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"

RDEPENDS:rust-hashbrown0.15+allocator-api2-devel = " \
 cargo \
 rust-allocator-api2+alloc-devel \
 rust-allocator-api2-devel \
 rust-hashbrown0.15-devel \
 "
RDEPENDS:rust-hashbrown0.15+default-devel = " \
 cargo \
 rust-hashbrown0.15+allocator-api2-devel \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15+equivalent-devel \
 rust-hashbrown0.15+inline-more-devel \
 rust-hashbrown0.15+raw-entry-devel \
 rust-hashbrown0.15-devel \
 "
RDEPENDS:rust-hashbrown0.15+default-hasher-devel = " \
 cargo \
 rust-foldhash0.1-devel \
 rust-hashbrown0.15-devel \
 "
RDEPENDS:rust-hashbrown0.15+equivalent-devel = " \
 cargo \
 rust-equivalent-devel \
 rust-hashbrown0.15-devel \
 "
RDEPENDS:rust-hashbrown0.15+inline-more-devel = " \
 cargo \
 rust-hashbrown0.15-devel \
 "
RDEPENDS:rust-hashbrown0.15+raw-entry-devel = " \
 cargo \
 rust-hashbrown0.15-devel \
 "
RDEPENDS:rust-hashbrown0.15+rayon-devel = " \
 cargo \
 rust-hashbrown0.15-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-hashbrown0.15+serde-devel = " \
 cargo \
 rust-hashbrown0.15-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hashbrown0.15-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~ rpm/virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~ rpm/virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~ rpm/virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~ rpm/virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~ rpm/virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~ rpm/virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~ rpm/virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~ rpm/virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"
