# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pkcs1"
PV = "0.7.5"
PR = "2.el10_0"
PACKAGES = " \
 rust-pkcs1+alloc-devel \
 rust-pkcs1+default-devel \
 rust-pkcs1+pem-devel \
 rust-pkcs1+pkcs8-devel \
 rust-pkcs1+std-devel \
 rust-pkcs1+zeroize-devel \
 rust-pkcs1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pkcs1-0.7.5-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9ff0c4189d96d53e7d023e302a48e5d7cb902c4f1badb2dbc4dd88dd902638b"

URI_x86_64_v2_rust-pkcs1+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1+alloc-devel-0.7.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1+alloc-devel}"
SRC_URI[x86_64_v2_rust-pkcs1+alloc-devel.sha256sum] = "1f09c0817243a137ca1e6b241af20f7148906b52b04d4ad577abd74f554d1d22"

URI_x86_64_v2_rust-pkcs1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1+default-devel-0.7.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1+default-devel}"
SRC_URI[x86_64_v2_rust-pkcs1+default-devel.sha256sum] = "7fda535f30234079656d4f981b5109953c9003a11f887114ed127af12c116451"

URI_x86_64_v2_rust-pkcs1+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1+pem-devel-0.7.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1+pem-devel}"
SRC_URI[x86_64_v2_rust-pkcs1+pem-devel.sha256sum] = "e34eef860e6e47f7a5c60db16ddcd2a209794d8b844763e6e6d8254df2709982"

URI_x86_64_v2_rust-pkcs1+pkcs8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1+pkcs8-devel-0.7.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1+pkcs8-devel}"
SRC_URI[x86_64_v2_rust-pkcs1+pkcs8-devel.sha256sum] = "390783dc4b52f2022dea1861729f47fe54c516ae5bc6a5823d68289940250171"

URI_x86_64_v2_rust-pkcs1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1+std-devel-0.7.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1+std-devel}"
SRC_URI[x86_64_v2_rust-pkcs1+std-devel.sha256sum] = "548ef19ff4e93f5c30dbb95f36a82f9eac72b0a3e3a2931643d61750fc1dd038"

URI_x86_64_v2_rust-pkcs1+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1+zeroize-devel-0.7.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1+zeroize-devel}"
SRC_URI[x86_64_v2_rust-pkcs1+zeroize-devel.sha256sum] = "28cc641be5c4723a94f2c49d4dfd470f109ded63c5d5a538a8fe99f7b475583c"

URI_x86_64_v2_rust-pkcs1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1-devel-0.7.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1-devel}"
SRC_URI[x86_64_v2_rust-pkcs1-devel.sha256sum] = "392fd18925de82e06142e0e4cef23416777a0c9c06729da474d348c22804cdba"

URI_aarch64_rust-pkcs1+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1+alloc-devel-0.7.5-2.el10_0.noarch.rpm;name=aarch64_rust-pkcs1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1+alloc-devel}"
SRC_URI[aarch64_rust-pkcs1+alloc-devel.sha256sum] = "b4c2af4059a288ff7b0435091e422981782f715bd6c32190b87d4712167b1669"

URI_aarch64_rust-pkcs1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1+default-devel-0.7.5-2.el10_0.noarch.rpm;name=aarch64_rust-pkcs1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1+default-devel}"
SRC_URI[aarch64_rust-pkcs1+default-devel.sha256sum] = "10e299810a94d11f3369c8bf43b5ec7147e325524f0819b59dd7b796937670e2"

URI_aarch64_rust-pkcs1+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1+pem-devel-0.7.5-2.el10_0.noarch.rpm;name=aarch64_rust-pkcs1+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1+pem-devel}"
SRC_URI[aarch64_rust-pkcs1+pem-devel.sha256sum] = "fcc5ab2c185a4affece7127d4846b44129148448f37c40ac56ab622a8e08905e"

URI_aarch64_rust-pkcs1+pkcs8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1+pkcs8-devel-0.7.5-2.el10_0.noarch.rpm;name=aarch64_rust-pkcs1+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1+pkcs8-devel}"
SRC_URI[aarch64_rust-pkcs1+pkcs8-devel.sha256sum] = "7a4e916e40d473397ddb9f724fd41039d6a89d689124ef6c8f0114bf029e46f2"

URI_aarch64_rust-pkcs1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1+std-devel-0.7.5-2.el10_0.noarch.rpm;name=aarch64_rust-pkcs1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1+std-devel}"
SRC_URI[aarch64_rust-pkcs1+std-devel.sha256sum] = "235686f4ff6e1ce958e94c250ed1927c1d55114e1c20c3d13bd210e2516f62e5"

URI_aarch64_rust-pkcs1+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1+zeroize-devel-0.7.5-2.el10_0.noarch.rpm;name=aarch64_rust-pkcs1+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1+zeroize-devel}"
SRC_URI[aarch64_rust-pkcs1+zeroize-devel.sha256sum] = "5ca9260618368f5e42683957869d2624e714d6d2de1898d82cad250d590817ec"

URI_aarch64_rust-pkcs1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1-devel-0.7.5-2.el10_0.noarch.rpm;name=aarch64_rust-pkcs1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1-devel}"
SRC_URI[aarch64_rust-pkcs1-devel.sha256sum] = "fafe8b0a2063f4ed45835a2d14c613a7bbd8b1a03d750b6d686ac53b805c9b34"

RDEPENDS:rust-pkcs1+alloc-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-pkcs1+zeroize-devel \
 rust-pkcs1-devel \
 rust-pkcs8+alloc-devel \
 rust-pkcs8-devel \
 "
RDEPENDS:rust-pkcs1+default-devel = " \
 cargo \
 rust-pkcs1-devel \
 "
RDEPENDS:rust-pkcs1+pem-devel = " \
 cargo \
 rust-der+pem-devel \
 rust-pkcs1+alloc-devel \
 rust-pkcs1-devel \
 rust-pkcs8+pem-devel \
 rust-pkcs8-devel \
 "
RDEPENDS:rust-pkcs1+pkcs8-devel = " \
 cargo \
 rust-pkcs1-devel \
 rust-pkcs8-devel \
 "
RDEPENDS:rust-pkcs1+std-devel = " \
 cargo \
 rust-der+std-devel \
 rust-pkcs1+alloc-devel \
 rust-pkcs1-devel \
 "
RDEPENDS:rust-pkcs1+zeroize-devel = " \
 cargo \
 rust-der+zeroize-devel \
 rust-pkcs1-devel \
 "
RDEPENDS:rust-pkcs1-devel = " \
 cargo \
 rust \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-spki+default-devel \
 "
