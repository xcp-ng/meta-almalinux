# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-ObjectName"
PV = "1.1.0.2"
PR = "9.el10_0"
PACKAGES = " \
 ghc-ObjectName \
 ghc-ObjectName-devel \
 ghc-ObjectName-doc \
 ghc-ObjectName-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-ObjectName-1.1.0.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "504ce9cc051cc83105f8425ac0517e2f4a8f4dab4f1a5695992d7e51d7e83e2a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ObjectName-1.1.0.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ObjectName;unpack=0"
SRC_URI[x86_64_v2_ghc-ObjectName.sha256sum] = "647b0283e9a6a96d3ae440186b730e317914b3f86d2fef0e2696fa57ce77333d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ObjectName-devel-1.1.0.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ObjectName-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-ObjectName-devel.sha256sum] = "050a8ef66473a897d88d06a393d96154889bf35977486e0131b3beb52cfb4499"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ObjectName-doc-1.1.0.2-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ObjectName-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-ObjectName-doc.sha256sum] = "456cb49615b16f5b422d0319897af0dd2575c018d18b192656eb1bc324200d1e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ObjectName-prof-1.1.0.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ObjectName-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-ObjectName-prof.sha256sum] = "2afd7ff563d0b4c93929d3d0d0c374835c8212f2b5218ac694867b1b11d3ed1b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-ObjectName-1.1.0.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-ObjectName;unpack=0"
SRC_URI[aarch64_ghc-ObjectName.sha256sum] = "07d4381f281f54da2633d18c189fe9c279497654c87bcdf5666e1c656336e1de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-ObjectName-devel-1.1.0.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-ObjectName-devel;unpack=0"
SRC_URI[aarch64_ghc-ObjectName-devel.sha256sum] = "97f1f5c75a728908022e572a1571eeefb45c013943f15762ca9b2f06f06f7a45"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-ObjectName-doc-1.1.0.2-9.el10_0.noarch.rpm;name=aarch64_ghc-ObjectName-doc;unpack=0"
SRC_URI[aarch64_ghc-ObjectName-doc.sha256sum] = "d0fa2f11da0efd5264114bdbb199ac7ed0b92ecba52c13042b6d5822f94ac90d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-ObjectName-prof-1.1.0.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-ObjectName-prof;unpack=0"
SRC_URI[aarch64_ghc-ObjectName-prof.sha256sum] = "4a25e6b274a3de0583e553a0a1c55ebe0fe27433b7ba1ca7e9b01ca577553096"

RDEPENDS:ghc-ObjectName = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ObjectName-devel = " \
 ghc-ObjectName \
 ghc-base-devel \
 ghc-compiler \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-ObjectName-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ObjectName-prof = " \
 ghc-ObjectName-devel \
 ghc-base-prof \
 ghc-transformers-prof \
 "
