# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-virtue"
PV = "0.0.18"
PR = "1.el10_1"
PACKAGES = " \
 rust-virtue+default-devel \
 rust-virtue+proc-macro2-devel \
 rust-virtue-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-virtue-0.0.18-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c31fd26a03e10ed3a3fbaa8cda04b9760023410c2ee2a799dc357dec3e2c1973"

URI_x86_64_v2_rust-virtue+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-virtue+default-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-virtue+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-virtue+default-devel}"
SRC_URI[x86_64_v2_rust-virtue+default-devel.sha256sum] = "e43bcdcd40e08159a87bf494018ed82a95e0f0b119ad364342fe26daf6d6f052"

URI_x86_64_v2_rust-virtue+proc-macro2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-virtue+proc-macro2-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-virtue+proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-virtue+proc-macro2-devel}"
SRC_URI[x86_64_v2_rust-virtue+proc-macro2-devel.sha256sum] = "2c427aa94ab5a7c717ed436bb5e2d3d19f9bd59a965af5b608fdd6c75321aa2f"

URI_x86_64_v2_rust-virtue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-virtue-devel-0.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-virtue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-virtue-devel}"
SRC_URI[x86_64_v2_rust-virtue-devel.sha256sum] = "9c378af0f3955a15376a09d26a60a7fb914654a1036a2beece8fd726b1fd487e"

URI_aarch64_rust-virtue+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-virtue+default-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-virtue+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-virtue+default-devel}"
SRC_URI[aarch64_rust-virtue+default-devel.sha256sum] = "5c1d7ac55b00ef741929f91703ec767d75d420f4cd7760a2934d9c15bcc3a5cf"

URI_aarch64_rust-virtue+proc-macro2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-virtue+proc-macro2-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-virtue+proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-virtue+proc-macro2-devel}"
SRC_URI[aarch64_rust-virtue+proc-macro2-devel.sha256sum] = "fec65220e8abdb544a95e56c90edc4ed72b6df424dbd8a83c04485b2ba12b5db"

URI_aarch64_rust-virtue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-virtue-devel-0.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-virtue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-virtue-devel}"
SRC_URI[aarch64_rust-virtue-devel.sha256sum] = "6da0d6e0fa8ff310111e50af5702003436f87b5c0866634caff19c62151f2e74"

RDEPENDS:rust-virtue+default-devel = " \
 cargo \
 rust-virtue-devel \
 "
RDEPENDS:rust-virtue+proc-macro2-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-virtue-devel \
 "
RDEPENDS:rust-virtue-devel = " \
 cargo \
 "
