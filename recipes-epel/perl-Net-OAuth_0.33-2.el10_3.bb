# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-OAuth"
PV = "0.33"
PR = "2.el10_3"
PACKAGES = " \
 perl-Net-OAuth \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Net-OAuth-0.33-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bd2b81fe03e2ed06f6bc8720804eaaf8b1910c1491c44af34f8e818e61429120"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-OAuth-0.33-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-OAuth;unpack=0"
SRC_URI[x86_64_v2_perl-Net-OAuth.sha256sum] = "1fbb689f67c18f87ccf8169e29b12208488a5d6f117195deff5a5cda5333effa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-OAuth-0.33-2.el10_3.noarch.rpm;name=aarch64_perl-Net-OAuth;unpack=0"
SRC_URI[aarch64_perl-Net-OAuth.sha256sum] = "2b3ae915698bac0d4205aff569ca0e0bf16839685c20d4e84bea269593354748"

RDEPENDS:perl-Net-OAuth = " \
 perl-Carp \
 perl-Class-Accessor \
 perl-Class-Data-Inheritable \
 perl-Crypt-SysRandom \
 perl-Digest-SHA \
 perl-MIME-Base64 \
 perl-Net-OAuth \
 perl-URI \
 perl-base \
 perl-constant \
 perl-libs \
 perl-libwww-perl \
 "
