# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oneapi-level-zero"
PV = "1.24.0"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 oneapi-level-zero \
 oneapi-level-zero-devel \
 oneapi-level-zero-zello_world \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/o/oneapi-level-zero-1.24.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40c62233bc9777e005c367c2bfeed24115da7db49b5dadee3bd9975fbf0637f5"

URI_x86_64_v2_oneapi-level-zero = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oneapi-level-zero-1.24.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oneapi-level-zero;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oneapi-level-zero}"
SRC_URI[x86_64_v2_oneapi-level-zero.sha256sum] = "ad0eca2ece06e80c15aeb9300ae2551a471016f5aaf036a1eaf432404f7f136f"

URI_x86_64_v2_oneapi-level-zero-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oneapi-level-zero-devel-1.24.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oneapi-level-zero-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oneapi-level-zero-devel}"
SRC_URI[x86_64_v2_oneapi-level-zero-devel.sha256sum] = "370902ef50027ccb53e624d4f2e95c5b70a9a7e195fc6d2a8d20582040c9ebf1"

URI_x86_64_v2_oneapi-level-zero-zello_world = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oneapi-level-zero-zello_world-1.24.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oneapi-level-zero-zello_world;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oneapi-level-zero-zello_world}"
SRC_URI[x86_64_v2_oneapi-level-zero-zello_world.sha256sum] = "15fdbbe30f79e25e1fca34072b4ee30d8d31066cb2c379a2bbe1bb066cdc6441"

RDEPENDS:oneapi-level-zero = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:oneapi-level-zero-devel = " \
 oneapi-level-zero \
 oneapi-level-zero-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:oneapi-level-zero-zello_world = " \
 glibc \
 libgcc \
 libstdc++ \
 oneapi-level-zero \
 "
