# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-cipher"
PV = "2.0"
PR = "12.el10"
PACKAGES = " \
 plexus-cipher \
 plexus-cipher-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/plexus-cipher-2.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "044cd66b88ed14beddc6279600c2658bb33429126baad9066888300b776dd9e0"

URI_x86_64_v2_plexus-cipher = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plexus-cipher-2.0-12.el10.noarch.rpm;name=x86_64_v2_plexus-cipher;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-cipher}"
SRC_URI[x86_64_v2_plexus-cipher.sha256sum] = "d74084b3dfd37f7bb979bd7c454d9f1bc1ffb8921a6dab88cc27ed4fe4189c40"

URI_x86_64_v2_plexus-cipher-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-cipher-javadoc-2.0-12.el10.noarch.rpm;name=x86_64_v2_plexus-cipher-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-cipher-javadoc}"
SRC_URI[x86_64_v2_plexus-cipher-javadoc.sha256sum] = "4c207ff6605e6b975f2e91088d35820f904cfd422206f707fa0bd7bac913ad4f"

URI_aarch64_plexus-cipher = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plexus-cipher-2.0-12.el10.noarch.rpm;name=aarch64_plexus-cipher;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-cipher}"
SRC_URI[aarch64_plexus-cipher.sha256sum] = "d74084b3dfd37f7bb979bd7c454d9f1bc1ffb8921a6dab88cc27ed4fe4189c40"

URI_aarch64_plexus-cipher-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-cipher-javadoc-2.0-12.el10.noarch.rpm;name=aarch64_plexus-cipher-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-cipher-javadoc}"
SRC_URI[aarch64_plexus-cipher-javadoc.sha256sum] = "4c207ff6605e6b975f2e91088d35820f904cfd422206f707fa0bd7bac913ad4f"

RDEPENDS:plexus-cipher = " \
 atinject \
 javapackages-filesystem \
 "
RDEPENDS:plexus-cipher-javadoc = " \
 javapackages-filesystem \
 "
