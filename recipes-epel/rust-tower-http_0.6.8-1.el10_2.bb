# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tower-http"
PV = "0.6.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-tower-http+add-extension-devel \
 rust-tower-http+async-compression-devel \
 rust-tower-http+auth-devel \
 rust-tower-http+base64-devel \
 rust-tower-http+catch-panic-devel \
 rust-tower-http+compression-br-devel \
 rust-tower-http+compression-deflate-devel \
 rust-tower-http+compression-full-devel \
 rust-tower-http+compression-gzip-devel \
 rust-tower-http+compression-zstd-devel \
 rust-tower-http+cors-devel \
 rust-tower-http+decompression-br-devel \
 rust-tower-http+decompression-deflate-devel \
 rust-tower-http+decompression-full-devel \
 rust-tower-http+decompression-gzip-devel \
 rust-tower-http+decompression-zstd-devel \
 rust-tower-http+default-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http+fs-devel \
 rust-tower-http+full-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+futures-util-devel \
 rust-tower-http+httpdate-devel \
 rust-tower-http+iri-string-devel \
 rust-tower-http+limit-devel \
 rust-tower-http+map-request-body-devel \
 rust-tower-http+map-response-body-devel \
 rust-tower-http+metrics-devel \
 rust-tower-http+mime-devel \
 rust-tower-http+mime_guess-devel \
 rust-tower-http+normalize-path-devel \
 rust-tower-http+percent-encoding-devel \
 rust-tower-http+propagate-header-devel \
 rust-tower-http+redirect-devel \
 rust-tower-http+request-id-devel \
 rust-tower-http+sensitive-headers-devel \
 rust-tower-http+set-header-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+timeout-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http+tower-devel \
 rust-tower-http+trace-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http+util-devel \
 rust-tower-http+uuid-devel \
 rust-tower-http+validate-request-devel \
 rust-tower-http-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tower-http-0.6.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a36643867df133b745027897f7bcfbe54939ba93cd0eda83916633a5657cace"

URI_x86_64_v2_rust-tower-http+add-extension-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+add-extension-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+add-extension-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+add-extension-devel}"
SRC_URI[x86_64_v2_rust-tower-http+add-extension-devel.sha256sum] = "ed6ccb4ba51503c46cf24f29e9eda37d00481d84d39edba7153b10e6583a92c4"

URI_x86_64_v2_rust-tower-http+async-compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+async-compression-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+async-compression-devel}"
SRC_URI[x86_64_v2_rust-tower-http+async-compression-devel.sha256sum] = "877591ec1c6c0162fab91d9624e41ead53aacf82a69fd5b5437c5f3928c48a28"

URI_x86_64_v2_rust-tower-http+auth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+auth-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+auth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+auth-devel}"
SRC_URI[x86_64_v2_rust-tower-http+auth-devel.sha256sum] = "b33b2cd7bb0214c1df14f704a2d431dced9e566f62185c998daf44bfaefccb3e"

URI_x86_64_v2_rust-tower-http+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+base64-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+base64-devel}"
SRC_URI[x86_64_v2_rust-tower-http+base64-devel.sha256sum] = "012432e28b17719e00a637d766212d8f0506c4f3c406e89bd20cdaaaeb6af3d1"

URI_x86_64_v2_rust-tower-http+catch-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+catch-panic-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+catch-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+catch-panic-devel}"
SRC_URI[x86_64_v2_rust-tower-http+catch-panic-devel.sha256sum] = "a95b81fc2be08ff316951770e57dcfa173ae523e02bc461333b41f69305989ed"

URI_x86_64_v2_rust-tower-http+compression-br-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-br-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-br-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-br-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-br-devel.sha256sum] = "e1946574127d4ac1c052f5a8f8548a490e827788091755b63fdd6cd4c7ce5414"

URI_x86_64_v2_rust-tower-http+compression-deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-deflate-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-deflate-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-deflate-devel.sha256sum] = "2d6ee19b08167e453d7f2baac6a18ca1ab8e5a18b82de26819542cc79d791266"

URI_x86_64_v2_rust-tower-http+compression-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-full-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-full-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-full-devel.sha256sum] = "9d1db41d3fcb79ef92cd4741b49476140a4e9342a985a6cae444f16faafc5991"

URI_x86_64_v2_rust-tower-http+compression-gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-gzip-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-gzip-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-gzip-devel.sha256sum] = "a2bee416255195ffd0469ad2d690153141f59a4aa82ee981503f3c56de61a456"

URI_x86_64_v2_rust-tower-http+compression-zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-zstd-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-zstd-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-zstd-devel.sha256sum] = "6fe842c7e1a06dc1b91dd39cd117d9f2cd0b7ce56935fe8fc5b0463c56c1d869"

URI_x86_64_v2_rust-tower-http+cors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+cors-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+cors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+cors-devel}"
SRC_URI[x86_64_v2_rust-tower-http+cors-devel.sha256sum] = "c700334123fb30bee20d8258f4860a537190d475040d9562e94e4206b2303f70"

URI_x86_64_v2_rust-tower-http+decompression-br-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-br-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-br-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-br-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-br-devel.sha256sum] = "52523f5e9800ceef9e5d507838b8dc6e537660f4d28599e78bf719b17c47140e"

URI_x86_64_v2_rust-tower-http+decompression-deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-deflate-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-deflate-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-deflate-devel.sha256sum] = "9b8959b8aa33a858e0cb8937aed1de685265bd1f2aa1e72f9c68a08e05be9610"

URI_x86_64_v2_rust-tower-http+decompression-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-full-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-full-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-full-devel.sha256sum] = "1f011fbf849500c2cd66f7feaffe1e28e43116576c6050f214545c6eb30f5cf5"

URI_x86_64_v2_rust-tower-http+decompression-gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-gzip-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-gzip-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-gzip-devel.sha256sum] = "47f97e68953045e44ba8a106e6892ca13123bfda047565ce3016f0f8057d107b"

URI_x86_64_v2_rust-tower-http+decompression-zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-zstd-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-zstd-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-zstd-devel.sha256sum] = "12973310343159b63cd68b5f2c6aac98584c11af2119f8de972005e39e6d8b42"

URI_x86_64_v2_rust-tower-http+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+default-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+default-devel}"
SRC_URI[x86_64_v2_rust-tower-http+default-devel.sha256sum] = "1b0961318754a6298c0835f194a3cf85d73b1e5d432598e86c3b55b7051aa919"

URI_x86_64_v2_rust-tower-http+follow-redirect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+follow-redirect-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+follow-redirect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+follow-redirect-devel}"
SRC_URI[x86_64_v2_rust-tower-http+follow-redirect-devel.sha256sum] = "12933b58849fd9e5f794abbda97ffbb501ad394dae94413fcc5b6ae015fde524"

URI_x86_64_v2_rust-tower-http+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+fs-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+fs-devel}"
SRC_URI[x86_64_v2_rust-tower-http+fs-devel.sha256sum] = "7a3a2e10476e8f7f36aff042eff93ff4f71d134317e01344ed12afd546ec29f8"

URI_x86_64_v2_rust-tower-http+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+full-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+full-devel}"
SRC_URI[x86_64_v2_rust-tower-http+full-devel.sha256sum] = "a55996a38f5645af3be8c331d6aa6241bba4b078acea35f233eb10123892528c"

URI_x86_64_v2_rust-tower-http+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+futures-core-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+futures-core-devel}"
SRC_URI[x86_64_v2_rust-tower-http+futures-core-devel.sha256sum] = "8dc727a0f8e80673309e5860b7de80042afd1746bd1eb77b08f8f30f814dcdc8"

URI_x86_64_v2_rust-tower-http+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+futures-util-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+futures-util-devel}"
SRC_URI[x86_64_v2_rust-tower-http+futures-util-devel.sha256sum] = "d27f8a7136d0e355030359906253ec4f4776a4fdd0198890e75c4a51cd8a796f"

URI_x86_64_v2_rust-tower-http+httpdate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+httpdate-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+httpdate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+httpdate-devel}"
SRC_URI[x86_64_v2_rust-tower-http+httpdate-devel.sha256sum] = "e7dca10f997424ba00be275fb552cabf9672dc77366d43688cdf03594e7e9834"

URI_x86_64_v2_rust-tower-http+iri-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+iri-string-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+iri-string-devel}"
SRC_URI[x86_64_v2_rust-tower-http+iri-string-devel.sha256sum] = "a5e2e0ab1eab97dc92974d7bb18aae391e82ce9d85ab1ebda2c0e89b876bed73"

URI_x86_64_v2_rust-tower-http+limit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+limit-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+limit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+limit-devel}"
SRC_URI[x86_64_v2_rust-tower-http+limit-devel.sha256sum] = "f0d0d6cd771548994759e8a11b8ab7b64171ac90e59915f86a5080878f8fc4d7"

URI_x86_64_v2_rust-tower-http+map-request-body-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+map-request-body-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+map-request-body-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+map-request-body-devel}"
SRC_URI[x86_64_v2_rust-tower-http+map-request-body-devel.sha256sum] = "357d2926f391138cb021d09465d3c3c73df7ba40dffa5f70cfd6a86f48c7df68"

URI_x86_64_v2_rust-tower-http+map-response-body-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+map-response-body-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+map-response-body-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+map-response-body-devel}"
SRC_URI[x86_64_v2_rust-tower-http+map-response-body-devel.sha256sum] = "d0c20a1da8d9f539673bfba30e809992fb74e5e82a99b177fdb6e4cd2b8e13b8"

URI_x86_64_v2_rust-tower-http+metrics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+metrics-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+metrics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+metrics-devel}"
SRC_URI[x86_64_v2_rust-tower-http+metrics-devel.sha256sum] = "817f66d9e876bc1a300d59e7214b47a5ed3739e31531ee7a76962bc5dc55db68"

URI_x86_64_v2_rust-tower-http+mime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+mime-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+mime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+mime-devel}"
SRC_URI[x86_64_v2_rust-tower-http+mime-devel.sha256sum] = "93174361274259f5de3ab4087daa23d0b53c67d0bd01295030dc76d1ce72d108"

URI_x86_64_v2_rust-tower-http+mime_guess-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+mime_guess-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+mime_guess-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+mime_guess-devel}"
SRC_URI[x86_64_v2_rust-tower-http+mime_guess-devel.sha256sum] = "4155658d38510be797efb7e4bd41ae6913b618b6d07d57c21969cced981d0197"

URI_x86_64_v2_rust-tower-http+normalize-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+normalize-path-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+normalize-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+normalize-path-devel}"
SRC_URI[x86_64_v2_rust-tower-http+normalize-path-devel.sha256sum] = "88dcd3e7573113e57bf7a6137041a2222a870962aa2791254fcabafbb03aa6bc"

URI_x86_64_v2_rust-tower-http+percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+percent-encoding-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-tower-http+percent-encoding-devel.sha256sum] = "ce4db86eab44133b41aa08a28545ec5c5bbbaad0307cf51bea01c730b694c289"

URI_x86_64_v2_rust-tower-http+propagate-header-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+propagate-header-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+propagate-header-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+propagate-header-devel}"
SRC_URI[x86_64_v2_rust-tower-http+propagate-header-devel.sha256sum] = "28a3d45f2ebba136d950ae9a715937f8e27eb59eeb3474a054fb68436accbcc0"

URI_x86_64_v2_rust-tower-http+redirect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+redirect-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+redirect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+redirect-devel}"
SRC_URI[x86_64_v2_rust-tower-http+redirect-devel.sha256sum] = "b365b94246e643d2373bba4141b59a6c46680c1070b7d52ffb19b2578c34725e"

URI_x86_64_v2_rust-tower-http+request-id-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+request-id-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+request-id-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+request-id-devel}"
SRC_URI[x86_64_v2_rust-tower-http+request-id-devel.sha256sum] = "5716ed119fb0d1dd47f9063133d32afac40a863f150a376f9b88acd3a0ceed34"

URI_x86_64_v2_rust-tower-http+sensitive-headers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+sensitive-headers-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+sensitive-headers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+sensitive-headers-devel}"
SRC_URI[x86_64_v2_rust-tower-http+sensitive-headers-devel.sha256sum] = "4572179e1a78572001cf44abcc38886dd7b913da24f3d8ad3ccbf8681652aa99"

URI_x86_64_v2_rust-tower-http+set-header-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+set-header-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+set-header-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+set-header-devel}"
SRC_URI[x86_64_v2_rust-tower-http+set-header-devel.sha256sum] = "add76c07e3839f3cd44e620bc38f40b0520ac1824c510f632eebb7e4153f6d4a"

URI_x86_64_v2_rust-tower-http+set-status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+set-status-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+set-status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+set-status-devel}"
SRC_URI[x86_64_v2_rust-tower-http+set-status-devel.sha256sum] = "a2a55f1daf418ecb93b2ecf2fdbdee6a40919667382454d783be81cb76c5b97d"

URI_x86_64_v2_rust-tower-http+timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+timeout-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+timeout-devel}"
SRC_URI[x86_64_v2_rust-tower-http+timeout-devel.sha256sum] = "6ec4a60712bf5d5f9d7fdd278f93dd2c61e8058a0a02269d975ac89897da9fec"

URI_x86_64_v2_rust-tower-http+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tokio-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+tokio-devel}"
SRC_URI[x86_64_v2_rust-tower-http+tokio-devel.sha256sum] = "b26838418c4c714d3f9746daf81eb8c8223376a54b0fc648c0263ae7497f9de5"

URI_x86_64_v2_rust-tower-http+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tokio-util-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-tower-http+tokio-util-devel.sha256sum] = "f2697d35a16fb56bdb94bcc77211626b97861c50f246926c77285d0f70311dab"

URI_x86_64_v2_rust-tower-http+tower-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tower-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tower-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+tower-devel}"
SRC_URI[x86_64_v2_rust-tower-http+tower-devel.sha256sum] = "4b5ce2adbfe8125899c467781c5c588b5909c5c3455bf827aa15e2de4559ae0a"

URI_x86_64_v2_rust-tower-http+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+trace-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+trace-devel}"
SRC_URI[x86_64_v2_rust-tower-http+trace-devel.sha256sum] = "7767936bb43e71478a8beaf067375692bb236c5e97dcf43d05a244f96d821dc3"

URI_x86_64_v2_rust-tower-http+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tracing-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+tracing-devel}"
SRC_URI[x86_64_v2_rust-tower-http+tracing-devel.sha256sum] = "3ebc203928e4e4c0372e676188e30e912b0cb9fdd65ec6553096fcf887474c3b"

URI_x86_64_v2_rust-tower-http+util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+util-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+util-devel}"
SRC_URI[x86_64_v2_rust-tower-http+util-devel.sha256sum] = "01a0fe2e029ea581024dadda919db01aba8e8ce7944f51e0c00971f85fbc21f1"

URI_x86_64_v2_rust-tower-http+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+uuid-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+uuid-devel}"
SRC_URI[x86_64_v2_rust-tower-http+uuid-devel.sha256sum] = "7d3fa0b62c80ee6874cb993cedf2a191c28d0783c75e1de6bae765c0e95e186f"

URI_x86_64_v2_rust-tower-http+validate-request-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+validate-request-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+validate-request-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+validate-request-devel}"
SRC_URI[x86_64_v2_rust-tower-http+validate-request-devel.sha256sum] = "8924827f892ca7386b7ea45fb130e3406008059f8fc5004c0d260de0682da5ac"

URI_x86_64_v2_rust-tower-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http-devel-0.6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http-devel}"
SRC_URI[x86_64_v2_rust-tower-http-devel.sha256sum] = "980f7bd622f647435e4593936b7f8684a5f4393a0428d8cef2b46df746ceb93d"

URI_aarch64_rust-tower-http+add-extension-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+add-extension-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+add-extension-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+add-extension-devel}"
SRC_URI[aarch64_rust-tower-http+add-extension-devel.sha256sum] = "3b39f39a9f88e94f1ffac7029af74cd939ab9bdbec6036f2356ae45b6d0870ef"

URI_aarch64_rust-tower-http+async-compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+async-compression-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+async-compression-devel}"
SRC_URI[aarch64_rust-tower-http+async-compression-devel.sha256sum] = "c9a817a6883e291e858db45fb2c2fa0b5646559b641fb07c11cc330cad5bce25"

URI_aarch64_rust-tower-http+auth-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+auth-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+auth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+auth-devel}"
SRC_URI[aarch64_rust-tower-http+auth-devel.sha256sum] = "c73e73d5865cf5a6ea2c1f81c4e2cfe9a10b0ef91fee78c04c97aa9026966831"

URI_aarch64_rust-tower-http+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+base64-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+base64-devel}"
SRC_URI[aarch64_rust-tower-http+base64-devel.sha256sum] = "2e2c9e552a675cf2cb7fa70026a57352d79cce5acad4b91b0e942aba5b91bae1"

URI_aarch64_rust-tower-http+catch-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+catch-panic-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+catch-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+catch-panic-devel}"
SRC_URI[aarch64_rust-tower-http+catch-panic-devel.sha256sum] = "10fbe2e7c283c9cb6f63770e2aa264758e2f11c9a766b81b4d54f9a2ca587216"

URI_aarch64_rust-tower-http+compression-br-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-br-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+compression-br-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-br-devel}"
SRC_URI[aarch64_rust-tower-http+compression-br-devel.sha256sum] = "e649e36c02e550ef40db78d12c811e3922c5d1dcc0f949eee4e84fde8e172652"

URI_aarch64_rust-tower-http+compression-deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-deflate-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-deflate-devel}"
SRC_URI[aarch64_rust-tower-http+compression-deflate-devel.sha256sum] = "4c6e2ec21af0f390cc877f993cd77b49149948fe4b9e08aeba7dc78d669286c6"

URI_aarch64_rust-tower-http+compression-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-full-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+compression-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-full-devel}"
SRC_URI[aarch64_rust-tower-http+compression-full-devel.sha256sum] = "ff659216a7c96c564dc3c7c3191230455875a650035dd45b1de0222b8134e6e6"

URI_aarch64_rust-tower-http+compression-gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-gzip-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+compression-gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-gzip-devel}"
SRC_URI[aarch64_rust-tower-http+compression-gzip-devel.sha256sum] = "9e02bab2e23a101904e3d5bed08606c7b7afe9509f161d2ecedf081af4ba8f6d"

URI_aarch64_rust-tower-http+compression-zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-zstd-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+compression-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-zstd-devel}"
SRC_URI[aarch64_rust-tower-http+compression-zstd-devel.sha256sum] = "a8971109df3f61a5aab6afffc4f8be9d6b4f764ac0ad710c79f8b9fc55fecd0f"

URI_aarch64_rust-tower-http+cors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+cors-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+cors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+cors-devel}"
SRC_URI[aarch64_rust-tower-http+cors-devel.sha256sum] = "e9406423e59b12bb1d4a22aa8276258dff6b182ad868528c6106d68cbca34b0d"

URI_aarch64_rust-tower-http+decompression-br-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-br-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+decompression-br-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-br-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-br-devel.sha256sum] = "8c3fb5fc20a1b942c73cba6e414e34d913ba6f198857c91a2ee8b3cc1720fae3"

URI_aarch64_rust-tower-http+decompression-deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-deflate-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+decompression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-deflate-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-deflate-devel.sha256sum] = "0186ef231d995288b37a14ca46e783006d97432a2cbbb25531fc0e90689ddb6f"

URI_aarch64_rust-tower-http+decompression-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-full-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+decompression-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-full-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-full-devel.sha256sum] = "6f74c8543581b5939262ce4eaee04f2022b11484b6aa6466a20742bc7bef1945"

URI_aarch64_rust-tower-http+decompression-gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-gzip-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+decompression-gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-gzip-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-gzip-devel.sha256sum] = "49131f618b35c80b9215d637809d55afc3d15d40a0e6caf5356ebd416e5248fd"

URI_aarch64_rust-tower-http+decompression-zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-zstd-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+decompression-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-zstd-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-zstd-devel.sha256sum] = "665108aaa5740a2f69df9a2e7534da65f6503532304384f7c5f0144a550215e4"

URI_aarch64_rust-tower-http+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+default-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+default-devel}"
SRC_URI[aarch64_rust-tower-http+default-devel.sha256sum] = "d5476d86ccfe74fc72f1d4551316e2f0f0b0d4597d9f94f3b75182632c9f0d44"

URI_aarch64_rust-tower-http+follow-redirect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+follow-redirect-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+follow-redirect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+follow-redirect-devel}"
SRC_URI[aarch64_rust-tower-http+follow-redirect-devel.sha256sum] = "2ae15643a7bcfeeec00da7764fa2be18e4c51cc29e5128c64743bc246779195b"

URI_aarch64_rust-tower-http+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+fs-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+fs-devel}"
SRC_URI[aarch64_rust-tower-http+fs-devel.sha256sum] = "d336da20edd85906be6abd5ca5d2641732eda196c35cfb7027dec66aca918452"

URI_aarch64_rust-tower-http+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+full-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+full-devel}"
SRC_URI[aarch64_rust-tower-http+full-devel.sha256sum] = "f62ac5a768b813e6249e5ad188a7f612394ae163dbb53bca9ecfe713506cb841"

URI_aarch64_rust-tower-http+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+futures-core-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+futures-core-devel}"
SRC_URI[aarch64_rust-tower-http+futures-core-devel.sha256sum] = "75119a09008078c4d319bb4352343cd02747589c13d68b35389d7bc18659cb8e"

URI_aarch64_rust-tower-http+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+futures-util-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+futures-util-devel}"
SRC_URI[aarch64_rust-tower-http+futures-util-devel.sha256sum] = "70ec9b462cd224d26265e1710ee7281b729a3a99cb80a734c4109e9254fd998c"

URI_aarch64_rust-tower-http+httpdate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+httpdate-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+httpdate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+httpdate-devel}"
SRC_URI[aarch64_rust-tower-http+httpdate-devel.sha256sum] = "e0a4b984b6e13168a17d51bb1c7cb612f102398efba99af05d0ebfb53de09ecc"

URI_aarch64_rust-tower-http+iri-string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+iri-string-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+iri-string-devel}"
SRC_URI[aarch64_rust-tower-http+iri-string-devel.sha256sum] = "9067252a661418915daefbab0d7602786af0d98e2c482e3e0214aabf65776ad9"

URI_aarch64_rust-tower-http+limit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+limit-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+limit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+limit-devel}"
SRC_URI[aarch64_rust-tower-http+limit-devel.sha256sum] = "ec26297e133b7eff2583f363e993e7964e43911a69ebd96d17331957b1b8ea68"

URI_aarch64_rust-tower-http+map-request-body-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+map-request-body-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+map-request-body-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+map-request-body-devel}"
SRC_URI[aarch64_rust-tower-http+map-request-body-devel.sha256sum] = "4769a3e01ea6733115e63f483d169e6fd341bac5a61756b48783c7fca4374967"

URI_aarch64_rust-tower-http+map-response-body-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+map-response-body-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+map-response-body-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+map-response-body-devel}"
SRC_URI[aarch64_rust-tower-http+map-response-body-devel.sha256sum] = "945351f64bd5539372d673f9f3e78d99e88882ac7702736d28d60598fbd4b957"

URI_aarch64_rust-tower-http+metrics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+metrics-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+metrics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+metrics-devel}"
SRC_URI[aarch64_rust-tower-http+metrics-devel.sha256sum] = "a4e10de5d34c69d441352d894274193c1b7078efd2a2404ef5cac4b3f8a6744c"

URI_aarch64_rust-tower-http+mime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+mime-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+mime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+mime-devel}"
SRC_URI[aarch64_rust-tower-http+mime-devel.sha256sum] = "1ebee951751e0fc56d47cbe1d8946d3769dbbc7b65939bacde5e5cc6e31b3f9f"

URI_aarch64_rust-tower-http+mime_guess-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+mime_guess-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+mime_guess-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+mime_guess-devel}"
SRC_URI[aarch64_rust-tower-http+mime_guess-devel.sha256sum] = "7149de8e259feb1a70fb1b2f8ec753f26b4071f3458480ecbb1a579817ff7d48"

URI_aarch64_rust-tower-http+normalize-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+normalize-path-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+normalize-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+normalize-path-devel}"
SRC_URI[aarch64_rust-tower-http+normalize-path-devel.sha256sum] = "d31969636e72d441de9f6df4f0cc96a96ad31776c9188f1873375cf273e82477"

URI_aarch64_rust-tower-http+percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+percent-encoding-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+percent-encoding-devel}"
SRC_URI[aarch64_rust-tower-http+percent-encoding-devel.sha256sum] = "b795842f3196d91f9d2a9ef9c1a4f01f1975d328284116fe08b0f218cc13d8db"

URI_aarch64_rust-tower-http+propagate-header-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+propagate-header-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+propagate-header-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+propagate-header-devel}"
SRC_URI[aarch64_rust-tower-http+propagate-header-devel.sha256sum] = "bb42ec59ef2dc5987eae418cf8c0cac84e7d5d47b912128e61ca4507210ef444"

URI_aarch64_rust-tower-http+redirect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+redirect-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+redirect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+redirect-devel}"
SRC_URI[aarch64_rust-tower-http+redirect-devel.sha256sum] = "03150d59f90444217fecf3c806a78f9258adf22721fd6d7720ef2436db7f4c2c"

URI_aarch64_rust-tower-http+request-id-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+request-id-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+request-id-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+request-id-devel}"
SRC_URI[aarch64_rust-tower-http+request-id-devel.sha256sum] = "ea350aa61ef5daed4db0bec1e2ef089f4af6bcb54548614cb2e66d98795958b4"

URI_aarch64_rust-tower-http+sensitive-headers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+sensitive-headers-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+sensitive-headers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+sensitive-headers-devel}"
SRC_URI[aarch64_rust-tower-http+sensitive-headers-devel.sha256sum] = "b06f3db755cbbb381504ee9710ea81aa041ff00df1261690a91980fe4e06e206"

URI_aarch64_rust-tower-http+set-header-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+set-header-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+set-header-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+set-header-devel}"
SRC_URI[aarch64_rust-tower-http+set-header-devel.sha256sum] = "a920fda9c94760f067647b3dfe0ddb5cdf51da8a691f45c388b5851f12e72bd6"

URI_aarch64_rust-tower-http+set-status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+set-status-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+set-status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+set-status-devel}"
SRC_URI[aarch64_rust-tower-http+set-status-devel.sha256sum] = "2143d750b0d6ea9da8b8dd8832210288454977ec059c0ee6cb72936c02440cba"

URI_aarch64_rust-tower-http+timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+timeout-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+timeout-devel}"
SRC_URI[aarch64_rust-tower-http+timeout-devel.sha256sum] = "2abe36dd9615f0b6426caa10b794e1414afdba2cb4656d4b49aa1553eda98b5a"

URI_aarch64_rust-tower-http+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tokio-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+tokio-devel}"
SRC_URI[aarch64_rust-tower-http+tokio-devel.sha256sum] = "07a153f03063baa4d6a4bc6588a6483129a56bad6b672ff75c911e911a221802"

URI_aarch64_rust-tower-http+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tokio-util-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+tokio-util-devel}"
SRC_URI[aarch64_rust-tower-http+tokio-util-devel.sha256sum] = "2eac699017a3528b03ab13ab4715ca52667c1899e00b38cc155993eaed98777c"

URI_aarch64_rust-tower-http+tower-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tower-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+tower-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+tower-devel}"
SRC_URI[aarch64_rust-tower-http+tower-devel.sha256sum] = "0ce724389057c03169285d68cd841f0ec5cb27f27c2d5931d80fd440c74db161"

URI_aarch64_rust-tower-http+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+trace-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+trace-devel}"
SRC_URI[aarch64_rust-tower-http+trace-devel.sha256sum] = "a218f8a9e70b2c87f3ffe9d597b4e48eb6075dad066aed13a772d3188d02edd1"

URI_aarch64_rust-tower-http+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tracing-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+tracing-devel}"
SRC_URI[aarch64_rust-tower-http+tracing-devel.sha256sum] = "f491ea79b54e0a073080b25a6d6090af2cfac27cd498b8814547d09d1c313824"

URI_aarch64_rust-tower-http+util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+util-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+util-devel}"
SRC_URI[aarch64_rust-tower-http+util-devel.sha256sum] = "d8a152eb0a71ce2f57763cad056f954e1923dce8f0fb4ffa14ffea5a8cf9c9f2"

URI_aarch64_rust-tower-http+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+uuid-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+uuid-devel}"
SRC_URI[aarch64_rust-tower-http+uuid-devel.sha256sum] = "28a2ce3dc17d32b662572d121d1bbf0b1559ba5f345d181357a68da43aa93088"

URI_aarch64_rust-tower-http+validate-request-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+validate-request-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+validate-request-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+validate-request-devel}"
SRC_URI[aarch64_rust-tower-http+validate-request-devel.sha256sum] = "fb63a6b30f30c20f2040c1a7f66f34dd57186a074c2cb6a65f567cd97e0a4b89"

URI_aarch64_rust-tower-http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http-devel-0.6.8-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http-devel}"
SRC_URI[aarch64_rust-tower-http-devel.sha256sum] = "80799a64c60c6d8bbfbe3a310555ddbcdf2eed0360d76c74ed1089259bd0a63f"

RDEPENDS:rust-tower-http+add-extension-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+async-compression-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+auth-devel = " \
 cargo \
 rust-tower-http+base64-devel \
 rust-tower-http+validate-request-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+base64-devel = " \
 cargo \
 rust-base64_0.22+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+catch-panic-devel = " \
 cargo \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-br-devel = " \
 cargo \
 rust-async-compression+brotli-devel \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-deflate-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zlib-devel \
 rust-http-body+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-full-devel = " \
 cargo \
 rust-tower-http+compression-br-devel \
 rust-tower-http+compression-deflate-devel \
 rust-tower-http+compression-gzip-devel \
 rust-tower-http+compression-zstd-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-gzip-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-zstd-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zstd-devel \
 rust-http-body+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+cors-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-br-devel = " \
 cargo \
 rust-async-compression+brotli-devel \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-deflate-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zlib-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-full-devel = " \
 cargo \
 rust-tower-http+decompression-br-devel \
 rust-tower-http+decompression-deflate-devel \
 rust-tower-http+decompression-gzip-devel \
 rust-tower-http+decompression-zstd-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-gzip-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-zstd-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zstd-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+default-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+follow-redirect-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tower+default-devel \
 rust-tower+util-devel \
 rust-tower-http+futures-util-devel \
 rust-tower-http+iri-string-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+fs-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-http-range-header+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+futures-util-devel \
 rust-tower-http+httpdate-devel \
 rust-tower-http+mime-devel \
 rust-tower-http+mime_guess-devel \
 rust-tower-http+percent-encoding-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+full-devel = " \
 cargo \
 rust-tower-http+add-extension-devel \
 rust-tower-http+auth-devel \
 rust-tower-http+catch-panic-devel \
 rust-tower-http+compression-full-devel \
 rust-tower-http+cors-devel \
 rust-tower-http+decompression-full-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http+fs-devel \
 rust-tower-http+limit-devel \
 rust-tower-http+map-request-body-devel \
 rust-tower-http+map-response-body-devel \
 rust-tower-http+metrics-devel \
 rust-tower-http+normalize-path-devel \
 rust-tower-http+propagate-header-devel \
 rust-tower-http+redirect-devel \
 rust-tower-http+request-id-devel \
 rust-tower-http+sensitive-headers-devel \
 rust-tower-http+set-header-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+timeout-devel \
 rust-tower-http+trace-devel \
 rust-tower-http+util-devel \
 rust-tower-http+validate-request-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+futures-core-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+futures-util-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+httpdate-devel = " \
 cargo \
 rust-httpdate+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+iri-string-devel = " \
 cargo \
 rust-iri-string+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+limit-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+map-request-body-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+map-response-body-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+metrics-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+mime-devel = " \
 cargo \
 rust-mime-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+mime_guess-devel = " \
 cargo \
 rust-mime_guess-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+normalize-path-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+percent-encoding-devel = " \
 cargo \
 rust-percent-encoding+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+propagate-header-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+redirect-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+request-id-devel = " \
 cargo \
 rust-tower-http+uuid-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+sensitive-headers-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+set-header-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+set-status-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+timeout-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tokio-devel = " \
 cargo \
 rust-tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tokio-util-devel = " \
 cargo \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tower-devel = " \
 cargo \
 rust-tower+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+trace-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tracing-devel = " \
 cargo \
 rust-tower-http-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tower-http+util-devel = " \
 cargo \
 rust-tower-http+tower-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+uuid-devel = " \
 cargo \
 rust-tower-http-devel \
 rust-uuid+default-devel \
 rust-uuid+v4-devel \
 "
RDEPENDS:rust-tower-http+validate-request-devel = " \
 cargo \
 rust-tower-http+mime-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-pin-project-lite+default-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
