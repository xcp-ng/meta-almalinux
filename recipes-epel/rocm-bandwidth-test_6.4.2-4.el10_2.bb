# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-bandwidth-test"
PV = "6.4.2"
PR = "4.el10_2"
PACKAGES:x86_64_v2 = " \
 rocm-bandwidth-test \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-bandwidth-test-6.4.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e406e6cce968a7e9a7cbc412749636ab0a81eb949c81797061acac2580ab224d"

URI_x86_64_v2_rocm-bandwidth-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-bandwidth-test-6.4.2-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-bandwidth-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-bandwidth-test}"
SRC_URI[x86_64_v2_rocm-bandwidth-test.sha256sum] = "865d9b9497c44afeb089b1d0e2326a0ba775412c2a2e05eae2789115d765480c"

RDEPENDS:rocm-bandwidth-test = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-runtime \
 "
