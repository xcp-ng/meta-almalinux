# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klines"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 klines \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/klines-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd66da7c9e25e0b3bda87f68bd009eca7863c9eafcb90dc04084ad1145028fde"

URI_x86_64_v2_klines = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klines-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klines;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_klines}"
SRC_URI[x86_64_v2_klines.sha256sum] = "1b72a2fa4247b460b968dfc352e6ab9b34d89757f8ff1f3d2a81c76427d176e9"

URI_aarch64_klines = "${EPEL_MIRROR}/aarch64/Packages/k/klines-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_klines;unpack=0"
SRC_URI:append = " ${URI_aarch64_klines}"
SRC_URI[aarch64_klines.sha256sum] = "f29d66c168118cac2d1898c54bcaf0a5275b744f67178f55aa067cf62633b216"

RDEPENDS:klines = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
