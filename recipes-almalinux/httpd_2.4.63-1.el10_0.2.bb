# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "httpd"
PV = "2.4.63"
PR = "1.el10_0.2"
PACKAGES = " \
 httpd \
 httpd-core \
 httpd-devel \
 httpd-filesystem \
 httpd-manual \
 httpd-tools \
 mod_ldap \
 mod_lua \
 mod_proxy_html \
 mod_session \
 mod_ssl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/httpd-2.4.63-1.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5395bdb87639831eb3b4ba3aa9eb7c9ace1013d19b56ae0c2da8bc20181302f5"

URI_x86_64_v2_httpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-2.4.63-1.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd}"
SRC_URI[x86_64_v2_httpd.sha256sum] = "dc12bb10aff17309b71f303fdd686417315a3f41806312074af95aad8cf33c3d"
RPROVIDES:httpd:x86_64_v2 = "virtual/httpd_or_nginx virtual/webserver"

URI_x86_64_v2_httpd-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-core-2.4.63-1.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_httpd-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-core}"
SRC_URI[x86_64_v2_httpd-core.sha256sum] = "ae66ad09ac97832fb402c9b8c1c261e6d32ee3cd798161e3233365fd77324a05"

URI_x86_64_v2_httpd-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-devel-2.4.63-1.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_httpd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-devel}"
SRC_URI[x86_64_v2_httpd-devel.sha256sum] = "5c5e7f3c32d039d34b0c18e5266036e5063b9d24deccaccec6bc5e4a7390d176"

URI_x86_64_v2_httpd-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-filesystem-2.4.63-1.el10_0.2.noarch.rpm;name=x86_64_v2_httpd-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-filesystem}"
SRC_URI[x86_64_v2_httpd-filesystem.sha256sum] = "23f6f8235a3f05108a4d571c2d97070cde904bc10c499c19721e36118a0b3cb5"

URI_x86_64_v2_httpd-manual = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-manual-2.4.63-1.el10_0.2.noarch.rpm;name=x86_64_v2_httpd-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-manual}"
SRC_URI[x86_64_v2_httpd-manual.sha256sum] = "fa129998bfad24b227f00316175e1a55119eb8a181278169fd59b9353fd8be7f"

URI_x86_64_v2_httpd-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-tools-2.4.63-1.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_httpd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-tools}"
SRC_URI[x86_64_v2_httpd-tools.sha256sum] = "8c2b55d889838265ffd42fe66a3dc3927c6d6e7d5be9277621cf7d0644270ae6"

URI_x86_64_v2_mod_ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_ldap-2.4.63-1.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_mod_ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_ldap}"
SRC_URI[x86_64_v2_mod_ldap.sha256sum] = "edc7ecbc4a98d41fd1a78992c6ba73777031de6a12b9b0d36468b8e1c29bd54e"

URI_x86_64_v2_mod_lua = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_lua-2.4.63-1.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_mod_lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_lua}"
SRC_URI[x86_64_v2_mod_lua.sha256sum] = "5b1b17953b65404dbc77591967c0b058af5f153cefe3c3c56c6bcc7177cc89a2"

URI_x86_64_v2_mod_proxy_html = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_proxy_html-2.4.63-1.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_mod_proxy_html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_proxy_html}"
SRC_URI[x86_64_v2_mod_proxy_html.sha256sum] = "21bf95fdbd9f660382be50edc4658a74d8c148de6f0d61df8905e577bd159c7e"

URI_x86_64_v2_mod_session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_session-2.4.63-1.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_mod_session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_session}"
SRC_URI[x86_64_v2_mod_session.sha256sum] = "e753f9dece405168f7e570a5d3576a8f5fffdf4e7d594539d6c727718c07a215"

URI_x86_64_v2_mod_ssl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_ssl-2.4.63-1.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_mod_ssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_ssl}"
SRC_URI[x86_64_v2_mod_ssl.sha256sum] = "502de857d78e7178f768091e9b489bf3f736fe01ec107f2facae9106191475a9"

URI_aarch64_httpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-2.4.63-1.el10_0.2.aarch64.rpm;name=aarch64_httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd}"
SRC_URI[aarch64_httpd.sha256sum] = "2b16bf2ccc530932775a03b2f73d0f2199e40c6b469e1050f305a0a4e84c7536"
RPROVIDES:httpd:aarch64 = "virtual/httpd_or_nginx virtual/webserver"

URI_aarch64_httpd-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-core-2.4.63-1.el10_0.2.aarch64.rpm;name=aarch64_httpd-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-core}"
SRC_URI[aarch64_httpd-core.sha256sum] = "0c2084a1c5faa73d3e644ea11f43160c245453862dbc0bb7978315b20cc9d16b"

URI_aarch64_httpd-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-devel-2.4.63-1.el10_0.2.aarch64.rpm;name=aarch64_httpd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-devel}"
SRC_URI[aarch64_httpd-devel.sha256sum] = "c04777f96c9e65d7c1645a76448a961207d73d96e18e48282949f3bbbfea0ad7"

URI_aarch64_httpd-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-filesystem-2.4.63-1.el10_0.2.noarch.rpm;name=aarch64_httpd-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-filesystem}"
SRC_URI[aarch64_httpd-filesystem.sha256sum] = "23f6f8235a3f05108a4d571c2d97070cde904bc10c499c19721e36118a0b3cb5"

URI_aarch64_httpd-manual = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-manual-2.4.63-1.el10_0.2.noarch.rpm;name=aarch64_httpd-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-manual}"
SRC_URI[aarch64_httpd-manual.sha256sum] = "fa129998bfad24b227f00316175e1a55119eb8a181278169fd59b9353fd8be7f"

URI_aarch64_httpd-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-tools-2.4.63-1.el10_0.2.aarch64.rpm;name=aarch64_httpd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-tools}"
SRC_URI[aarch64_httpd-tools.sha256sum] = "4df3874b67a05d1e4b590aa2dbf9f7227de5fb1907db8db045650a82facd5866"

URI_aarch64_mod_ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_ldap-2.4.63-1.el10_0.2.aarch64.rpm;name=aarch64_mod_ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_ldap}"
SRC_URI[aarch64_mod_ldap.sha256sum] = "68ce39fc47867c1b2aed1a175e65dcbbe78fe361019b430b84a5bdfd83ab104d"

URI_aarch64_mod_lua = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_lua-2.4.63-1.el10_0.2.aarch64.rpm;name=aarch64_mod_lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_lua}"
SRC_URI[aarch64_mod_lua.sha256sum] = "89f10a195204e6a11553ad8ac484edd88562dcf0d5365ac2bd7b369b17b18634"

URI_aarch64_mod_proxy_html = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_proxy_html-2.4.63-1.el10_0.2.aarch64.rpm;name=aarch64_mod_proxy_html;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_proxy_html}"
SRC_URI[aarch64_mod_proxy_html.sha256sum] = "7e51ecb0f0865c65727013937e4de244d41ffc08527184d4622628be81e05d30"

URI_aarch64_mod_session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_session-2.4.63-1.el10_0.2.aarch64.rpm;name=aarch64_mod_session;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_session}"
SRC_URI[aarch64_mod_session.sha256sum] = "03f2a812bbdcaf54b1e1a60ba79feccc54fa0024595f5cb33ad75484b1801074"

URI_aarch64_mod_ssl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_ssl-2.4.63-1.el10_0.2.aarch64.rpm;name=aarch64_mod_ssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_ssl}"
SRC_URI[aarch64_mod_ssl.sha256sum] = "6c7c1ebef9b44bab4f029053509a2183a8a433080221d757aee1ab5674ce0bda"

RDEPENDS:httpd = " \
 almalinux-logos-httpd \
 bash \
 glibc \
 httpd-core \
 libbrotli \
 libselinux \
 systemd \
 systemd-libs \
 "
RDEPENDS:httpd-core = " \
 apr \
 apr-util \
 apr-util-lmdb \
 bash \
 glibc \
 httpd-filesystem \
 httpd-tools \
 mailcap \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:httpd-devel = " \
 apr-devel \
 apr-util-devel \
 bash \
 httpd-core \
 libtool \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:httpd-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:httpd-manual = " \
 httpd-core \
 "
RDEPENDS:httpd-tools = " \
 apr \
 apr-util \
 glibc \
 libxcrypt \
 openssl-libs \
 "
RDEPENDS:mod_ldap = " \
 apr-util-ldap \
 glibc \
 httpd-core \
 openldap \
 "
RDEPENDS:mod_lua = " \
 glibc \
 httpd-core \
 libxcrypt \
 lua-libs \
 "
RDEPENDS:mod_proxy_html = " \
 glibc \
 httpd-core \
 libxml2 \
 "
RDEPENDS:mod_session = " \
 glibc \
 httpd-core \
 "
RDEPENDS:mod_ssl = " \
 bash \
 glibc \
 hostname \
 httpd-core \
 httpd-filesystem \
 openssl-libs \
 sscg \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/httpd_or_nginx rpm/virtual/webserver"

PROVIDES:append:aarch64 = " rpm/virtual/httpd_or_nginx rpm/virtual/webserver"
