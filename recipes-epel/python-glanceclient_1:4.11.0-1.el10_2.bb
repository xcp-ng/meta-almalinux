# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-glanceclient"
PE = "1"
PV = "4.11.0"
PR = "1.el10_2"
PACKAGES = " \
 python-glanceclient-doc \
 python3-glanceclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-glanceclient-4.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "068a649cd0ea784fd6dc11f49dd4435ba2f1bcd17090129d9de1683061af27c6"

URI_x86_64_v2_python-glanceclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-glanceclient-doc-4.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-glanceclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-glanceclient-doc}"
SRC_URI[x86_64_v2_python-glanceclient-doc.sha256sum] = "c4890d6fb4736f921d658d2e70efd5f331b7116a400f77623c1b73c451019dd0"

URI_x86_64_v2_python3-glanceclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-glanceclient-4.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-glanceclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-glanceclient}"
SRC_URI[x86_64_v2_python3-glanceclient.sha256sum] = "b8365a3cd6728a2ccf56b07a428b6b52ac7f91b963648921abf0ffdb6587714b"

URI_aarch64_python-glanceclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-glanceclient-doc-4.11.0-1.el10_2.noarch.rpm;name=aarch64_python-glanceclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-glanceclient-doc}"
SRC_URI[aarch64_python-glanceclient-doc.sha256sum] = "1cfbe5ece9483e6ee76542382f245d7aea813c652fea1508eb387e1492395c8e"

URI_aarch64_python3-glanceclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-glanceclient-4.11.0-1.el10_2.noarch.rpm;name=aarch64_python3-glanceclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-glanceclient}"
SRC_URI[aarch64_python3-glanceclient.sha256sum] = "36b10e376fe026d4ffeb3da14500936d823d826079e40506dcad03b575054667"

RDEPENDS:python-glanceclient-doc = " \
 "
RDEPENDS:python3-glanceclient = " \
 python3 \
 python3-keystoneauth1 \
 python3-oslo-i18n \
 python3-oslo-utils \
 python3-pbr \
 python3-prettytable \
 python3-pyOpenSSL \
 python3-requests \
 python3-warlock \
 python3-wrapt \
 "
