# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hatch"
PV = "1.15.1"
PR = "2.el10_3"
PACKAGES = " \
 hatch \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/hatch-1.15.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c4d1094968b9fa62eb8cad6aa1bb4c234533b63d4c63f4bd732bdb2a89f038ee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hatch-1.15.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_hatch;unpack=0"
SRC_URI[x86_64_v2_hatch.sha256sum] = "1eecd4e8b444da9d9731f6458b93df9fc43b98d1ede9545e341a8beca5c0f8da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hatch-1.15.1-2.el10_3.noarch.rpm;name=aarch64_hatch;unpack=0"
SRC_URI[aarch64_hatch.sha256sum] = "544febc501b72f33d15672dc20ac87ff078f7f07daa6f14a0a5ea731f91bc394"

RDEPENDS:hatch = " \
 git-core \
 python3 \
 python3-click \
 python3-hatchling \
 python3-httpx \
 python3-hyperlink \
 python3-keyring \
 python3-packaging \
 python3-pexpect \
 python3-platformdirs \
 python3-rich \
 python3-shellingham \
 python3-tomli-w \
 python3-tomlkit \
 python3-userpath \
 python3-uv \
 python3-virtualenv \
 python3-zstandard \
 "
