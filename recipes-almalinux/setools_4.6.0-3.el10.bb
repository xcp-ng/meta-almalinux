# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setools"
PV = "4.6.0"
PR = "3.el10"
PACKAGES = " \
 python3-setools \
 setools \
 setools-console \
 setools-console-analyses \
 setools-gui \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/setools-4.6.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9db6f6ad547d54edc56c5d0cc4087ecd1cadc0246d62148b385566f252629ad"

URI_x86_64_v2_python3-setools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-setools-4.6.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-setools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-setools}"
SRC_URI[x86_64_v2_python3-setools.sha256sum] = "d49c0ba208d89c443d454d1f60f3219fc6cf7571c0e4908c9271ac750c183e80"

URI_x86_64_v2_setools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-4.6.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_setools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools}"
SRC_URI[x86_64_v2_setools.sha256sum] = "48f011749ceb2535cb37d617b8770286fbbf123ad8094205e6de340b5cd4bd39"

URI_x86_64_v2_setools-console = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/setools-console-4.6.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_setools-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools-console}"
SRC_URI[x86_64_v2_setools-console.sha256sum] = "11d51abc67940a7dc5dc4ec5d7034245fabced203c813aef6b7e39bb4a4b656a"

URI_x86_64_v2_setools-console-analyses = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-console-analyses-4.6.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_setools-console-analyses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools-console-analyses}"
SRC_URI[x86_64_v2_setools-console-analyses.sha256sum] = "15a5f0081830bb1a710acd84753edae063734607b17f3df2e957737ea41da0fc"

URI_x86_64_v2_setools-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-gui-4.6.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_setools-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools-gui}"
SRC_URI[x86_64_v2_setools-gui.sha256sum] = "21ec2ef0e9df8c3edfa3c0fc698f1699cc50ae54440ab3f9c3fc05bbc88d45aa"

URI_aarch64_python3-setools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-setools-4.6.0-3.el10.aarch64.rpm;name=aarch64_python3-setools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-setools}"
SRC_URI[aarch64_python3-setools.sha256sum] = "a451647e3d38f89fbc0cb4d896137fa417e1f7e90c2dfa8eea64f9280ac0c03b"

URI_aarch64_setools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-4.6.0-3.el10.aarch64.rpm;name=aarch64_setools;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools}"
SRC_URI[aarch64_setools.sha256sum] = "10c7809b7657851dfeaccc4f2c9c2b5555b6975dd5698ff051d7b66377ab2ee0"

URI_aarch64_setools-console = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/setools-console-4.6.0-3.el10.aarch64.rpm;name=aarch64_setools-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools-console}"
SRC_URI[aarch64_setools-console.sha256sum] = "37daac5316bf50a1e553c030c856b3140d078245f52f5ee943274a5c21c61d18"

URI_aarch64_setools-console-analyses = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-console-analyses-4.6.0-3.el10.aarch64.rpm;name=aarch64_setools-console-analyses;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools-console-analyses}"
SRC_URI[aarch64_setools-console-analyses.sha256sum] = "87fa68965319f3391b7ce02d60c5e3f3f34436d92411cbcec321cb9effc4fee2"

URI_aarch64_setools-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-gui-4.6.0-3.el10.aarch64.rpm;name=aarch64_setools-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools-gui}"
SRC_URI[aarch64_setools-gui.sha256sum] = "3082e54d24c3372805ce6355183c9e61436078f3d491987172717eff870cd7fa"

RDEPENDS:python3-setools = " \
 glibc \
 libselinux \
 libsepol \
 python3 \
 "
RDEPENDS:setools = " \
 setools-console \
 setools-console-analyses \
 setools-gui \
 "
RDEPENDS:setools-console = " \
 libselinux \
 python3 \
 python3-setools \
 "
RDEPENDS:setools-console-analyses = " \
 libselinux \
 python3 \
 python3-networkx \
 python3-setools \
 "
RDEPENDS:setools-gui = " \
 python3 \
 python3-networkx \
 python3-pyqt6 \
 python3-pyqt6-sip \
 python3-setools \
 "
