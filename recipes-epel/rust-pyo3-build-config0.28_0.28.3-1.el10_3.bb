# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-build-config0.28"
PV = "0.28.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-pyo3-build-config0.28+abi3-devel \
 rust-pyo3-build-config0.28+abi3-py310-devel \
 rust-pyo3-build-config0.28+abi3-py311-devel \
 rust-pyo3-build-config0.28+abi3-py312-devel \
 rust-pyo3-build-config0.28+abi3-py313-devel \
 rust-pyo3-build-config0.28+abi3-py314-devel \
 rust-pyo3-build-config0.28+abi3-py37-devel \
 rust-pyo3-build-config0.28+abi3-py38-devel \
 rust-pyo3-build-config0.28+abi3-py39-devel \
 rust-pyo3-build-config0.28+default-devel \
 rust-pyo3-build-config0.28+extension-module-devel \
 rust-pyo3-build-config0.28+resolve-config-devel \
 rust-pyo3-build-config0.28-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-build-config0.28-0.28.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec8ae1e103516b83c880f8bc8fa72d8cf4b5424400d8f93663ef2ac538cbfc46"

URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.28+abi3-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.28+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.28+abi3-devel.sha256sum] = "2188a296d047038a7310e70498a9ab3c6ee8c8c31ac2439587018616c949c27c"

URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.28+abi3-py310-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.28+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.28+abi3-py310-devel.sha256sum] = "f6049bc2859f138c4c0cc1add210cfc17ec93d446ce6a3d11a744fb242b5461a"

URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.28+abi3-py311-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.28+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.28+abi3-py311-devel.sha256sum] = "9adb4842fd9aa5da6bfa31f5890bbad9dd279ec58e45da70bd6e9fde0b177af6"

URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.28+abi3-py312-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.28+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.28+abi3-py312-devel.sha256sum] = "9c66219767d4145bc86c736822daa3fe0e5b15409e864d3e559c3974f60916df"

URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.28+abi3-py313-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.28+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.28+abi3-py313-devel.sha256sum] = "b8551c235759ca2e2c6618b539f71d00fa369b2ff9e080b3f7b908e5cb91d591"

URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.28+abi3-py314-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.28+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.28+abi3-py314-devel.sha256sum] = "9888a55efdd1b5b3b7731caca474cc7c9a2b2a110d9ae572cbff04c83c2e500c"

URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.28+abi3-py37-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.28+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.28+abi3-py37-devel.sha256sum] = "d808dc4eb95b443515167da1ff6fb4328e14afe48931564bd7150c80d1fcb08c"

URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.28+abi3-py38-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.28+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.28+abi3-py38-devel.sha256sum] = "f968f84989332e429519d2e99f7f9436e30f809e021b2d70cf5bda1f4cd08b6a"

URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.28+abi3-py39-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.28+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.28+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.28+abi3-py39-devel.sha256sum] = "7ff9124fa006ad7a830b8120332ec61b790afd61de9f2ad8463e9b50042da7f6"

URI_x86_64_v2_rust-pyo3-build-config0.28+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.28+default-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.28+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.28+default-devel.sha256sum] = "ebf8cc3a97b5cf68a1695ac766ec4e74a840405ca93d2e16636da6d892d88c5e"

URI_x86_64_v2_rust-pyo3-build-config0.28+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.28+extension-module-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.28+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.28+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.28+extension-module-devel.sha256sum] = "c4fe93940cce7e5a936034341595c1427c4073237312802a87374643473076d5"

URI_x86_64_v2_rust-pyo3-build-config0.28+resolve-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.28+resolve-config-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.28+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.28+resolve-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.28+resolve-config-devel.sha256sum] = "ba434100189eb06cef4b015f66f11e6f8ac4e2bc6604dadd672ec4e632a9f657"

URI_x86_64_v2_rust-pyo3-build-config0.28-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.28-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.28-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.28-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.28-devel.sha256sum] = "16adb59e7637828789d3c8a7a46adc5bcd43d3dcd8e028d5caa641dbdf0025a1"

URI_aarch64_rust-pyo3-build-config0.28+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.28+abi3-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config0.28+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.28+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.28+abi3-devel.sha256sum] = "d1c30630f33c8ea9bfdfe772b3aa2278d7451d03c10a4e629edcde45f18bfc89"

URI_aarch64_rust-pyo3-build-config0.28+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.28+abi3-py310-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config0.28+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.28+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.28+abi3-py310-devel.sha256sum] = "ef0e6b69a9b047d4ee886fd4d36f67dd00cc2face518edeec156fb992c7c44e0"

URI_aarch64_rust-pyo3-build-config0.28+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.28+abi3-py311-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config0.28+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.28+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.28+abi3-py311-devel.sha256sum] = "b76d8ac69bb77f7f0798508ceb82f097f42080c2c44fd8453820ca430080d8be"

URI_aarch64_rust-pyo3-build-config0.28+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.28+abi3-py312-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config0.28+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.28+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.28+abi3-py312-devel.sha256sum] = "f6ba39f8d2326fb78f174750000aad61578718a01836ab8df273cb1f9749d1a7"

URI_aarch64_rust-pyo3-build-config0.28+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.28+abi3-py313-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config0.28+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.28+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.28+abi3-py313-devel.sha256sum] = "48da51922c4dd1573622bca44c560bcb1eacdd1b232b2bf3b7b8a4c7a5afd1a0"

URI_aarch64_rust-pyo3-build-config0.28+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.28+abi3-py314-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config0.28+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.28+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.28+abi3-py314-devel.sha256sum] = "38e1a8259c6a8430894f8619790eeef3ee44365bae140f695d90a591cf2e6eea"

URI_aarch64_rust-pyo3-build-config0.28+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.28+abi3-py37-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config0.28+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.28+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.28+abi3-py37-devel.sha256sum] = "7b28b515cf64f37fd1dabd6e62af8ba3a5592eb30c8351a8bfaf4206a2b4edc7"

URI_aarch64_rust-pyo3-build-config0.28+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.28+abi3-py38-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config0.28+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.28+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.28+abi3-py38-devel.sha256sum] = "8ad57349e2e6cb0aba6881eca71d07fbdfca8b7af597b75167d12d7e5306b6d3"

URI_aarch64_rust-pyo3-build-config0.28+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.28+abi3-py39-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config0.28+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.28+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.28+abi3-py39-devel.sha256sum] = "db393b40003cf751a64caf39ddfc01565f9822adfd3243aecd2a4e06cc8afffa"

URI_aarch64_rust-pyo3-build-config0.28+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.28+default-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.28+default-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.28+default-devel.sha256sum] = "a8583cfda6579c1c2af184c3d360e39e5d60a1f8f064d0421cad1633c5c25565"

URI_aarch64_rust-pyo3-build-config0.28+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.28+extension-module-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config0.28+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.28+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.28+extension-module-devel.sha256sum] = "c987708888bb28bace2f6baab0ca33ba48e162a76b00cd3a9dcb4089930a28a5"

URI_aarch64_rust-pyo3-build-config0.28+resolve-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.28+resolve-config-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config0.28+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.28+resolve-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.28+resolve-config-devel.sha256sum] = "33f529aafbfe02c86798cdf627b16646fc05caa92d8bd1877f1cfc3935890904"

URI_aarch64_rust-pyo3-build-config0.28-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.28-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config0.28-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.28-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.28-devel.sha256sum] = "64e7f8d915435ffc0b14ae6d32a08be386af8fb51eaf2740d45cb11ff582b19e"

RDEPENDS:rust-pyo3-build-config0.28+abi3-devel = " \
 cargo \
 rust-pyo3-build-config0.28-devel \
 "
RDEPENDS:rust-pyo3-build-config0.28+abi3-py310-devel = " \
 cargo \
 rust-pyo3-build-config0.28+abi3-py311-devel \
 rust-pyo3-build-config0.28-devel \
 "
RDEPENDS:rust-pyo3-build-config0.28+abi3-py311-devel = " \
 cargo \
 rust-pyo3-build-config0.28+abi3-py312-devel \
 rust-pyo3-build-config0.28-devel \
 "
RDEPENDS:rust-pyo3-build-config0.28+abi3-py312-devel = " \
 cargo \
 rust-pyo3-build-config0.28+abi3-py313-devel \
 rust-pyo3-build-config0.28-devel \
 "
RDEPENDS:rust-pyo3-build-config0.28+abi3-py313-devel = " \
 cargo \
 rust-pyo3-build-config0.28+abi3-py314-devel \
 rust-pyo3-build-config0.28-devel \
 "
RDEPENDS:rust-pyo3-build-config0.28+abi3-py314-devel = " \
 cargo \
 rust-pyo3-build-config0.28+abi3-devel \
 rust-pyo3-build-config0.28-devel \
 "
RDEPENDS:rust-pyo3-build-config0.28+abi3-py37-devel = " \
 cargo \
 rust-pyo3-build-config0.28+abi3-py38-devel \
 rust-pyo3-build-config0.28-devel \
 "
RDEPENDS:rust-pyo3-build-config0.28+abi3-py38-devel = " \
 cargo \
 rust-pyo3-build-config0.28+abi3-py39-devel \
 rust-pyo3-build-config0.28-devel \
 "
RDEPENDS:rust-pyo3-build-config0.28+abi3-py39-devel = " \
 cargo \
 rust-pyo3-build-config0.28+abi3-py310-devel \
 rust-pyo3-build-config0.28-devel \
 "
RDEPENDS:rust-pyo3-build-config0.28+default-devel = " \
 cargo \
 rust-pyo3-build-config0.28-devel \
 "
RDEPENDS:rust-pyo3-build-config0.28+extension-module-devel = " \
 cargo \
 rust-pyo3-build-config0.28-devel \
 "
RDEPENDS:rust-pyo3-build-config0.28+resolve-config-devel = " \
 cargo \
 rust-pyo3-build-config0.28-devel \
 "
RDEPENDS:rust-pyo3-build-config0.28-devel = " \
 cargo \
 python3 \
 rust \
 rust-target-lexicon+default-devel \
 "
