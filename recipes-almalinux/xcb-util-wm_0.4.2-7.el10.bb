# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xcb-util-wm"
PV = "0.4.2"
PR = "7.el10"
PACKAGES = " \
 xcb-util-wm \
 xcb-util-wm-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xcb-util-wm-0.4.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efeb0bce05790af7bdbb6496fb4366b737358c3a6e1599908923af04b1888b46"

URI_x86_64_v2_xcb-util-wm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xcb-util-wm-0.4.2-7.el10.x86_64_v2.rpm;name=x86_64_v2_xcb-util-wm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcb-util-wm}"
SRC_URI[x86_64_v2_xcb-util-wm.sha256sum] = "d034877b48d8803f804285cc09a43f4b1866f7460680e812cb87255c87a8fe2c"

URI_x86_64_v2_xcb-util-wm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xcb-util-wm-devel-0.4.2-7.el10.x86_64_v2.rpm;name=x86_64_v2_xcb-util-wm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcb-util-wm-devel}"
SRC_URI[x86_64_v2_xcb-util-wm-devel.sha256sum] = "23bb59bf07b8fbfdc4693ccbd50a922a9b0ffc9526cdb8bcb8364ec8923203c2"

URI_aarch64_xcb-util-wm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xcb-util-wm-0.4.2-7.el10.aarch64.rpm;name=aarch64_xcb-util-wm;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcb-util-wm}"
SRC_URI[aarch64_xcb-util-wm.sha256sum] = "848d962d971a1dbd58c0107f9b8d621101e3b9728fc28f1d6a4b233363b9fcda"

URI_aarch64_xcb-util-wm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xcb-util-wm-devel-0.4.2-7.el10.aarch64.rpm;name=aarch64_xcb-util-wm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcb-util-wm-devel}"
SRC_URI[aarch64_xcb-util-wm-devel.sha256sum] = "c3c879d17b272e454a8e164b94e4c7bf630f001217b8e088ca3847c6f0515e6d"

RDEPENDS:xcb-util-wm = " \
 glibc \
 libxcb \
 "
RDEPENDS:xcb-util-wm-devel = " \
 libxcb-devel \
 pkgconf-pkg-config \
 xcb-util-wm \
 "
