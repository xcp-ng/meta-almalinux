# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwordquiz"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kwordquiz \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwordquiz-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d93ad29873bf132a7a0cee27b68ab81b56458e2ce1a3105ce8862727dfa4ed36"

URI_x86_64_v2_kwordquiz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwordquiz-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwordquiz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwordquiz}"
SRC_URI[x86_64_v2_kwordquiz.sha256sum] = "fe714130a19eee66ab790f2528342c0ad437fd817f13f0f0f2ef46b34905226c"

URI_aarch64_kwordquiz = "${EPEL_MIRROR}/aarch64/Packages/k/kwordquiz-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kwordquiz;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwordquiz}"
SRC_URI[aarch64_kwordquiz.sha256sum] = "5d448912cab9a98262f07a6727f572c32da1148833061b85a6f7adb1ec34cc07"

RDEPENDS:kwordquiz = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knewstuff \
 libkeduvocdocument \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
