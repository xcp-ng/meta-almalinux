# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "eggdrop"
PV = "1.10.2"
PR = "1.el10_2"
PACKAGES = " \
 eggdrop \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/eggdrop-1.10.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a9327ddc9ced1fb3d97c8d517f0ca176926fcb930ca357dcb6874c385753c603"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eggdrop-1.10.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eggdrop;unpack=0"
SRC_URI[x86_64_v2_eggdrop.sha256sum] = "38002e755fd64ef4ec79fb470066f3b62392f894e1d522567b035fbfcbd40f2d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/eggdrop-1.10.2-1.el10_2.aarch64.rpm;name=aarch64_eggdrop;unpack=0"
SRC_URI[aarch64_eggdrop.sha256sum] = "81f207ef3c2ec596ff81b463369432229b14f07d71f16f721b753b13099efdee"

RDEPENDS:eggdrop = " \
 bash \
 glibc \
 openssl-libs \
 python3-libs \
 tcl \
 zlib-ng-compat \
 "
