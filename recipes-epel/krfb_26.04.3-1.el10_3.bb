# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krfb"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 krfb \
 krfb-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krfb-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e481009f46c92c3e9401114f2b6bb9a897b3e305584e7ac7c22f38d93ef0585"

URI_x86_64_v2_krfb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krfb-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krfb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krfb}"
SRC_URI[x86_64_v2_krfb.sha256sum] = "68429ef72658ab79fa1b7a62aec804c2830dc5feb435e25511bedad02a7cf500"

URI_x86_64_v2_krfb-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krfb-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krfb-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krfb-libs}"
SRC_URI[x86_64_v2_krfb-libs.sha256sum] = "c184aed0a84f85683b82be0013639bf2b2d9cbff75bdfa9e04604fffb4c755d7"

URI_aarch64_krfb = "${EPEL_MIRROR}/aarch64/Packages/k/krfb-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_krfb;unpack=0"
SRC_URI:append = " ${URI_aarch64_krfb}"
SRC_URI[aarch64_krfb.sha256sum] = "d8422e492dee2b2f4edeb23994c9c44fc36f6ad4cdfba009bf50861c682ddc25"

URI_aarch64_krfb-libs = "${EPEL_MIRROR}/aarch64/Packages/k/krfb-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_krfb-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krfb-libs}"
SRC_URI[aarch64_krfb-libs.sha256sum] = "ae540aac800a35b6cfe7548ac9d4144610461fc73abf8254e9116587125b9139"

RDEPENDS:krfb = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 krfb-libs \
 libXtst \
 libstdc++ \
 libvncserver \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:krfb-libs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kpipewire \
 krfb \
 kwayland \
 libX11 \
 libXtst \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 xcb-util-image \
 "
