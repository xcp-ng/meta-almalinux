# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sysinfo0.33"
PV = "0.33.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-sysinfo0.33+c-interface-devel \
 rust-sysinfo0.33+component-devel \
 rust-sysinfo0.33+debug-devel \
 rust-sysinfo0.33+default-devel \
 rust-sysinfo0.33+disk-devel \
 rust-sysinfo0.33+linux-netdevs-devel \
 rust-sysinfo0.33+linux-tmpfs-devel \
 rust-sysinfo0.33+multithread-devel \
 rust-sysinfo0.33+network-devel \
 rust-sysinfo0.33+serde-devel \
 rust-sysinfo0.33+system-devel \
 rust-sysinfo0.33+user-devel \
 rust-sysinfo0.33-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sysinfo0.33-0.33.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d52edb058cf52562243d3f7a0ff390255ccde54b98bafa99c19ac831423d06ea"

URI_x86_64_v2_rust-sysinfo0.33+c-interface-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.33+c-interface-devel-0.33.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.33+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.33+c-interface-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.33+c-interface-devel.sha256sum] = "fb5f52fd181e57fa193c6d232b902eeb2ff2cc177942097f97157d67d54cae1d"

URI_x86_64_v2_rust-sysinfo0.33+component-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.33+component-devel-0.33.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.33+component-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.33+component-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.33+component-devel.sha256sum] = "0287a66cfde0b28c8835e1bdab7c8f797b061dcc609e64e24024717b8aebdc1c"

URI_x86_64_v2_rust-sysinfo0.33+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.33+debug-devel-0.33.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.33+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.33+debug-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.33+debug-devel.sha256sum] = "172b5dd48802b73ff5650c0da9bab57aa3f6cb713347a20d1cb0dcf7067c5a3c"

URI_x86_64_v2_rust-sysinfo0.33+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.33+default-devel-0.33.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.33+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.33+default-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.33+default-devel.sha256sum] = "30acfd010092d8b65540f571b72d8b36fe0071ba5ff9f5603f416a6e46d66126"

URI_x86_64_v2_rust-sysinfo0.33+disk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.33+disk-devel-0.33.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.33+disk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.33+disk-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.33+disk-devel.sha256sum] = "925d6e8d7f9f6c51f48f813f85c538addf213d328e6c3dedd54a4f3e136a6b7a"

URI_x86_64_v2_rust-sysinfo0.33+linux-netdevs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.33+linux-netdevs-devel-0.33.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.33+linux-netdevs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.33+linux-netdevs-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.33+linux-netdevs-devel.sha256sum] = "a55e8f096db03280d1c0f57e9e3eefe8257f444f912007137183f0ae967b2e71"

URI_x86_64_v2_rust-sysinfo0.33+linux-tmpfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.33+linux-tmpfs-devel-0.33.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.33+linux-tmpfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.33+linux-tmpfs-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.33+linux-tmpfs-devel.sha256sum] = "fd7756b9db4b7667bad81b30f7ae153c331bb7f1f7b244d02da0bc003f16ef6f"

URI_x86_64_v2_rust-sysinfo0.33+multithread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.33+multithread-devel-0.33.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.33+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.33+multithread-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.33+multithread-devel.sha256sum] = "97251691b1fa8784b5e7b6a75ad35634f3fe6551b254a68b405f36356678b5c2"

URI_x86_64_v2_rust-sysinfo0.33+network-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.33+network-devel-0.33.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.33+network-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.33+network-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.33+network-devel.sha256sum] = "f39c8bc3896ea22da7a19af559a6e34c33e9358f4a25cb84fd94c7e211f3322d"

URI_x86_64_v2_rust-sysinfo0.33+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.33+serde-devel-0.33.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.33+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.33+serde-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.33+serde-devel.sha256sum] = "f3e5423ebcc6988c2e604474939d8255cdf179c2b1eb09fddc88b278fcd74df7"

URI_x86_64_v2_rust-sysinfo0.33+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.33+system-devel-0.33.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.33+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.33+system-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.33+system-devel.sha256sum] = "4dcd907e0132e24b8e2ee2fa696167fd3d41bf80c7b55cf6a389b657c2b24213"

URI_x86_64_v2_rust-sysinfo0.33+user-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.33+user-devel-0.33.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.33+user-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.33+user-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.33+user-devel.sha256sum] = "78f5a80ec1eeb0369082f9c24e63e1b17ab49bcdfbb6fb7dd2ffddafa01c1d0c"

URI_x86_64_v2_rust-sysinfo0.33-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.33-devel-0.33.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.33-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.33-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.33-devel.sha256sum] = "ac885ca9dc60f49bbc972d557e9b6dc6b23649bba85f721048b5debe91b6fb31"

URI_aarch64_rust-sysinfo0.33+c-interface-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.33+c-interface-devel-0.33.1-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.33+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.33+c-interface-devel}"
SRC_URI[aarch64_rust-sysinfo0.33+c-interface-devel.sha256sum] = "fcde073ba9ab21e02cbd3a174173778b7b8b86daa439fbf13f06638ce4919614"

URI_aarch64_rust-sysinfo0.33+component-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.33+component-devel-0.33.1-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.33+component-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.33+component-devel}"
SRC_URI[aarch64_rust-sysinfo0.33+component-devel.sha256sum] = "f88e7cf59f49f7709309875bbdfc22ea1c39419e15f0675c950a62e11d5c320c"

URI_aarch64_rust-sysinfo0.33+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.33+debug-devel-0.33.1-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.33+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.33+debug-devel}"
SRC_URI[aarch64_rust-sysinfo0.33+debug-devel.sha256sum] = "7237d4993d750d8194701f080540d720dc9cf4f751cb8706f95d0d07fb900deb"

URI_aarch64_rust-sysinfo0.33+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.33+default-devel-0.33.1-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.33+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.33+default-devel}"
SRC_URI[aarch64_rust-sysinfo0.33+default-devel.sha256sum] = "2bee50d148ed6b30b79dcddfe795b7029fd9cda8f9e9762329944b877721119f"

URI_aarch64_rust-sysinfo0.33+disk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.33+disk-devel-0.33.1-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.33+disk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.33+disk-devel}"
SRC_URI[aarch64_rust-sysinfo0.33+disk-devel.sha256sum] = "b11264902fb63f9dc10e523f04448e39dfc8e048a4b1aa2e51c5ce7a42f22f0a"

URI_aarch64_rust-sysinfo0.33+linux-netdevs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.33+linux-netdevs-devel-0.33.1-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.33+linux-netdevs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.33+linux-netdevs-devel}"
SRC_URI[aarch64_rust-sysinfo0.33+linux-netdevs-devel.sha256sum] = "ca5352cdcb8d5a38f7e9f84df82c036485b391e038d8b6f6629e291ff4415569"

URI_aarch64_rust-sysinfo0.33+linux-tmpfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.33+linux-tmpfs-devel-0.33.1-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.33+linux-tmpfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.33+linux-tmpfs-devel}"
SRC_URI[aarch64_rust-sysinfo0.33+linux-tmpfs-devel.sha256sum] = "6f0396a1b94059503f90947c94257556292d8e3cc01a684632e5de0ec6999712"

URI_aarch64_rust-sysinfo0.33+multithread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.33+multithread-devel-0.33.1-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.33+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.33+multithread-devel}"
SRC_URI[aarch64_rust-sysinfo0.33+multithread-devel.sha256sum] = "9391cf4684d9c417bb6576153538d7e35bda4045cd0be38f7b090baf031a3b0a"

URI_aarch64_rust-sysinfo0.33+network-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.33+network-devel-0.33.1-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.33+network-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.33+network-devel}"
SRC_URI[aarch64_rust-sysinfo0.33+network-devel.sha256sum] = "61f6f2a23da571cb9f612f6dee2b3201d446d9e09cbfbb26529ec7ba7693b63b"

URI_aarch64_rust-sysinfo0.33+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.33+serde-devel-0.33.1-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.33+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.33+serde-devel}"
SRC_URI[aarch64_rust-sysinfo0.33+serde-devel.sha256sum] = "c56d6c990749cfc3ca9347f63737baae7ae4d7c5c24425bc9ae015ab80765592"

URI_aarch64_rust-sysinfo0.33+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.33+system-devel-0.33.1-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.33+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.33+system-devel}"
SRC_URI[aarch64_rust-sysinfo0.33+system-devel.sha256sum] = "560f241b67bb62641fda06204ed2b0d1cfe1635d4881248b3ccc9be9918e7e4d"

URI_aarch64_rust-sysinfo0.33+user-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.33+user-devel-0.33.1-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.33+user-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.33+user-devel}"
SRC_URI[aarch64_rust-sysinfo0.33+user-devel.sha256sum] = "0f808492c07c29c1ebd0ce14ef7063a7a79d58fa7fdf1f285c6980176c5a2a5c"

URI_aarch64_rust-sysinfo0.33-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.33-devel-0.33.1-1.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.33-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.33-devel}"
SRC_URI[aarch64_rust-sysinfo0.33-devel.sha256sum] = "440c7e8024816347ed34e7ac9b2ca72056ae233ca88f7d2706c6e33131360f6c"

RDEPENDS:rust-sysinfo0.33+c-interface-devel = " \
 cargo \
 rust-sysinfo0.33+default-devel \
 rust-sysinfo0.33-devel \
 "
RDEPENDS:rust-sysinfo0.33+component-devel = " \
 cargo \
 rust-sysinfo0.33-devel \
 "
RDEPENDS:rust-sysinfo0.33+debug-devel = " \
 cargo \
 rust-libc+extra_traits-devel \
 rust-sysinfo0.33-devel \
 "
RDEPENDS:rust-sysinfo0.33+default-devel = " \
 cargo \
 rust-sysinfo0.33+component-devel \
 rust-sysinfo0.33+disk-devel \
 rust-sysinfo0.33+multithread-devel \
 rust-sysinfo0.33+network-devel \
 rust-sysinfo0.33+system-devel \
 rust-sysinfo0.33+user-devel \
 rust-sysinfo0.33-devel \
 "
RDEPENDS:rust-sysinfo0.33+disk-devel = " \
 cargo \
 rust-sysinfo0.33-devel \
 "
RDEPENDS:rust-sysinfo0.33+linux-netdevs-devel = " \
 cargo \
 rust-sysinfo0.33-devel \
 "
RDEPENDS:rust-sysinfo0.33+linux-tmpfs-devel = " \
 cargo \
 rust-sysinfo0.33-devel \
 "
RDEPENDS:rust-sysinfo0.33+multithread-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-sysinfo0.33-devel \
 "
RDEPENDS:rust-sysinfo0.33+network-devel = " \
 cargo \
 rust-sysinfo0.33-devel \
 "
RDEPENDS:rust-sysinfo0.33+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-sysinfo0.33-devel \
 "
RDEPENDS:rust-sysinfo0.33+system-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-sysinfo0.33-devel \
 "
RDEPENDS:rust-sysinfo0.33+user-devel = " \
 cargo \
 rust-sysinfo0.33-devel \
 "
RDEPENDS:rust-sysinfo0.33-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
