# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcp"
PV = "7.0.3"
PR = "5.el10_2"
PACKAGES:x86_64_v2 = " \
 pcp \
 pcp-conf \
 pcp-devel \
 pcp-doc \
 pcp-export-pcp2elasticsearch \
 pcp-export-pcp2graphite \
 pcp-export-pcp2influxdb \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2opentelemetry \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-export-zabbix-agent \
 pcp-geolocate \
 pcp-gui \
 pcp-import-benchmarks \
 pcp-import-collectl2pcp \
 pcp-import-ganglia2pcp \
 pcp-import-iostat2pcp \
 pcp-import-mrtg2pcp \
 pcp-import-pmseries \
 pcp-import-sar2pcp \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bcc \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cifs \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-hdb \
 pcp-pmda-infiniband \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mssql \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-opentelemetry \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-perfevent \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-redis \
 pcp-pmda-resctrl \
 pcp-pmda-rocestat \
 pcp-pmda-roomtemp \
 pcp-pmda-rsyslog \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-systemd \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-selinux \
 pcp-system-tools \
 pcp-testsuite \
 pcp-zeroconf \
 perl-PCP-LogImport \
 perl-PCP-LogSummary \
 perl-PCP-MMV \
 perl-PCP-PMDA \
 python3-pcp \
"
PACKAGES:aarch64 = " \
 pcp \
 pcp-conf \
 pcp-devel \
 pcp-doc \
 pcp-export-pcp2elasticsearch \
 pcp-export-pcp2graphite \
 pcp-export-pcp2influxdb \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2opentelemetry \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-export-zabbix-agent \
 pcp-geolocate \
 pcp-gui \
 pcp-import-benchmarks \
 pcp-import-collectl2pcp \
 pcp-import-ganglia2pcp \
 pcp-import-iostat2pcp \
 pcp-import-mrtg2pcp \
 pcp-import-pmseries \
 pcp-import-sar2pcp \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bcc \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cifs \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-hdb \
 pcp-pmda-infiniband \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-opentelemetry \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-perfevent \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-redis \
 pcp-pmda-rocestat \
 pcp-pmda-roomtemp \
 pcp-pmda-rsyslog \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-systemd \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-selinux \
 pcp-system-tools \
 pcp-testsuite \
 pcp-zeroconf \
 perl-PCP-LogImport \
 perl-PCP-LogSummary \
 perl-PCP-MMV \
 perl-PCP-PMDA \
 python3-pcp \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pcp-7.0.3-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73e0acf9501641540d7ace2de98d460818ab7d0f8151cd63888bb013ca621536"

URI_x86_64_v2_pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp}"
SRC_URI[x86_64_v2_pcp.sha256sum] = "e9e2024b084ffa3f6a58adb215969bbe2ba14bd93926cd24b4569e4950d62741"

URI_x86_64_v2_pcp-conf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-conf-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-conf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-conf}"
SRC_URI[x86_64_v2_pcp-conf.sha256sum] = "b331ae3ad1899cc2ffcd60756f4dac17ee44279ea530d45a7a1196dadf43b00a"

URI_x86_64_v2_pcp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-devel-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-devel}"
SRC_URI[x86_64_v2_pcp-devel.sha256sum] = "eeb44b2b7012e1b12d1294a4c12e2cda102b959d10d16e333363b33cae62e214"

URI_x86_64_v2_pcp-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-doc-7.0.3-5.el10_2.noarch.rpm;name=x86_64_v2_pcp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-doc}"
SRC_URI[x86_64_v2_pcp-doc.sha256sum] = "94a7dc3f75afab71ce735dd038541108a4e6b18e03790db4d1e46bbc272ecb1d"

URI_x86_64_v2_pcp-export-pcp2elasticsearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2elasticsearch-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2elasticsearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2elasticsearch}"
SRC_URI[x86_64_v2_pcp-export-pcp2elasticsearch.sha256sum] = "4cc8060a6f2ee9931e60baee05ec9fa3924f30a3e12b7e023826c1e513f22333"

URI_x86_64_v2_pcp-export-pcp2graphite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2graphite-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2graphite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2graphite}"
SRC_URI[x86_64_v2_pcp-export-pcp2graphite.sha256sum] = "4674fc787e44bcc5ef0a7a55ac922e8eded05f4ebc5f1aff85e4b5c8ff01e535"

URI_x86_64_v2_pcp-export-pcp2influxdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2influxdb-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2influxdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2influxdb}"
SRC_URI[x86_64_v2_pcp-export-pcp2influxdb.sha256sum] = "6ff6b5195069e83120504c1c7c9cb5958c251654058dd2722eecec4befea18ac"

URI_x86_64_v2_pcp-export-pcp2json = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2json-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2json}"
SRC_URI[x86_64_v2_pcp-export-pcp2json.sha256sum] = "1f62a5790714ac2f4dd70e2866ece8ca85b5e4765d5239740a784bd74c4d6116"

URI_x86_64_v2_pcp-export-pcp2openmetrics = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2openmetrics-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2openmetrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2openmetrics}"
SRC_URI[x86_64_v2_pcp-export-pcp2openmetrics.sha256sum] = "07f39611b76b10c9e4f031a2024ea687723e1c4bdd30acbfe95c1a4c6a00112f"

URI_x86_64_v2_pcp-export-pcp2opentelemetry = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2opentelemetry-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2opentelemetry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2opentelemetry}"
SRC_URI[x86_64_v2_pcp-export-pcp2opentelemetry.sha256sum] = "3092766ce6f4cbb58ff8ee213caa8a160f5426243aa18b34c45e9a0f24b87cc3"

URI_x86_64_v2_pcp-export-pcp2spark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2spark-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2spark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2spark}"
SRC_URI[x86_64_v2_pcp-export-pcp2spark.sha256sum] = "60f969a71855ec3a729d6491a134595028106a3b199f7ac369b8cec159a874dc"

URI_x86_64_v2_pcp-export-pcp2xml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2xml-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2xml}"
SRC_URI[x86_64_v2_pcp-export-pcp2xml.sha256sum] = "18348da1f800df4b73aba478c4e26ae17da9e8f445e26ebf20bc3225e15fabfd"

URI_x86_64_v2_pcp-export-pcp2zabbix = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2zabbix-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2zabbix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2zabbix}"
SRC_URI[x86_64_v2_pcp-export-pcp2zabbix.sha256sum] = "9807ad22cb0564efec8ef3861d67a675747ff0a9e022dca75c400269a81a0706"

URI_x86_64_v2_pcp-export-zabbix-agent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-zabbix-agent-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-export-zabbix-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-zabbix-agent}"
SRC_URI[x86_64_v2_pcp-export-zabbix-agent.sha256sum] = "44c85d6e5910a63521c7d81f3d903dd7a6143f8dfafb2e94314ad2b109eaa672"

URI_x86_64_v2_pcp-geolocate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-geolocate-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-geolocate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-geolocate}"
SRC_URI[x86_64_v2_pcp-geolocate.sha256sum] = "ceb095165157ba9c29881feb966aea082e5690442f54140eeb5fed074ccfb8f4"

URI_x86_64_v2_pcp-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-gui-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-gui}"
SRC_URI[x86_64_v2_pcp-gui.sha256sum] = "aee72f654569b67041d04cb4b46141529bac2765c735bdcf859460e138a1599d"

URI_x86_64_v2_pcp-import-benchmarks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-benchmarks-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-import-benchmarks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-benchmarks}"
SRC_URI[x86_64_v2_pcp-import-benchmarks.sha256sum] = "8b5513a746677404a2b7880f5101dac851a7f673c1850d3b51d4f185595724f5"

URI_x86_64_v2_pcp-import-collectl2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-collectl2pcp-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-import-collectl2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-collectl2pcp}"
SRC_URI[x86_64_v2_pcp-import-collectl2pcp.sha256sum] = "d5fb9a574f7c8aecc963fc764aded367faacabf3b40de78350f6e825e3792dea"

URI_x86_64_v2_pcp-import-ganglia2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-ganglia2pcp-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-import-ganglia2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-ganglia2pcp}"
SRC_URI[x86_64_v2_pcp-import-ganglia2pcp.sha256sum] = "3f4161b073ef83432c55aec48efcdafb6447b49128e674f4c042d71dad8f1928"

URI_x86_64_v2_pcp-import-iostat2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-iostat2pcp-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-import-iostat2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-iostat2pcp}"
SRC_URI[x86_64_v2_pcp-import-iostat2pcp.sha256sum] = "c00369d1c5cf25f0a981eba7c18fef86d1034043df3f82fcec24afaebd7e0ee6"

URI_x86_64_v2_pcp-import-mrtg2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-mrtg2pcp-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-import-mrtg2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-mrtg2pcp}"
SRC_URI[x86_64_v2_pcp-import-mrtg2pcp.sha256sum] = "413b46f70df91bfec8351baa4ef94ee57a00accf1351665f37eb1eb6e19e62a9"

URI_x86_64_v2_pcp-import-pmseries = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-pmseries-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-import-pmseries;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-pmseries}"
SRC_URI[x86_64_v2_pcp-import-pmseries.sha256sum] = "1b642e29cb832e72b53709dad848ca2b3ddcb30cbab6de21931dbfc23e0a8215"

URI_x86_64_v2_pcp-import-sar2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-sar2pcp-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-import-sar2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-sar2pcp}"
SRC_URI[x86_64_v2_pcp-import-sar2pcp.sha256sum] = "da55c9fa362b18e9695ee1e0e922edda755b5a051fde0a4ce8a20ac5792f9db4"

URI_x86_64_v2_pcp-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-libs-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-libs}"
SRC_URI[x86_64_v2_pcp-libs.sha256sum] = "57e51adb943ad80363e0418a8c0100dfda1eb705cebdf93f2dcb43dbb8c6b934"

URI_x86_64_v2_pcp-libs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-libs-devel-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-libs-devel}"
SRC_URI[x86_64_v2_pcp-libs-devel.sha256sum] = "fc87d1711c6cc09ad5c2aefd9286b47178d9c3a561be63b4bf4aaea5f868c551"

URI_x86_64_v2_pcp-pmda-activemq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-activemq-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-activemq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-activemq}"
SRC_URI[x86_64_v2_pcp-pmda-activemq.sha256sum] = "c0a9f29e4ca09b7173b8e2f5dd97eb676a3c6483f9706c245d756be95f74f99e"

URI_x86_64_v2_pcp-pmda-amdgpu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-amdgpu-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-amdgpu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-amdgpu}"
SRC_URI[x86_64_v2_pcp-pmda-amdgpu.sha256sum] = "3e56bd302ecead6e4e6b80a17ffe3eff8a8e80b053d396d9a37b808d0d9245d8"

URI_x86_64_v2_pcp-pmda-apache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-apache-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-apache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-apache}"
SRC_URI[x86_64_v2_pcp-pmda-apache.sha256sum] = "7efa39157a6ed5873194a6c5ad2807e75d0b8befe16e1e32a6c5311b4851efd8"

URI_x86_64_v2_pcp-pmda-bash = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bash-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bash}"
SRC_URI[x86_64_v2_pcp-pmda-bash.sha256sum] = "98ac55855f1ad23b9f7356a3bb230b756b01287a57f7f4ef3e1c8238aed9cfaa"

URI_x86_64_v2_pcp-pmda-bcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bcc-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bcc}"
SRC_URI[x86_64_v2_pcp-pmda-bcc.sha256sum] = "07852c364becd0e8c3725e6519661f8eac61a6ba16fdd5adebd9675d0ad04b79"

URI_x86_64_v2_pcp-pmda-bind2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bind2-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bind2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bind2}"
SRC_URI[x86_64_v2_pcp-pmda-bind2.sha256sum] = "2cdbbdd5b6caa17bf2b40de67f231a2f2329a9c25cce83b97be7e195fde3a279"

URI_x86_64_v2_pcp-pmda-bonding = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bonding-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bonding;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bonding}"
SRC_URI[x86_64_v2_pcp-pmda-bonding.sha256sum] = "d960510d7ed45c1d36536a8a981a4429be4183e31412fdf81de5ccc54d6169c0"

URI_x86_64_v2_pcp-pmda-bpf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bpf-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bpf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bpf}"
SRC_URI[x86_64_v2_pcp-pmda-bpf.sha256sum] = "0e8691e9fdc5e980a388bc422ea6acdce24e2d7f6171351e0304711d199cb1b6"

URI_x86_64_v2_pcp-pmda-bpftrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bpftrace-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bpftrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bpftrace}"
SRC_URI[x86_64_v2_pcp-pmda-bpftrace.sha256sum] = "bc4d6c115cd597b3653724d6dfabce98ea8145a74bd0a7d91437d2ac1c174870"

URI_x86_64_v2_pcp-pmda-cifs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-cifs-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-cifs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-cifs}"
SRC_URI[x86_64_v2_pcp-pmda-cifs.sha256sum] = "9e5255b8f0e0657b6de4493f624cf654c3e2ef89d8b0b4ef3392ce92fa42ec41"

URI_x86_64_v2_pcp-pmda-cisco = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-cisco-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-cisco;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-cisco}"
SRC_URI[x86_64_v2_pcp-pmda-cisco.sha256sum] = "37f2b9a998a3d263944868585c2b80b111e80fed9bfd97aa9e2fd19f99a79903"

URI_x86_64_v2_pcp-pmda-dbping = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-dbping-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-dbping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-dbping}"
SRC_URI[x86_64_v2_pcp-pmda-dbping.sha256sum] = "a48f42d249818c50aae3f34045705246ed54103cd1e83a7f21892c64d768bba3"

URI_x86_64_v2_pcp-pmda-denki = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-denki-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-denki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-denki}"
SRC_URI[x86_64_v2_pcp-pmda-denki.sha256sum] = "43dcd8a23226ecec7221dc12425e59565eb1fd6f3105537add0a7b07cf49450d"

URI_x86_64_v2_pcp-pmda-dm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-dm-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-dm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-dm}"
SRC_URI[x86_64_v2_pcp-pmda-dm.sha256sum] = "ecd02a682013895f0512486707b5aa89f20f15bee6f62a8121be6573d54a37ac"

URI_x86_64_v2_pcp-pmda-docker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-docker-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-docker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-docker}"
SRC_URI[x86_64_v2_pcp-pmda-docker.sha256sum] = "7b6d5e5f5130a51ee4c1aaab1630cbd09e5fee5d27bd90715d7e29e9bdf870c0"

URI_x86_64_v2_pcp-pmda-ds389 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-ds389-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-ds389;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-ds389}"
SRC_URI[x86_64_v2_pcp-pmda-ds389.sha256sum] = "ad7ce2d663e7be9d3c0537355a3b616b07b7666290de1c581091f0a9b2be5f25"

URI_x86_64_v2_pcp-pmda-ds389log = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-ds389log-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-ds389log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-ds389log}"
SRC_URI[x86_64_v2_pcp-pmda-ds389log.sha256sum] = "6f503670bd6a789246cc9bd6d9073a1ef704420e887ebcf46d32b56061df9eb6"

URI_x86_64_v2_pcp-pmda-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-elasticsearch-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-elasticsearch}"
SRC_URI[x86_64_v2_pcp-pmda-elasticsearch.sha256sum] = "8afa49fb1fb286845de33fa02fccd9dcb02062d664daf95e4ca56d3eb2af0efd"

URI_x86_64_v2_pcp-pmda-farm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-farm-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-farm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-farm}"
SRC_URI[x86_64_v2_pcp-pmda-farm.sha256sum] = "f19e15adeccacb5de78c6061ebdf137fbb80d7615514b02fc615758c70e114af"

URI_x86_64_v2_pcp-pmda-gluster = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gluster-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gluster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-gluster}"
SRC_URI[x86_64_v2_pcp-pmda-gluster.sha256sum] = "a22e376f6460e93866b95b1eb63f7843918bec1be19a268f8281e41c28ad8293"

URI_x86_64_v2_pcp-pmda-gpfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gpfs-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gpfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-gpfs}"
SRC_URI[x86_64_v2_pcp-pmda-gpfs.sha256sum] = "a6e18ed7b8278bf66a92556077aed3a7b820bdea9624d2cc53c109aecfdeafca"

URI_x86_64_v2_pcp-pmda-gpsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gpsd-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gpsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-gpsd}"
SRC_URI[x86_64_v2_pcp-pmda-gpsd.sha256sum] = "dd4410a9dc690b200f12396da68904cb4172d08c73e527f0b117f84f4ca418ab"

URI_x86_64_v2_pcp-pmda-hacluster = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-hacluster-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-hacluster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-hacluster}"
SRC_URI[x86_64_v2_pcp-pmda-hacluster.sha256sum] = "9b4f4ccc86d459cdbca55105def55528d97dcc5b6af3625c13bc32dcfa360e69"

URI_x86_64_v2_pcp-pmda-haproxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-haproxy-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-haproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-haproxy}"
SRC_URI[x86_64_v2_pcp-pmda-haproxy.sha256sum] = "8e9988b8b8311e9880cdd992bce02b4d826477c3eded69477dadb11d8208775f"

URI_x86_64_v2_pcp-pmda-hdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-hdb-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-hdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-hdb}"
SRC_URI[x86_64_v2_pcp-pmda-hdb.sha256sum] = "1a94808675a931bed6bf7fa459214b230d3b0f93472f9b3d206aadf196454a6c"

URI_x86_64_v2_pcp-pmda-infiniband = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-infiniband-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-infiniband;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-infiniband}"
SRC_URI[x86_64_v2_pcp-pmda-infiniband.sha256sum] = "0df9a0e0ca3a14c6f7524a853cc64f98b755a1e7f88ab4f7038883cf8e8be317"

URI_x86_64_v2_pcp-pmda-libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-libvirt-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-libvirt}"
SRC_URI[x86_64_v2_pcp-pmda-libvirt.sha256sum] = "9416a4d7b9e147c941bf28ca97a48ea8831e98a9bbd5426be7af6b61f825e6ef"

URI_x86_64_v2_pcp-pmda-lio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lio-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lio}"
SRC_URI[x86_64_v2_pcp-pmda-lio.sha256sum] = "841b5591a7a090abbb39c3b0973b5b1951a4ede36c5de1af5a6aaebf37c21da5"

URI_x86_64_v2_pcp-pmda-lmsensors = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lmsensors-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lmsensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lmsensors}"
SRC_URI[x86_64_v2_pcp-pmda-lmsensors.sha256sum] = "cb84d807725d931315579326453bcf85e9e8b5160b3066a666baa35d876dba69"

URI_x86_64_v2_pcp-pmda-logger = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-logger-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-logger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-logger}"
SRC_URI[x86_64_v2_pcp-pmda-logger.sha256sum] = "c550a72bda0e8b53ca291f1d20121364732ff1abea25bb7b09e8251fa0b1f5bc"

URI_x86_64_v2_pcp-pmda-lustre = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lustre-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lustre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lustre}"
SRC_URI[x86_64_v2_pcp-pmda-lustre.sha256sum] = "3da4d4165a39d433ba52321f410762f2da6c2fd9d26fafe95a2af50d6a25aea4"

URI_x86_64_v2_pcp-pmda-lustrecomm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lustrecomm-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lustrecomm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lustrecomm}"
SRC_URI[x86_64_v2_pcp-pmda-lustrecomm.sha256sum] = "918bf1ec5fdc73f008ddae04797c14e7c165a70af8e4ec3768f2251238d728af"

URI_x86_64_v2_pcp-pmda-mailq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mailq-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mailq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mailq}"
SRC_URI[x86_64_v2_pcp-pmda-mailq.sha256sum] = "fd3a6503f116bbac74b47bcf1bae53823a13ba9e314351da3c67a00a79d553a6"

URI_x86_64_v2_pcp-pmda-memcache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-memcache-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-memcache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-memcache}"
SRC_URI[x86_64_v2_pcp-pmda-memcache.sha256sum] = "521cde8e9314361b84508b95b74a8c6f0acb06f040553e2d8560fb093bc1bf02"

URI_x86_64_v2_pcp-pmda-mic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mic-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mic}"
SRC_URI[x86_64_v2_pcp-pmda-mic.sha256sum] = "62fa872b764f299befcbce1bcf9c68939b7e7c9b87563228406394ea6dff2404"

URI_x86_64_v2_pcp-pmda-mongodb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mongodb-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mongodb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mongodb}"
SRC_URI[x86_64_v2_pcp-pmda-mongodb.sha256sum] = "7419a8a7d31a216917f356338348f7fa9216119d4a09eda51067870afd06cc89"

URI_x86_64_v2_pcp-pmda-mounts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mounts-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mounts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mounts}"
SRC_URI[x86_64_v2_pcp-pmda-mounts.sha256sum] = "a6f68ee4e626d50df5cba677d5245ddb2be679e801e410f3d75d107afd99da9e"

URI_x86_64_v2_pcp-pmda-mssql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mssql-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mssql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mssql}"
SRC_URI[x86_64_v2_pcp-pmda-mssql.sha256sum] = "b64c645d431aeb0fc0f5e56848344b1adbff80eed56b6de55d47804eccad6ff7"

URI_x86_64_v2_pcp-pmda-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mysql-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mysql}"
SRC_URI[x86_64_v2_pcp-pmda-mysql.sha256sum] = "6c0bc54f8f2fb49410175b815d28f224d4c252f118da2453544f2202c6eca679"

URI_x86_64_v2_pcp-pmda-named = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-named-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-named;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-named}"
SRC_URI[x86_64_v2_pcp-pmda-named.sha256sum] = "6a5284425a5cb10ee0c2368614ba9a1d5194263c72cbf465f39f63258afa3319"

URI_x86_64_v2_pcp-pmda-netcheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-netcheck-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-netcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-netcheck}"
SRC_URI[x86_64_v2_pcp-pmda-netcheck.sha256sum] = "6182d4de8801c697f811853cc427a5560bbd8d5b31b56be8452fa14f71e7b424"

URI_x86_64_v2_pcp-pmda-netfilter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-netfilter-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-netfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-netfilter}"
SRC_URI[x86_64_v2_pcp-pmda-netfilter.sha256sum] = "121f0b5ee80f80d6ec89ef307bdada3929ce479f9e6157d5363a0a373a1253de"

URI_x86_64_v2_pcp-pmda-news = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-news-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-news;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-news}"
SRC_URI[x86_64_v2_pcp-pmda-news.sha256sum] = "82c5b9f9097c0b5386d261c430ed1ee460527891bee69111e0a302dd61bc5773"

URI_x86_64_v2_pcp-pmda-nfsclient = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nfsclient-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nfsclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-nfsclient}"
SRC_URI[x86_64_v2_pcp-pmda-nfsclient.sha256sum] = "2f8f244e52574acf0a2ba595e92a28a8dfb58fa261f6bf94ce7e2f3d1aec72ea"

URI_x86_64_v2_pcp-pmda-nginx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nginx-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-nginx}"
SRC_URI[x86_64_v2_pcp-pmda-nginx.sha256sum] = "36838fe0157d981f75b0310aa6f8aeac1374bfcb0232106045750a081d269c78"

URI_x86_64_v2_pcp-pmda-nvidia-gpu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nvidia-gpu-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nvidia-gpu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-nvidia-gpu}"
SRC_URI[x86_64_v2_pcp-pmda-nvidia-gpu.sha256sum] = "27e1987e8a2c84379956f182a4bffe9dbee6adc8e49155029c783ea1b2698893"

URI_x86_64_v2_pcp-pmda-openmetrics = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-openmetrics-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-openmetrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-openmetrics}"
SRC_URI[x86_64_v2_pcp-pmda-openmetrics.sha256sum] = "373ebeda3f2f74a223410d55d7bb1faf082de87192e334fb3c50dd688943d714"

URI_x86_64_v2_pcp-pmda-opentelemetry = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-opentelemetry-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-opentelemetry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-opentelemetry}"
SRC_URI[x86_64_v2_pcp-pmda-opentelemetry.sha256sum] = "09bba7e5b41c6fbcae66f3ac7120a44755aaaa9ce50a72d4ed55c4d9411e1dac"

URI_x86_64_v2_pcp-pmda-openvswitch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-openvswitch-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-openvswitch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-openvswitch}"
SRC_URI[x86_64_v2_pcp-pmda-openvswitch.sha256sum] = "d359ed158982720fae6f41cc85f620c59761b67bcd6a80fdbc33a484bd7c8ed7"

URI_x86_64_v2_pcp-pmda-oracle = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-oracle-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-oracle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-oracle}"
SRC_URI[x86_64_v2_pcp-pmda-oracle.sha256sum] = "880adf4cfef0b015243c0fe1f5b57ec5dec5bb319947a32c129b475882573eb5"

URI_x86_64_v2_pcp-pmda-pdns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-pdns-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-pdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-pdns}"
SRC_URI[x86_64_v2_pcp-pmda-pdns.sha256sum] = "0ffc1ccc8f6960e7fb7bf1f2b5f2b100810964dacac92a62e7455f968ac180e1"

URI_x86_64_v2_pcp-pmda-perfevent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-perfevent-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-perfevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-perfevent}"
SRC_URI[x86_64_v2_pcp-pmda-perfevent.sha256sum] = "3654a3e9d57d7b8e81fb1ce8c0fda3eea6da03760b98bc3c132c4747e571bfe5"

URI_x86_64_v2_pcp-pmda-podman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-podman-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-podman}"
SRC_URI[x86_64_v2_pcp-pmda-podman.sha256sum] = "1ca436c94471d3ddbd8c075f92f73e7f8cea28ea3e2d75c0c4c047b34b1577a7"

URI_x86_64_v2_pcp-pmda-postfix = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-postfix-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-postfix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-postfix}"
SRC_URI[x86_64_v2_pcp-pmda-postfix.sha256sum] = "a304fe93cb5e9144fcc2d550b93e67e772d47ab215974f3ab4937428fd51e776"

URI_x86_64_v2_pcp-pmda-postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-postgresql-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-postgresql}"
SRC_URI[x86_64_v2_pcp-pmda-postgresql.sha256sum] = "f49e7922c19d97e372e3d2f16a3f4e799c78c868ee556100c4cd1e0beed6663b"

URI_x86_64_v2_pcp-pmda-rabbitmq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-rabbitmq-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-rabbitmq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-rabbitmq}"
SRC_URI[x86_64_v2_pcp-pmda-rabbitmq.sha256sum] = "fe9737044af32ed0db8d9783cf4c088c6ff4ad1800eacd3dae6847fce652c351"

URI_x86_64_v2_pcp-pmda-redis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-redis-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-redis}"
SRC_URI[x86_64_v2_pcp-pmda-redis.sha256sum] = "23b4d533c370e8e9ab2c891d32f7fa4fbd8b16cc6fb1ba0b890262868298164b"

URI_x86_64_v2_pcp-pmda-resctrl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-resctrl-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-resctrl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-resctrl}"
SRC_URI[x86_64_v2_pcp-pmda-resctrl.sha256sum] = "7c31c893d2997688649cdaef3ab1c53be6e9a1692405b5b21ad4f12e754733bf"

URI_x86_64_v2_pcp-pmda-rocestat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-rocestat-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-rocestat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-rocestat}"
SRC_URI[x86_64_v2_pcp-pmda-rocestat.sha256sum] = "dc6700fad6d31b18f7dd6c3b56359929a8bdaffe252448337be308f70afffff8"

URI_x86_64_v2_pcp-pmda-roomtemp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-roomtemp-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-roomtemp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-roomtemp}"
SRC_URI[x86_64_v2_pcp-pmda-roomtemp.sha256sum] = "837220193c551105806cc79a22a548886c26aea4ab72c7a76026b2d5fb9f27c8"

URI_x86_64_v2_pcp-pmda-rsyslog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-rsyslog-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-rsyslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-rsyslog}"
SRC_URI[x86_64_v2_pcp-pmda-rsyslog.sha256sum] = "df54c14315eac0c0af3cd6561e29a852a8dad37774cf98a01465cce83d61af95"

URI_x86_64_v2_pcp-pmda-samba = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-samba-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-samba}"
SRC_URI[x86_64_v2_pcp-pmda-samba.sha256sum] = "9e412d816dad9b19e03364ca9551a4f9b307cd28b0eced7e73cc33074e750ddd"

URI_x86_64_v2_pcp-pmda-sendmail = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-sendmail-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-sendmail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-sendmail}"
SRC_URI[x86_64_v2_pcp-pmda-sendmail.sha256sum] = "22dcc09790a81deb164efca38e3138344f85fc7b852ad52ce0732e96c90aea58"

URI_x86_64_v2_pcp-pmda-shping = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-shping-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-shping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-shping}"
SRC_URI[x86_64_v2_pcp-pmda-shping.sha256sum] = "5cc264933c5ad46f0f29d075916557d6d0a9eff76e6ba9b636eb6bbd73e745b3"

URI_x86_64_v2_pcp-pmda-slurm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-slurm-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-slurm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-slurm}"
SRC_URI[x86_64_v2_pcp-pmda-slurm.sha256sum] = "6827f517ec6331f4a81647ac38c4fcf980ae44a04b33aa47fcfbddfce273783d"

URI_x86_64_v2_pcp-pmda-smart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-smart-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-smart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-smart}"
SRC_URI[x86_64_v2_pcp-pmda-smart.sha256sum] = "580dc024a6cffbc6d3acd56bd485cd8b8d7575b550d4fb47e9076d4d59bb67b5"

URI_x86_64_v2_pcp-pmda-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-snmp-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-snmp}"
SRC_URI[x86_64_v2_pcp-pmda-snmp.sha256sum] = "f4112a791e120b6d62cc4d36d86758c51ffd7c0a8a764b0d67927ca006d7d059"

URI_x86_64_v2_pcp-pmda-sockets = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-sockets-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-sockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-sockets}"
SRC_URI[x86_64_v2_pcp-pmda-sockets.sha256sum] = "59c5dbc0b00a7ca04f98c309fef39b5cf60b53d20285ff65a74543f5df3cf412"

URI_x86_64_v2_pcp-pmda-statsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-statsd-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-statsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-statsd}"
SRC_URI[x86_64_v2_pcp-pmda-statsd.sha256sum] = "3edd3c88ce3829fe20693eb0c1c7706b25d609cef2cfebd8db40b49189154089"

URI_x86_64_v2_pcp-pmda-summary = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-summary-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-summary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-summary}"
SRC_URI[x86_64_v2_pcp-pmda-summary.sha256sum] = "730ac9d13135b230d424b1d2fb5e61d5205bfd870e8c0982ecdf41511e972b49"

URI_x86_64_v2_pcp-pmda-systemd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-systemd-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-systemd}"
SRC_URI[x86_64_v2_pcp-pmda-systemd.sha256sum] = "236ab82543995affac36a52ae204551829b8d55ccf4bb1debb38c507e67bcd6d"

URI_x86_64_v2_pcp-pmda-trace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-trace-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-trace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-trace}"
SRC_URI[x86_64_v2_pcp-pmda-trace.sha256sum] = "1d458fd2fbffa85038ef8415856a9457806618c9c26e84aed70a537c08df9fab"

URI_x86_64_v2_pcp-pmda-unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-unbound-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-unbound}"
SRC_URI[x86_64_v2_pcp-pmda-unbound.sha256sum] = "a0482304647021621d271a2d75c793a84b8286602544bb15622f25acf0373c5a"

URI_x86_64_v2_pcp-pmda-uwsgi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-uwsgi-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-uwsgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-uwsgi}"
SRC_URI[x86_64_v2_pcp-pmda-uwsgi.sha256sum] = "6e8001c38eeb653d8b89face64ac52e323c285715c45be72562ae17bd4eccac7"

URI_x86_64_v2_pcp-pmda-weblog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-weblog-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-weblog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-weblog}"
SRC_URI[x86_64_v2_pcp-pmda-weblog.sha256sum] = "f62e334264ae3c068d7f9d7b741e2fc6948efc62f1dd9311ecf5876d679934da"

URI_x86_64_v2_pcp-pmda-zimbra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-zimbra-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-zimbra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-zimbra}"
SRC_URI[x86_64_v2_pcp-pmda-zimbra.sha256sum] = "1d42c964d2ea9c95c4d0f63e75a6be64f00991e3f67c68e2985eda1fa2cf98f1"

URI_x86_64_v2_pcp-pmda-zswap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-zswap-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-zswap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-zswap}"
SRC_URI[x86_64_v2_pcp-pmda-zswap.sha256sum] = "fac74d59832e6ea125371cb27273387828eae3b8109731f2dc7987f8ce82a3b0"

URI_x86_64_v2_pcp-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-selinux-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-selinux}"
SRC_URI[x86_64_v2_pcp-selinux.sha256sum] = "9fc3fe9b1a14e5487d65c827a3d98f079b9248e63b9f94dee52ac36aeee7a6a1"

URI_x86_64_v2_pcp-system-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-system-tools-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-system-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-system-tools}"
SRC_URI[x86_64_v2_pcp-system-tools.sha256sum] = "46e35b6b0a1d80afa3923fa289bcdc820dc34e80373acaef9a3fd73c9bf89150"

URI_x86_64_v2_pcp-testsuite = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/pcp-testsuite-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-testsuite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-testsuite}"
SRC_URI[x86_64_v2_pcp-testsuite.sha256sum] = "84843c67c6ca861b5c84e9b3bfeb17d547ec512a87c008222c37893b36851cd6"

URI_x86_64_v2_pcp-zeroconf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-zeroconf-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_pcp-zeroconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-zeroconf}"
SRC_URI[x86_64_v2_pcp-zeroconf.sha256sum] = "a8faa22eb019df7d20298d5d4254c349847f39acf4d755062c7f605bb010ca83"

URI_x86_64_v2_perl-PCP-LogImport = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-LogImport-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-LogImport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-LogImport}"
SRC_URI[x86_64_v2_perl-PCP-LogImport.sha256sum] = "9a045d9cec93e03ce1dc20123f4dfff89570d6fac172a8ed9104b13654e27a59"

URI_x86_64_v2_perl-PCP-LogSummary = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-LogSummary-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-LogSummary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-LogSummary}"
SRC_URI[x86_64_v2_perl-PCP-LogSummary.sha256sum] = "36354f6a2f8e9ba6a41179bb4b8537d7c53ca8e6db818ee095dda191e1271178"

URI_x86_64_v2_perl-PCP-MMV = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-MMV-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-MMV;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-MMV}"
SRC_URI[x86_64_v2_perl-PCP-MMV.sha256sum] = "8f2b38284dfefd21602ad0a5f6ee828a6af3e9662fcbd6ece3e1ac17cef9ab11"

URI_x86_64_v2_perl-PCP-PMDA = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-PMDA-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-PMDA;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-PMDA}"
SRC_URI[x86_64_v2_perl-PCP-PMDA.sha256sum] = "d3eb4d51f4e6c826a39484eed276da687acb9fdc0b0f4261b35daff9e9df3e12"

URI_x86_64_v2_python3-pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pcp-7.0.3-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pcp}"
SRC_URI[x86_64_v2_python3-pcp.sha256sum] = "61bf5cb44ee6272130dc8c28bf305cbfae7d171130978e7340afb4bc96231270"

URI_aarch64_pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp}"
SRC_URI[aarch64_pcp.sha256sum] = "a74a4439dddd89190c0d3e0cac55328bce1bc745eb2df86fde95fdc0fddd0454"

URI_aarch64_pcp-conf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-conf-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-conf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-conf}"
SRC_URI[aarch64_pcp-conf.sha256sum] = "8dba20a6981bdc5a30cabfac80a343ed8ecfe09a9e3e2f799483117fa75131b3"

URI_aarch64_pcp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-devel-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-devel}"
SRC_URI[aarch64_pcp-devel.sha256sum] = "f95e439a7a256e5ced348930f9bf982a9173eee65e9acc875fc241afc44c9d40"

URI_aarch64_pcp-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-doc-7.0.3-5.el10_2.noarch.rpm;name=aarch64_pcp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-doc}"
SRC_URI[aarch64_pcp-doc.sha256sum] = "94a7dc3f75afab71ce735dd038541108a4e6b18e03790db4d1e46bbc272ecb1d"

URI_aarch64_pcp-export-pcp2elasticsearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2elasticsearch-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-export-pcp2elasticsearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2elasticsearch}"
SRC_URI[aarch64_pcp-export-pcp2elasticsearch.sha256sum] = "5c4a9041e0ca3b06e2a1b1d528176e5325ddec5f8ef38ed4c89dd6abed6a18b9"

URI_aarch64_pcp-export-pcp2graphite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2graphite-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-export-pcp2graphite;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2graphite}"
SRC_URI[aarch64_pcp-export-pcp2graphite.sha256sum] = "c5a3d6762bfa062aa80058ea98e3832004edf5bfac9968fd3869cfb7099e9edb"

URI_aarch64_pcp-export-pcp2influxdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2influxdb-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-export-pcp2influxdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2influxdb}"
SRC_URI[aarch64_pcp-export-pcp2influxdb.sha256sum] = "09fbedb83b9129d312dad32b44ee148ae92db17824c019979d8861700de8f595"

URI_aarch64_pcp-export-pcp2json = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2json-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-export-pcp2json;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2json}"
SRC_URI[aarch64_pcp-export-pcp2json.sha256sum] = "54e42c89a013477332a9da7f6b68bf88cf5d19dc1b7cde26b020a0031cbe65be"

URI_aarch64_pcp-export-pcp2openmetrics = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2openmetrics-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-export-pcp2openmetrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2openmetrics}"
SRC_URI[aarch64_pcp-export-pcp2openmetrics.sha256sum] = "74941b7f202e79daa073d8e238f3ca8bf8d947e5b21e9f4922ce4f2fa48e97d1"

URI_aarch64_pcp-export-pcp2opentelemetry = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2opentelemetry-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-export-pcp2opentelemetry;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2opentelemetry}"
SRC_URI[aarch64_pcp-export-pcp2opentelemetry.sha256sum] = "3580c0a57a8f70b90ad8a703c05ed9b4d5f29282731ccc8fcd4f9dc4defd0014"

URI_aarch64_pcp-export-pcp2spark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2spark-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-export-pcp2spark;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2spark}"
SRC_URI[aarch64_pcp-export-pcp2spark.sha256sum] = "21861d46fddb461d2908df86ba031d00403a8ee7a4fb0f9c5d64159af8350fd1"

URI_aarch64_pcp-export-pcp2xml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2xml-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-export-pcp2xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2xml}"
SRC_URI[aarch64_pcp-export-pcp2xml.sha256sum] = "61d2f82a284b93cd613c070b41b347d0c8a598af6f160b11ac45e6bfc387f65d"

URI_aarch64_pcp-export-pcp2zabbix = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2zabbix-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-export-pcp2zabbix;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2zabbix}"
SRC_URI[aarch64_pcp-export-pcp2zabbix.sha256sum] = "f63f57c70b999a68075311fa8486f0c2cc3877583132f5684f05c4110b5bcb7e"

URI_aarch64_pcp-export-zabbix-agent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-zabbix-agent-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-export-zabbix-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-zabbix-agent}"
SRC_URI[aarch64_pcp-export-zabbix-agent.sha256sum] = "ea5f5b3a593a599df4ea71248513b794894b79440c5b5375c55fd973302b04db"

URI_aarch64_pcp-geolocate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-geolocate-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-geolocate;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-geolocate}"
SRC_URI[aarch64_pcp-geolocate.sha256sum] = "c08d8545d93662532a4b34876dcc42597ae31c64382ef14fa6aa5f41aca63952"

URI_aarch64_pcp-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-gui-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-gui}"
SRC_URI[aarch64_pcp-gui.sha256sum] = "6d0c866562ff8d2fc105b82e50e786d6233e2b858b2f03e24f57c4ec262c3782"

URI_aarch64_pcp-import-benchmarks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-benchmarks-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-import-benchmarks;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-benchmarks}"
SRC_URI[aarch64_pcp-import-benchmarks.sha256sum] = "af365bd7abbccbebbbdf66798c1d0474ed61e6d1f4c7c6cb91565e831e73148e"

URI_aarch64_pcp-import-collectl2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-collectl2pcp-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-import-collectl2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-collectl2pcp}"
SRC_URI[aarch64_pcp-import-collectl2pcp.sha256sum] = "82defb8b2cab7ae03db4e5a6549c5ed8b6546a5366d1640c56e9bd4daeeca39f"

URI_aarch64_pcp-import-ganglia2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-ganglia2pcp-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-import-ganglia2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-ganglia2pcp}"
SRC_URI[aarch64_pcp-import-ganglia2pcp.sha256sum] = "9799b460e3f36c03ab450bf9db7ddb0b019b83386266a402cb8efff8e7876d78"

URI_aarch64_pcp-import-iostat2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-iostat2pcp-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-import-iostat2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-iostat2pcp}"
SRC_URI[aarch64_pcp-import-iostat2pcp.sha256sum] = "9fd427e5b4156c1550fb6755f05f03ccea920289dec400a703fff408eb472934"

URI_aarch64_pcp-import-mrtg2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-mrtg2pcp-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-import-mrtg2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-mrtg2pcp}"
SRC_URI[aarch64_pcp-import-mrtg2pcp.sha256sum] = "297ddec6aa96055bdcd80728daf0eecb728b7b221bc8fd856e45108fb27fc818"

URI_aarch64_pcp-import-pmseries = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-pmseries-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-import-pmseries;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-pmseries}"
SRC_URI[aarch64_pcp-import-pmseries.sha256sum] = "4523fb16ee5529a461db6636eaae9ed8d8e13a029a8d0146dcd134d2d4c24684"

URI_aarch64_pcp-import-sar2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-sar2pcp-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-import-sar2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-sar2pcp}"
SRC_URI[aarch64_pcp-import-sar2pcp.sha256sum] = "1d2d553f3cc6ad4673112d5505174c3167f4832cfb1e2b1a868883f244dd2986"

URI_aarch64_pcp-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-libs-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-libs}"
SRC_URI[aarch64_pcp-libs.sha256sum] = "e3b3c270d1087161c669392ead74cbac622c646d82448a64d2d694bf0c329a36"

URI_aarch64_pcp-libs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-libs-devel-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-libs-devel}"
SRC_URI[aarch64_pcp-libs-devel.sha256sum] = "67a071656f8723b63da4ca2a649785a2b083160c404663e30542e970cc213653"

URI_aarch64_pcp-pmda-activemq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-activemq-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-activemq;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-activemq}"
SRC_URI[aarch64_pcp-pmda-activemq.sha256sum] = "ee0863146f7c0b4cf9cecddeb5e9702f75c4b507552d48d9fc68890cc907e875"

URI_aarch64_pcp-pmda-amdgpu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-amdgpu-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-amdgpu;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-amdgpu}"
SRC_URI[aarch64_pcp-pmda-amdgpu.sha256sum] = "be4a015b9d9ca2dd471bca36269dc3f8ff20d868686f10a34eae2c765f5f49cc"

URI_aarch64_pcp-pmda-apache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-apache-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-apache;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-apache}"
SRC_URI[aarch64_pcp-pmda-apache.sha256sum] = "2fcebb91fc22f7d735af1453895826cac3fc0a5960ca68ccc2de8c43a642bca1"

URI_aarch64_pcp-pmda-bash = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bash-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-bash;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bash}"
SRC_URI[aarch64_pcp-pmda-bash.sha256sum] = "9246a6d837a3361a2c83f9f06b5f9c5aab722603c74417c64cf66d66c7b0872b"

URI_aarch64_pcp-pmda-bcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bcc-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-bcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bcc}"
SRC_URI[aarch64_pcp-pmda-bcc.sha256sum] = "4af82c3d268dd31068afeb19f85c53e5ad3028f5f0f5df3313adff472cbc4fa5"

URI_aarch64_pcp-pmda-bind2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bind2-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-bind2;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bind2}"
SRC_URI[aarch64_pcp-pmda-bind2.sha256sum] = "c286ac8e5df2ff16a2223f6faf864b5753e6bb736f173300f568fa22d915a514"

URI_aarch64_pcp-pmda-bonding = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bonding-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-bonding;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bonding}"
SRC_URI[aarch64_pcp-pmda-bonding.sha256sum] = "995b877a0fd63ba50e1ae134b80c0e55c753bc5e05b6f5ecbed241ec57e7ed70"

URI_aarch64_pcp-pmda-bpf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bpf-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-bpf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bpf}"
SRC_URI[aarch64_pcp-pmda-bpf.sha256sum] = "52929de227a9d444d4cc5e8a5fd51c751cefc6a2240692310de94b0ad6274f79"

URI_aarch64_pcp-pmda-bpftrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bpftrace-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-bpftrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bpftrace}"
SRC_URI[aarch64_pcp-pmda-bpftrace.sha256sum] = "deeae0dd715f6fafb6a9c6a8d4dd98d39bfbbbe63f59f21a27d30b3226b5c069"

URI_aarch64_pcp-pmda-cifs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-cifs-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-cifs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-cifs}"
SRC_URI[aarch64_pcp-pmda-cifs.sha256sum] = "ee9868965f548de267559d802c3ab210f08bb39dd56101df42c09bbd667853ed"

URI_aarch64_pcp-pmda-cisco = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-cisco-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-cisco;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-cisco}"
SRC_URI[aarch64_pcp-pmda-cisco.sha256sum] = "5a83c8815bbb7939cb927bce967a7a1ab1e84ff08780c99c967b56fe87bf4479"

URI_aarch64_pcp-pmda-dbping = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-dbping-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-dbping;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-dbping}"
SRC_URI[aarch64_pcp-pmda-dbping.sha256sum] = "56255aee45aa8f82809216247a9104cdbffe574a3b361820478a7ee4ccee898c"

URI_aarch64_pcp-pmda-denki = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-denki-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-denki;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-denki}"
SRC_URI[aarch64_pcp-pmda-denki.sha256sum] = "4dada052e57735aad8436185588eeab588d4ace9e2ed0fbafd6c339feda6be8d"

URI_aarch64_pcp-pmda-dm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-dm-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-dm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-dm}"
SRC_URI[aarch64_pcp-pmda-dm.sha256sum] = "bec5ee42f9f47e1e6b0bef653de753430cee461b6547fe22d7082b8fdc38d1ed"

URI_aarch64_pcp-pmda-docker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-docker-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-docker;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-docker}"
SRC_URI[aarch64_pcp-pmda-docker.sha256sum] = "3b2e3d3bef969d34fba9edb92db8f82d96a5c6445ac4d1004f3f74b49faba865"

URI_aarch64_pcp-pmda-ds389 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-ds389-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-ds389;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-ds389}"
SRC_URI[aarch64_pcp-pmda-ds389.sha256sum] = "c40c68906f5e467f9f504ee004de877a021dcab808e4c40fa48240c52ee951a0"

URI_aarch64_pcp-pmda-ds389log = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-ds389log-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-ds389log;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-ds389log}"
SRC_URI[aarch64_pcp-pmda-ds389log.sha256sum] = "038b101d5067a6a5f60dce2ba61774e1cb694d7cdbe27a98d89b92f7741cf4f9"

URI_aarch64_pcp-pmda-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-elasticsearch-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-elasticsearch}"
SRC_URI[aarch64_pcp-pmda-elasticsearch.sha256sum] = "5f60c00aede4b65eed981533b6df99644f56a351a6c68d0cfe2271eda09873e1"

URI_aarch64_pcp-pmda-farm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-farm-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-farm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-farm}"
SRC_URI[aarch64_pcp-pmda-farm.sha256sum] = "83eae49181c4d62933b343b35dc8fe1cbbcf67a4c094a4e098ad9c9db3fce245"

URI_aarch64_pcp-pmda-gluster = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gluster-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-gluster;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-gluster}"
SRC_URI[aarch64_pcp-pmda-gluster.sha256sum] = "8e11c4f6a9cdecda1a02c7e9a13dbade68cd58a9be4675b9690929133eafe2e2"

URI_aarch64_pcp-pmda-gpfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gpfs-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-gpfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-gpfs}"
SRC_URI[aarch64_pcp-pmda-gpfs.sha256sum] = "2f7a7ed31d1b80d2d4b7530deb5574507b94719fb02bca7c7432d80da2cf976a"

URI_aarch64_pcp-pmda-gpsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gpsd-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-gpsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-gpsd}"
SRC_URI[aarch64_pcp-pmda-gpsd.sha256sum] = "04ed57e13d7e95389783c7932a837905c7702fc07959377b7e0da6561e7ebeb6"

URI_aarch64_pcp-pmda-hacluster = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-hacluster-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-hacluster;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-hacluster}"
SRC_URI[aarch64_pcp-pmda-hacluster.sha256sum] = "51fabb51011b9b8507d14e11b3c55ae4f47492c2c51c76905689474cc56718d4"

URI_aarch64_pcp-pmda-haproxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-haproxy-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-haproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-haproxy}"
SRC_URI[aarch64_pcp-pmda-haproxy.sha256sum] = "7dc1eb2451f39bfe2141cc273740fe611098d9fc6c8e8279bc0406fec2902533"

URI_aarch64_pcp-pmda-hdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-hdb-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-hdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-hdb}"
SRC_URI[aarch64_pcp-pmda-hdb.sha256sum] = "80338f5d45222cdccd86e342e25a66c5c00f37f702362007e15a16650c6e4757"

URI_aarch64_pcp-pmda-infiniband = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-infiniband-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-infiniband;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-infiniband}"
SRC_URI[aarch64_pcp-pmda-infiniband.sha256sum] = "fc471078e6d448cba2241be396776f4932851487ee29da1123e15aae8684db39"

URI_aarch64_pcp-pmda-libvirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-libvirt-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-libvirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-libvirt}"
SRC_URI[aarch64_pcp-pmda-libvirt.sha256sum] = "9a4157c8c0c14d2ba0100023b02a91cb2b59e7f6f6ba57324e904a80ccaf5591"

URI_aarch64_pcp-pmda-lio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lio-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-lio;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lio}"
SRC_URI[aarch64_pcp-pmda-lio.sha256sum] = "a8a3d89c85a7dce0a8b8fcaa02b5ba932bca555e2017a352c2e3bcb045fc4830"

URI_aarch64_pcp-pmda-lmsensors = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lmsensors-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-lmsensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lmsensors}"
SRC_URI[aarch64_pcp-pmda-lmsensors.sha256sum] = "a9b0f88f4f529938c98df306390aa2a49b83579c8997c55a5b6dcd5230c76a9d"

URI_aarch64_pcp-pmda-logger = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-logger-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-logger;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-logger}"
SRC_URI[aarch64_pcp-pmda-logger.sha256sum] = "8129483b9d43735e39fd6249f6eaf6a50a595a2dcf4284c0cadc6a278232bee6"

URI_aarch64_pcp-pmda-lustre = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lustre-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-lustre;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lustre}"
SRC_URI[aarch64_pcp-pmda-lustre.sha256sum] = "55f24074c8c5bc4ba80193819930558008105886a9a034890f54e76c9929fc95"

URI_aarch64_pcp-pmda-lustrecomm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lustrecomm-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-lustrecomm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lustrecomm}"
SRC_URI[aarch64_pcp-pmda-lustrecomm.sha256sum] = "8547fe73a9f9906e6d23bcd6459117bd9cc35aca9a096f0be9f806b0c3e00cf5"

URI_aarch64_pcp-pmda-mailq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mailq-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-mailq;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mailq}"
SRC_URI[aarch64_pcp-pmda-mailq.sha256sum] = "37ea1512d44201935c530605ded89613354ff4bf226871351c9513930e871f4f"

URI_aarch64_pcp-pmda-memcache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-memcache-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-memcache;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-memcache}"
SRC_URI[aarch64_pcp-pmda-memcache.sha256sum] = "3c9902df8479009c51d1d4fc9e80cee1ec3503971459aa7a061a5f50ff7ee391"

URI_aarch64_pcp-pmda-mic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mic-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-mic;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mic}"
SRC_URI[aarch64_pcp-pmda-mic.sha256sum] = "4fc22cf766e8228bb19c007cc0944f86d71eafecfde2be8d0b27221f309db4ab"

URI_aarch64_pcp-pmda-mongodb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mongodb-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-mongodb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mongodb}"
SRC_URI[aarch64_pcp-pmda-mongodb.sha256sum] = "e0e04351eb4434c4b517b24fc9b8a62a3995f4e8dd7665eaa009b71ada6f576f"

URI_aarch64_pcp-pmda-mounts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mounts-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-mounts;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mounts}"
SRC_URI[aarch64_pcp-pmda-mounts.sha256sum] = "a33c5bfd22b5516c408c80d4d451bc2075a9fd5d88c78ba2d92ba62eba54a027"

URI_aarch64_pcp-pmda-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mysql-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mysql}"
SRC_URI[aarch64_pcp-pmda-mysql.sha256sum] = "55d30a96be908c32112234f2879fbbaf088e64b0195e63955a43aaf82e4af265"

URI_aarch64_pcp-pmda-named = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-named-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-named;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-named}"
SRC_URI[aarch64_pcp-pmda-named.sha256sum] = "2e45935140b83bb5884ed7c67ab0c82a95aa8aa36fe93ebe3c9b02e948eec609"

URI_aarch64_pcp-pmda-netcheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-netcheck-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-netcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-netcheck}"
SRC_URI[aarch64_pcp-pmda-netcheck.sha256sum] = "b3ef03890c333628ed92038b09eb26c1d2bd6d86e86f07828641fca323b21291"

URI_aarch64_pcp-pmda-netfilter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-netfilter-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-netfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-netfilter}"
SRC_URI[aarch64_pcp-pmda-netfilter.sha256sum] = "d939f6a89d0bf03e6e042eac5025337ef185463ecd908279a679d462ea566cbe"

URI_aarch64_pcp-pmda-news = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-news-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-news;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-news}"
SRC_URI[aarch64_pcp-pmda-news.sha256sum] = "12510fce34784ef206e484bc9124f72b5e1626257e552d2182ab34d6830764ae"

URI_aarch64_pcp-pmda-nfsclient = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nfsclient-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-nfsclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-nfsclient}"
SRC_URI[aarch64_pcp-pmda-nfsclient.sha256sum] = "0a0a496084a774142afd97a83f31efd858cbdba3588dd220af877f3303e1150b"

URI_aarch64_pcp-pmda-nginx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nginx-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-nginx}"
SRC_URI[aarch64_pcp-pmda-nginx.sha256sum] = "39b54117b2564b8829f3eb5f1f813455d2d7dff86cc13c05feef092e6ea174bd"

URI_aarch64_pcp-pmda-nvidia-gpu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nvidia-gpu-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-nvidia-gpu;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-nvidia-gpu}"
SRC_URI[aarch64_pcp-pmda-nvidia-gpu.sha256sum] = "76236c4b1d63ac415e678c988a6cd31dcb6c184b16ebbcf3978b6d34e1079c85"

URI_aarch64_pcp-pmda-openmetrics = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-openmetrics-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-openmetrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-openmetrics}"
SRC_URI[aarch64_pcp-pmda-openmetrics.sha256sum] = "1e8aefabcc469bf2a57327de3b1e7b5318ff8038cc6490820a2626571063d45b"

URI_aarch64_pcp-pmda-opentelemetry = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-opentelemetry-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-opentelemetry;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-opentelemetry}"
SRC_URI[aarch64_pcp-pmda-opentelemetry.sha256sum] = "d8b0b5d1e28d6cc92f6c1694ae622788db9969ff22320de4cd341f78c67df3c9"

URI_aarch64_pcp-pmda-openvswitch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-openvswitch-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-openvswitch;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-openvswitch}"
SRC_URI[aarch64_pcp-pmda-openvswitch.sha256sum] = "fbf66db66e4762ead69be14e7885ca8ea6e26c92b9b70337fef8170dbdc634e1"

URI_aarch64_pcp-pmda-oracle = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-oracle-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-oracle;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-oracle}"
SRC_URI[aarch64_pcp-pmda-oracle.sha256sum] = "31bfc1c987235279f7e09edd40d570d0cb5f267109ed6dbafe3808a901356712"

URI_aarch64_pcp-pmda-pdns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-pdns-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-pdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-pdns}"
SRC_URI[aarch64_pcp-pmda-pdns.sha256sum] = "56e36b2b03b9f70865419f6335e3dc05a2d2488f15f2072a3e8ec7404194ff9b"

URI_aarch64_pcp-pmda-perfevent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-perfevent-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-perfevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-perfevent}"
SRC_URI[aarch64_pcp-pmda-perfevent.sha256sum] = "5ec27f13d128f2a1958850361e02d62ab4469a2855acfcf672b5f607840c2c65"

URI_aarch64_pcp-pmda-podman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-podman-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-podman}"
SRC_URI[aarch64_pcp-pmda-podman.sha256sum] = "bb309850d2d3fa8588d36462d100ab4e4a925efa7ae728b77e4137f7cf6d5b43"

URI_aarch64_pcp-pmda-postfix = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-postfix-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-postfix;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-postfix}"
SRC_URI[aarch64_pcp-pmda-postfix.sha256sum] = "f3890e879fd321d2ca76a4a5824bcd27b60aeaebad4b60efcdcee11435ce0907"

URI_aarch64_pcp-pmda-postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-postgresql-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-postgresql}"
SRC_URI[aarch64_pcp-pmda-postgresql.sha256sum] = "dbe358f6b31b8623467130c8289114a9ee4065f57af12bf0f01c4e169bad79a8"

URI_aarch64_pcp-pmda-rabbitmq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-rabbitmq-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-rabbitmq;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-rabbitmq}"
SRC_URI[aarch64_pcp-pmda-rabbitmq.sha256sum] = "1c2c8380652ff4b6dc182412ea610c43d4701d1a123aa3a633f3f001af4fe9de"

URI_aarch64_pcp-pmda-redis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-redis-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-redis}"
SRC_URI[aarch64_pcp-pmda-redis.sha256sum] = "7c31d5887456eaddd052fc845bdad44fd609bde823df7b06b65c19ccafd6adb4"

URI_aarch64_pcp-pmda-rocestat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-rocestat-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-rocestat;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-rocestat}"
SRC_URI[aarch64_pcp-pmda-rocestat.sha256sum] = "61750907ffb40ded7046a3a8db761138809cea81ce4d3d5d3e33c3ea64ec36a1"

URI_aarch64_pcp-pmda-roomtemp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-roomtemp-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-roomtemp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-roomtemp}"
SRC_URI[aarch64_pcp-pmda-roomtemp.sha256sum] = "e6bebb165c5e0e9e724f1cc9a3ec3fffe4d807f8bf3aae17446d34e97cd2d2df"

URI_aarch64_pcp-pmda-rsyslog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-rsyslog-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-rsyslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-rsyslog}"
SRC_URI[aarch64_pcp-pmda-rsyslog.sha256sum] = "f6dd1305d8290a47ce7f19853aa8fe088c776ef79d22ae8a09edffb84e79f56d"

URI_aarch64_pcp-pmda-samba = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-samba-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-samba}"
SRC_URI[aarch64_pcp-pmda-samba.sha256sum] = "db7674916a74c19a6a2d91366084ab237875413821582b94c670ab1816a4b74c"

URI_aarch64_pcp-pmda-sendmail = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-sendmail-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-sendmail;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-sendmail}"
SRC_URI[aarch64_pcp-pmda-sendmail.sha256sum] = "026e569f73232f43f99296ba15b58e6ec64c502a58b07ac60986bdc93b3022ca"

URI_aarch64_pcp-pmda-shping = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-shping-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-shping;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-shping}"
SRC_URI[aarch64_pcp-pmda-shping.sha256sum] = "c5e27e259f03bcc30ebe8e867b5182f2e77e401890dc939b4a82126f7a097a01"

URI_aarch64_pcp-pmda-slurm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-slurm-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-slurm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-slurm}"
SRC_URI[aarch64_pcp-pmda-slurm.sha256sum] = "69867a8a53157b36fb9fb3974c1aa8d4b6ab590c9aa82b02c653518a7d774ab3"

URI_aarch64_pcp-pmda-smart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-smart-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-smart;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-smart}"
SRC_URI[aarch64_pcp-pmda-smart.sha256sum] = "70da74c681d9f9864e8a9ee07b9cd054c378f78e5a35222cef178625c9c48fb1"

URI_aarch64_pcp-pmda-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-snmp-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-snmp}"
SRC_URI[aarch64_pcp-pmda-snmp.sha256sum] = "fe3b16b8c21a857927c9d71d3e498873fd5b4c253914277602a534d5ae4293f2"

URI_aarch64_pcp-pmda-sockets = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-sockets-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-sockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-sockets}"
SRC_URI[aarch64_pcp-pmda-sockets.sha256sum] = "835dc4f0e7ac5f63a37908559e8573077786345d6932dfcc4e6c49e4337b0f6d"

URI_aarch64_pcp-pmda-statsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-statsd-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-statsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-statsd}"
SRC_URI[aarch64_pcp-pmda-statsd.sha256sum] = "194c1c3ef440fac480021c8d5f38fbea97e2d8e0cd1dd3fc2b8dfc23cdece4ec"

URI_aarch64_pcp-pmda-summary = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-summary-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-summary;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-summary}"
SRC_URI[aarch64_pcp-pmda-summary.sha256sum] = "90af599f6e6ea011ad283416e68323ba51e4cb094f58c5a6aef5dc00417a0e07"

URI_aarch64_pcp-pmda-systemd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-systemd-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-systemd}"
SRC_URI[aarch64_pcp-pmda-systemd.sha256sum] = "fab44e20f2b7a8001598b378b8ca34c51c360d0955a92cf7734815fe7f47bfc1"

URI_aarch64_pcp-pmda-trace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-trace-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-trace;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-trace}"
SRC_URI[aarch64_pcp-pmda-trace.sha256sum] = "44ce12ebd3672fee6aa88772da2213e9a5c22a48e5fcf2f4a778f82cb2442580"

URI_aarch64_pcp-pmda-unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-unbound-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-unbound}"
SRC_URI[aarch64_pcp-pmda-unbound.sha256sum] = "2f01d54f1877a396390f227e5c9b1f8d4ffdcea94cffa252aeeb2cf8a6c6e4bd"

URI_aarch64_pcp-pmda-uwsgi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-uwsgi-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-uwsgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-uwsgi}"
SRC_URI[aarch64_pcp-pmda-uwsgi.sha256sum] = "5713f3559adc111c67cb0519bdb21adc5d1b8226a2b738924b92b9cd564fb2d6"

URI_aarch64_pcp-pmda-weblog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-weblog-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-weblog;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-weblog}"
SRC_URI[aarch64_pcp-pmda-weblog.sha256sum] = "518ad0aeb89d50abde2d1b5ea3c7e1b83131e5433ffbc6aa738373846245572a"

URI_aarch64_pcp-pmda-zimbra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-zimbra-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-zimbra;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-zimbra}"
SRC_URI[aarch64_pcp-pmda-zimbra.sha256sum] = "8d2a7d6e3c7bd8728fbb2f3a6ba0300ff3e1424baa234989b918582088af0d7f"

URI_aarch64_pcp-pmda-zswap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-zswap-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-pmda-zswap;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-zswap}"
SRC_URI[aarch64_pcp-pmda-zswap.sha256sum] = "85171695b1b90a04b460f491eb2215dc5c1a03614ad42052be22be0629748de8"

URI_aarch64_pcp-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-selinux-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-selinux}"
SRC_URI[aarch64_pcp-selinux.sha256sum] = "260fe07b0e4a3e5a0143ee316d349eaeb84ba5cbc70eecb45c402830f32e958d"

URI_aarch64_pcp-system-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-system-tools-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-system-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-system-tools}"
SRC_URI[aarch64_pcp-system-tools.sha256sum] = "766952ab888d5ec7152f7228391aaa4b6b9ed09eada58d006472df2764f05cc7"

URI_aarch64_pcp-testsuite = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/pcp-testsuite-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-testsuite;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-testsuite}"
SRC_URI[aarch64_pcp-testsuite.sha256sum] = "ed2c67553a9f6e6dd1703d2796be2700058a774237bff7c87ff9f58afa7cd243"

URI_aarch64_pcp-zeroconf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-zeroconf-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_pcp-zeroconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-zeroconf}"
SRC_URI[aarch64_pcp-zeroconf.sha256sum] = "7d80420fd8c099c13c13d3a14a376ec8bb9978ab1b58c626aa9d7103f0592bc5"

URI_aarch64_perl-PCP-LogImport = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-LogImport-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_perl-PCP-LogImport;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-LogImport}"
SRC_URI[aarch64_perl-PCP-LogImport.sha256sum] = "fbcd4427443a095e90d76ee57700ea62c9ea35202a972f1fb93646f38215208b"

URI_aarch64_perl-PCP-LogSummary = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-LogSummary-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_perl-PCP-LogSummary;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-LogSummary}"
SRC_URI[aarch64_perl-PCP-LogSummary.sha256sum] = "b9179140632962dce705760a9ba2e1f1f8b1d9805b07539f8ecb0a36a65bf4e3"

URI_aarch64_perl-PCP-MMV = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-MMV-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_perl-PCP-MMV;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-MMV}"
SRC_URI[aarch64_perl-PCP-MMV.sha256sum] = "91bb413b2ed7a669239152a83e2d921a4cb3d21ce44327389461b4bfef605bc1"

URI_aarch64_perl-PCP-PMDA = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-PMDA-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_perl-PCP-PMDA;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-PMDA}"
SRC_URI[aarch64_perl-PCP-PMDA.sha256sum] = "91145508253aef4ab464a9d614d332afb9ea956f219f327c76c87ddcb533977d"

URI_aarch64_python3-pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pcp-7.0.3-5.el10_2.aarch64.rpm;name=aarch64_python3-pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pcp}"
SRC_URI[aarch64_python3-pcp.sha256sum] = "76776e5c2ed1fe6f9e5fbc70f9ec551b817457419760b5bc247044dc43f40763"

RDEPENDS:pcp = " \
 bash \
 diffutils \
 findutils \
 gawk \
 glibc \
 grep \
 hostname \
 libuv \
 openssl-libs \
 pcp-libs \
 pcp-selinux \
 pkgconf-pkg-config \
 procps-ng \
 readline \
 sed \
 virtual/coreutils \
 which \
 xz \
 zlib-ng-compat \
 zstd \
 "
RDEPENDS:pcp-conf = " \
 "
RDEPENDS:pcp-devel = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 pcp-libs-devel \
 perl-PCP-PMDA \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:pcp-doc = " \
 "
RDEPENDS:pcp-export-pcp2elasticsearch = " \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-export-pcp2graphite = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2influxdb = " \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-export-pcp2json = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2openmetrics = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2opentelemetry = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2spark = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2xml = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2zabbix = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-zabbix-agent = " \
 glibc \
 pcp-libs \
 "
RDEPENDS:pcp-geolocate = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-gui = " \
 bash \
 glibc \
 liberation-sans-fonts \
 libgcc \
 libstdc++ \
 pcp \
 pcp-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:pcp-import-benchmarks = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-import-collectl2pcp = " \
 glibc \
 pcp-libs \
 "
RDEPENDS:pcp-import-ganglia2pcp = " \
 pcp-libs \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-PCP-LogImport \
 perl-POSIX \
 perl-TimeDate \
 perl-interpreter \
 perl-libs \
 perl-vars \
 rrdtool-perl \
 "
RDEPENDS:pcp-import-iostat2pcp = " \
 pcp-libs \
 perl-Getopt-Std \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-import-mrtg2pcp = " \
 pcp-libs \
 perl-PCP-LogImport \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-import-pmseries = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-import-sar2pcp = " \
 pcp-libs \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-XML-TokeParser \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-libs = " \
 avahi-libs \
 cyrus-sasl-lib \
 glibc \
 libuv \
 openssl-libs \
 pcp-conf \
 systemd-libs \
 xz-libs \
 "
RDEPENDS:pcp-libs-devel = " \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-activemq = " \
 bash \
 pcp \
 pcp-libs \
 perl-Digest-MD5 \
 perl-JSON \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-amdgpu = " \
 bash \
 glibc \
 libdrm \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-apache = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-bash = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-bcc = " \
 bash \
 pcp \
 pcp-libs \
 python3-bcc \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-bind2 = " \
 bash \
 pcp \
 pcp-libs \
 perl-File-Slurp \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-XML-LibXML \
 perl-autodie \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-bonding = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-bpf = " \
 bash \
 elfutils-libelf \
 glibc \
 libbpf \
 pcp \
 pcp-libs \
 zlib-ng-compat \
 "
RDEPENDS:pcp-pmda-bpftrace = " \
 bash \
 bpftrace \
 pcp \
 pcp-libs \
 python3 \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-cifs = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-cisco = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-dbping = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBI \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-denki = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-dm = " \
 bash \
 device-mapper-libs \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-docker = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-ds389 = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-ds389log = " \
 bash \
 pcp \
 pcp-libs \
 perl-Date-Manip \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-elasticsearch = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-farm = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 smartmontools \
 "
RDEPENDS:pcp-pmda-gluster = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-gpfs = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-gpsd = " \
 bash \
 pcp \
 pcp-libs \
 perl-JSON \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 "
RDEPENDS:pcp-pmda-hacluster = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-haproxy = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-hdb = " \
 bash \
 pcp \
 pcp-libs \
 python3-packaging \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-infiniband = " \
 bash \
 glibc \
 infiniband-diags \
 libibumad \
 libibverbs \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-libvirt = " \
 bash \
 pcp \
 pcp-libs \
 python3-libvirt \
 python3-lxml \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-lio = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-rtslib \
 "
RDEPENDS:pcp-pmda-lmsensors = " \
 bash \
 lm_sensors \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-logger = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-lustre = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-lustrecomm = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-mailq = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-memcache = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-mic = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-mongodb = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-mounts = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-mssql = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-pyodbc \
 "
RDEPENDS:pcp-pmda-mysql = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBD-MySQL \
 perl-DBI \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-named = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-netcheck = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-netfilter = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-news = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-nfsclient = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-nginx = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-nvidia-gpu = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-openmetrics = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-pmda-opentelemetry = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-pmda-openvswitch = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-oracle = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBI \
 perl-PCP-PMDA \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-pmda-pdns = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 "
RDEPENDS:pcp-pmda-perfevent = " \
 bash \
 glibc \
 libpfm \
 pcp \
 pcp-libs \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-pmda-podman = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-postfix = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 postfix-perl-scripts \
 "
RDEPENDS:pcp-pmda-postgresql = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-psycopg2 \
 "
RDEPENDS:pcp-pmda-rabbitmq = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-redis = " \
 bash \
 pcp \
 pcp-libs \
 perl-Data-Dumper \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-autodie \
 "
RDEPENDS:pcp-pmda-resctrl = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-rocestat = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-roomtemp = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-rsyslog = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-samba = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-sendmail = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-shping = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-slurm = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-smart = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 smartmontools \
 "
RDEPENDS:pcp-pmda-snmp = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-sockets = " \
 bash \
 glibc \
 iproute \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-statsd = " \
 HdrHistogram_c \
 bash \
 chan \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-summary = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-systemd = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 systemd-libs \
 "
RDEPENDS:pcp-pmda-trace = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-unbound = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-uwsgi = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-weblog = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-zimbra = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-zswap = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-selinux = " \
 bash \
 policycoreutils \
 selinux-policy-targeted \
 "
RDEPENDS:pcp-system-tools = " \
 bash \
 glibc \
 ncurses-libs \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-testsuite = " \
 avahi-libs \
 bash \
 bc \
 bzip2 \
 cyrus-sasl-lib \
 gcc \
 glibc \
 gzip \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcp \
 pcp-devel \
 pcp-libs \
 pcp-libs-devel \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 redhat-rpm-config \
 selinux-policy-devel \
 selinux-policy-targeted \
 setools \
 systemd-libs \
 xz-libs \
 "
RDEPENDS:pcp-zeroconf = " \
 bash \
 pcp \
 pcp-doc \
 pcp-libs \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-dm \
 pcp-pmda-nfsclient \
 pcp-pmda-openmetrics \
 pcp-pmda-opentelemetry \
 pcp-system-tools \
 "
RDEPENDS:perl-PCP-LogImport = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-PCP-LogSummary = " \
 pcp-libs \
 perl-Exporter \
 perl-PCP-LogSummary \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-PCP-MMV = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-PCP-MMV \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-PCP-PMDA = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:python3-pcp = " \
 glibc \
 pcp \
 pcp-libs \
 python3 \
 "
