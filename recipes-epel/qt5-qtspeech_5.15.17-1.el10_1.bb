# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtspeech"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtspeech \
 qt5-qtspeech-devel \
 qt5-qtspeech-examples \
 qt5-qtspeech-speechd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtspeech-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6b6d3c7170bd2f85af86c19a45abb13dc4bfbf77c644a7675c94fd72ed5b727"

URI_x86_64_v2_qt5-qtspeech = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtspeech;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech}"
SRC_URI[x86_64_v2_qt5-qtspeech.sha256sum] = "4d03f4486e9ad7b4c38a0bb23d259cd6570a323636f2f913455c3ddeea2d18c2"

URI_x86_64_v2_qt5-qtspeech-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtspeech-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech-devel}"
SRC_URI[x86_64_v2_qt5-qtspeech-devel.sha256sum] = "ba770d5c412c3bd147a4405af835fe5c672ef1fff18530cf57e0c9830ceccc6c"

URI_x86_64_v2_qt5-qtspeech-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtspeech-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech-examples}"
SRC_URI[x86_64_v2_qt5-qtspeech-examples.sha256sum] = "bc7f059c528ead89d7f4ebb367c52d635287b3e3190b783fe67a8c59f03b1099"

URI_x86_64_v2_qt5-qtspeech-speechd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-speechd-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtspeech-speechd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech-speechd}"
SRC_URI[x86_64_v2_qt5-qtspeech-speechd.sha256sum] = "4dff5e154f45cbdf0f768bccd5666e507698c797d7a678b1002de426b4698085"

URI_aarch64_qt5-qtspeech = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtspeech;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech}"
SRC_URI[aarch64_qt5-qtspeech.sha256sum] = "1eec3083b088e259791a93a9d54070f79c2a16277acad39187771920d2407b60"

URI_aarch64_qt5-qtspeech-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtspeech-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech-devel}"
SRC_URI[aarch64_qt5-qtspeech-devel.sha256sum] = "c68d1b34452ebfc8643f68fcc5a67bbd2a1e85af92a379b81ac228d0a0e8cca0"

URI_aarch64_qt5-qtspeech-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtspeech-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech-examples}"
SRC_URI[aarch64_qt5-qtspeech-examples.sha256sum] = "e3a524acba15e0fdeccf52ebb52ca14c5f0f053ac7a4100d214409d9e7809c3b"

URI_aarch64_qt5-qtspeech-speechd = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-speechd-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtspeech-speechd;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech-speechd}"
SRC_URI[aarch64_qt5-qtspeech-speechd.sha256sum] = "4861e7665e2349794bede75007bd33d0988df7ab1c34927942e4bb2f0c9bef22"

RDEPENDS:qt5-qtspeech = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtspeech-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtspeech \
 "
RDEPENDS:qt5-qtspeech-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtspeech \
 "
RDEPENDS:qt5-qtspeech-speechd = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtspeech \
 speech-dispatcher-libs \
 "
