# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "polkit-kde"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 polkit-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/polkit-kde-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "498590740948b815bc8888555e1d0d188de5b166be561ed4c4f78918c3517d69"

URI_x86_64_v2_polkit-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-kde-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-kde}"
SRC_URI[x86_64_v2_polkit-kde.sha256sum] = "f3abef47aa75c2059f156ad9623f35e0b96f15960b2e2e100872a31cc0e94cd0"
RPROVIDES:polkit-kde:x86_64_v2 = "virtual/PolicyKit-authentication-agent"

URI_aarch64_polkit-kde = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-kde-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_polkit-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-kde}"
SRC_URI[aarch64_polkit-kde.sha256sum] = "77747b041db33c6397ea0d2963eb5da64b4a93be54dd8e7223e86392a7a8ec8f"
RPROVIDES:polkit-kde:aarch64 = "virtual/PolicyKit-authentication-agent"

RDEPENDS:polkit-kde = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwindowsystem \
 libstdc++ \
 polkit \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/PolicyKit-authentication-agent"

PROVIDES:append:aarch64 = " rpm/virtual/PolicyKit-authentication-agent"
