# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktimer"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ktimer \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ktimer-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8b220ea501648247cead9d2d5bbb438443c30a0431e5acfa699eb99078f85493"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktimer-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktimer;unpack=0"
SRC_URI[x86_64_v2_ktimer.sha256sum] = "dbefe29340e1b717455a19e8a7d2ea30a08fa7798680e515deba285a9b17dee9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktimer-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ktimer;unpack=0"
SRC_URI[aarch64_ktimer.sha256sum] = "a87812748e79c1751b87e498a4b22569eb7ae64a3a2232a448f9babf25efd054"

RDEPENDS:ktimer = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
