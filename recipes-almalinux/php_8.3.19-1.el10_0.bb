# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php"
PV = "8.3.19"
PR = "1.el10_0"
PACKAGES = " \
 php \
 php-bcmath \
 php-cli \
 php-common \
 php-dba \
 php-dbg \
 php-devel \
 php-embedded \
 php-enchant \
 php-ffi \
 php-fpm \
 php-gd \
 php-gmp \
 php-intl \
 php-ldap \
 php-mbstring \
 php-mysqlnd \
 php-odbc \
 php-opcache \
 php-pdo \
 php-pgsql \
 php-process \
 php-snmp \
 php-soap \
 php-xml \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php-8.3.19-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68dff872a1f075afb5e0843c490260ae17c0f7dd8c1444a5b9e16fee2fe499df"

URI_x86_64_v2_php = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php}"
SRC_URI[x86_64_v2_php.sha256sum] = "5ce1d74e3a04fd1dd6a4839e4715a0ec5b39587e88ccbd4dadc268fb53fea471"

URI_x86_64_v2_php-bcmath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-bcmath-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-bcmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-bcmath}"
SRC_URI[x86_64_v2_php-bcmath.sha256sum] = "46e5087fd9b8de5868bbcd0e517b6133e5628863f241f7d5d8dd483cbcdfa9dc"

URI_x86_64_v2_php-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-cli-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-cli}"
SRC_URI[x86_64_v2_php-cli.sha256sum] = "dfa129f5f3e11d077abc88e2ee1a5f2f02589cd31aecfbfdf76028cbb06ecd0c"

URI_x86_64_v2_php-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-common-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-common}"
SRC_URI[x86_64_v2_php-common.sha256sum] = "5232359061e2c41309bc7db8ecf50d36e59f260ffbb67e4ed61a07e9a443b220"

URI_x86_64_v2_php-dba = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-dba-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-dba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-dba}"
SRC_URI[x86_64_v2_php-dba.sha256sum] = "e5508cf3d7376c3bb12c04d78d0f51fca99c0d81e2bcd9d828307b561ab0babe"

URI_x86_64_v2_php-dbg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-dbg-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-dbg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-dbg}"
SRC_URI[x86_64_v2_php-dbg.sha256sum] = "8c5218ccba43521431917b4ee7160f9f03c28e1786895a459a245085cba134d5"

URI_x86_64_v2_php-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-devel-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-devel}"
SRC_URI[x86_64_v2_php-devel.sha256sum] = "87f9fa2c9b6547d5576e922ca10a8f358620f60598279e4243b05fa6dff7b80b"

URI_x86_64_v2_php-embedded = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-embedded-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-embedded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-embedded}"
SRC_URI[x86_64_v2_php-embedded.sha256sum] = "2b100cca33ca2a26ff127a400348caaeac04e68bb876af7cde87927d001ca96a"

URI_x86_64_v2_php-enchant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-enchant-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-enchant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-enchant}"
SRC_URI[x86_64_v2_php-enchant.sha256sum] = "c111d8db7626ea6357721f6e7fb52228a3111da535ad6fcbe85f337c8c429c9b"

URI_x86_64_v2_php-ffi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-ffi-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-ffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-ffi}"
SRC_URI[x86_64_v2_php-ffi.sha256sum] = "4cb756fc81e4d7d0374d4c6d1f370255c04a61afad7830e15c7c53ca1f6c56c7"

URI_x86_64_v2_php-fpm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-fpm-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-fpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-fpm}"
SRC_URI[x86_64_v2_php-fpm.sha256sum] = "62e992febaa8c0c8fc30d99569a1ad5ae982ed2225f54fd3bf7e72808f3c21ef"

URI_x86_64_v2_php-gd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-gd-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-gd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-gd}"
SRC_URI[x86_64_v2_php-gd.sha256sum] = "2c299c6021fa62591bd5adfba6bfe0e6bfe26fe8c52fb229973181d19af7196e"

URI_x86_64_v2_php-gmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-gmp-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-gmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-gmp}"
SRC_URI[x86_64_v2_php-gmp.sha256sum] = "99fd0a115903cdf6822e8efb198dc458672592c542f80b7cc329dfecdaae7f56"

URI_x86_64_v2_php-intl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-intl-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-intl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-intl}"
SRC_URI[x86_64_v2_php-intl.sha256sum] = "6688cfe1945adeac40958575c09fb11fbcabc616aa8446f48c4aa0d4711a0d70"

URI_x86_64_v2_php-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-ldap-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-ldap}"
SRC_URI[x86_64_v2_php-ldap.sha256sum] = "e622ec12b6d584f80500d3964e1c3005a462eac442dbcf43c35209d6f899a46d"

URI_x86_64_v2_php-mbstring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-mbstring-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-mbstring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-mbstring}"
SRC_URI[x86_64_v2_php-mbstring.sha256sum] = "8578bf9f48e82f22a52d2b238f924b5d096ac043f7371902aa3b93a50c216c94"

URI_x86_64_v2_php-mysqlnd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-mysqlnd-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-mysqlnd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-mysqlnd}"
SRC_URI[x86_64_v2_php-mysqlnd.sha256sum] = "e166e42a5b3d91b1b14385855529fcd41ac2bbc247c5d7e5066014deae03fe7b"

URI_x86_64_v2_php-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-odbc-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-odbc}"
SRC_URI[x86_64_v2_php-odbc.sha256sum] = "c10386a24ec07b8d5793005d59cce15140dc597e8385e97bf9b317e1c51c98c0"

URI_x86_64_v2_php-opcache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-opcache-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-opcache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-opcache}"
SRC_URI[x86_64_v2_php-opcache.sha256sum] = "e4ebf4c7fe58b83079c4963afe2bb430ce34886c50dc8d3ea43f414eda940d92"

URI_x86_64_v2_php-pdo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pdo-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-pdo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pdo}"
SRC_URI[x86_64_v2_php-pdo.sha256sum] = "00024deeb9666a3be53b67c4cce0e4475319f124e1a4e95ad30a92d33d52d592"

URI_x86_64_v2_php-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pgsql-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pgsql}"
SRC_URI[x86_64_v2_php-pgsql.sha256sum] = "76a1f08fb1429d33349cbbe8716a5aaa228aee149418ce30a1695c33c5de8ca6"

URI_x86_64_v2_php-process = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-process-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-process}"
SRC_URI[x86_64_v2_php-process.sha256sum] = "59815da3ee9fa9a681904ece2415c27ff1f0277a7854f7249997eba2b8143148"

URI_x86_64_v2_php-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-snmp-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-snmp}"
SRC_URI[x86_64_v2_php-snmp.sha256sum] = "a334921bb11e6ac31033abe055a582133a3a8324038db1ac25c959b677bc395f"

URI_x86_64_v2_php-soap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-soap-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-soap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-soap}"
SRC_URI[x86_64_v2_php-soap.sha256sum] = "6dd01ec2c35597b7ea6326cf2eeea73c53b6efab555f2f974ae4b3e5548e9b9c"

URI_x86_64_v2_php-xml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-xml-8.3.19-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_php-xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-xml}"
SRC_URI[x86_64_v2_php-xml.sha256sum] = "2027583649d21e9904773f81a8a5d3e6d7c882a2409884d66783f652fdd9a6ab"

URI_aarch64_php = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php;unpack=0"
SRC_URI:append = " ${URI_aarch64_php}"
SRC_URI[aarch64_php.sha256sum] = "26b430fdb211969d3bba83c37de145cb3dcc3347e38f24f24c41c50e79fb5042"

URI_aarch64_php-bcmath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-bcmath-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-bcmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-bcmath}"
SRC_URI[aarch64_php-bcmath.sha256sum] = "4b102708388a42d21ca2ff55747b85adb645e7022856a0a31b7a178e531ff7b1"

URI_aarch64_php-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-cli-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-cli}"
SRC_URI[aarch64_php-cli.sha256sum] = "d321064f50549115c6d75894bae2dcc2f5c52db579589f109ff1b721ecd056c0"

URI_aarch64_php-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-common-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-common}"
SRC_URI[aarch64_php-common.sha256sum] = "63e0a64241578de4020812ae49bace860bf2d59929c6b09f0eed41fe55e425b0"

URI_aarch64_php-dba = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-dba-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-dba;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-dba}"
SRC_URI[aarch64_php-dba.sha256sum] = "22567ccdab763081d1fe8fa5268fa6ea0b486980079150a64132417ae83846f5"

URI_aarch64_php-dbg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-dbg-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-dbg;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-dbg}"
SRC_URI[aarch64_php-dbg.sha256sum] = "ef128fd8a25eb9aab397d0192bb5304fe079c8ab2d1a2d52782a6c90485c6439"

URI_aarch64_php-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-devel-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-devel}"
SRC_URI[aarch64_php-devel.sha256sum] = "c2cebdf16be6047eb52c00f2f4f9a42bdfcb200e4bacdd5e19f747d0e57628f2"

URI_aarch64_php-embedded = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-embedded-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-embedded;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-embedded}"
SRC_URI[aarch64_php-embedded.sha256sum] = "51a9529f3a4e20d4773c5adf4934f4e21a07054f7fbfb079f5e13800b91470d5"

URI_aarch64_php-enchant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-enchant-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-enchant;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-enchant}"
SRC_URI[aarch64_php-enchant.sha256sum] = "7c4228a411f43fd73dc3ef987db483b98d94c65af1388973e3ddc00f31ef12ca"

URI_aarch64_php-ffi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-ffi-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-ffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-ffi}"
SRC_URI[aarch64_php-ffi.sha256sum] = "8e3db9f632067f99f3b11577c536f66d755b384094516cc137bcac3b0b987baa"

URI_aarch64_php-fpm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-fpm-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-fpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-fpm}"
SRC_URI[aarch64_php-fpm.sha256sum] = "9c6d1fb5ddf1155b21ec32a59cf465f5c479bb76b4fb6816f4c3963a133154cf"

URI_aarch64_php-gd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-gd-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-gd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-gd}"
SRC_URI[aarch64_php-gd.sha256sum] = "bd618edc31c0540bdb68f7c3f1c8123b8061e2e626bb139f4a452d882d24cac9"

URI_aarch64_php-gmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-gmp-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-gmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-gmp}"
SRC_URI[aarch64_php-gmp.sha256sum] = "eef236322a2d639ca634f63fce25a5cf349c8cda2ae4f69241424c6ad402a842"

URI_aarch64_php-intl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-intl-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-intl;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-intl}"
SRC_URI[aarch64_php-intl.sha256sum] = "a2a594490824fc10579643ed338611b7b4b638b137d0986c166e21fa1fafbf6a"

URI_aarch64_php-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-ldap-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-ldap}"
SRC_URI[aarch64_php-ldap.sha256sum] = "1e1ec08e2622dad58734157a1ee74c798df271c5d626a4662851af7428845c6d"

URI_aarch64_php-mbstring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-mbstring-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-mbstring;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-mbstring}"
SRC_URI[aarch64_php-mbstring.sha256sum] = "e7aefdf20642a2105ee7b802d8a8f4a9dc9b36fe60abe4f42dc5f056c125042f"

URI_aarch64_php-mysqlnd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-mysqlnd-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-mysqlnd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-mysqlnd}"
SRC_URI[aarch64_php-mysqlnd.sha256sum] = "a83b3073aff759db4e9cbcc99283b240c8635900324c6173fbd0975ad10a79d7"

URI_aarch64_php-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-odbc-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-odbc}"
SRC_URI[aarch64_php-odbc.sha256sum] = "08cbc08a9ed314371ec0f240cddf8496f2ad3354b8e7c617a1f61883a15ff2f9"

URI_aarch64_php-opcache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-opcache-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-opcache;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-opcache}"
SRC_URI[aarch64_php-opcache.sha256sum] = "eef51eb0c438c99cc6722b16ee505db3888c97ee483fa1b9cc7f381983e37e7d"

URI_aarch64_php-pdo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pdo-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-pdo;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pdo}"
SRC_URI[aarch64_php-pdo.sha256sum] = "860432fdd9267dfbdd20fa49d86fad2b6be3ed26bde37eeac1afbbf43d8eb58f"

URI_aarch64_php-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pgsql-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pgsql}"
SRC_URI[aarch64_php-pgsql.sha256sum] = "d817452a0ea2975c44e080f88aa85d41a2f9d6935ae0c07447869d92bbb30088"

URI_aarch64_php-process = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-process-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-process}"
SRC_URI[aarch64_php-process.sha256sum] = "c45653f1eaa9cbb79531e8419d274b0cda404448192f4d293cda8f6aba14fa4e"

URI_aarch64_php-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-snmp-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-snmp}"
SRC_URI[aarch64_php-snmp.sha256sum] = "701b0c5eb3d838d5757a8c7e086e87905aa515b775e5c463b6d44e196ccf4d95"

URI_aarch64_php-soap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-soap-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-soap;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-soap}"
SRC_URI[aarch64_php-soap.sha256sum] = "33785d3209efeff3b6aaf38cc63fce12818db2c88b5efc481490b00de2707b5e"

URI_aarch64_php-xml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-xml-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-xml}"
SRC_URI[aarch64_php-xml.sha256sum] = "12decce5def675cc498d5923338ce046ed96b9b4353b20a77dae3e22122e9de6"

RDEPENDS:php = " \
 php-common \
 "
RDEPENDS:php-bcmath = " \
 glibc \
 php-common \
 "
RDEPENDS:php-cli = " \
 bash \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-common = " \
 bzip2-libs \
 glibc \
 openssl-libs \
 tzdata \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:php-dba = " \
 glibc \
 lmdb-libs \
 php-common \
 tokyocabinet \
 "
RDEPENDS:php-dbg = " \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-devel = " \
 autoconf \
 automake \
 bash \
 gcc \
 gcc-c++ \
 krb5-devel \
 libtool \
 libxml2-devel \
 make \
 openssl-devel \
 pcre2-devel \
 php-cli \
 zlib-ng-compat-devel \
 "
RDEPENDS:php-embedded = " \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-enchant = " \
 enchant2 \
 glibc \
 php-common \
 "
RDEPENDS:php-ffi = " \
 glibc \
 libffi \
 php-common \
 "
RDEPENDS:php-fpm = " \
 bash \
 glibc \
 httpd-filesystem \
 libacl \
 libselinux \
 libxcrypt \
 libxml2 \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 php-common \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:php-gd = " \
 gd \
 glibc \
 php-common \
 "
RDEPENDS:php-gmp = " \
 glibc \
 gmp \
 php-common \
 "
RDEPENDS:php-intl = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 php-common \
 "
RDEPENDS:php-ldap = " \
 cyrus-sasl-lib \
 glibc \
 openldap \
 php-common \
 "
RDEPENDS:php-mbstring = " \
 glibc \
 oniguruma \
 php-common \
 "
RDEPENDS:php-mysqlnd = " \
 glibc \
 php-pdo \
 "
RDEPENDS:php-odbc = " \
 glibc \
 php-pdo \
 unixODBC \
 "
RDEPENDS:php-opcache:x86_64_v2 = " \
 capstone \
 glibc \
 libgcc \
 php-common \
"
RDEPENDS:php-opcache:aarch64 = " \
 capstone \
 glibc \
 php-common \
"
RDEPENDS:php-pdo = " \
 glibc \
 php-common \
 sqlite-libs \
 "
RDEPENDS:php-pgsql = " \
 glibc \
 libpq \
 php-pdo \
 "
RDEPENDS:php-process = " \
 glibc \
 php-common \
 "
RDEPENDS:php-snmp = " \
 glibc \
 net-snmp \
 net-snmp-libs \
 openssl-libs \
 php-common \
 "
RDEPENDS:php-soap = " \
 glibc \
 libxml2 \
 php-common \
 "
RDEPENDS:php-xml = " \
 glibc \
 libxml2 \
 libxslt \
 php-common \
 "
