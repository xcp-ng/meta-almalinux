# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXfont2"
PV = "2.0.6"
PR = "5.el10_2.3"
PACKAGES = " \
 libXfont2 \
 libXfont2-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXfont2-2.0.6-5.el10_2.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb7dd7e4fe8b0bd9c0c30e194e433d07acfd0454d028f4b4a089f86775bfb988"

URI_x86_64_v2_libXfont2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXfont2-2.0.6-5.el10_2.3.x86_64_v2.rpm;name=x86_64_v2_libXfont2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXfont2}"
SRC_URI[x86_64_v2_libXfont2.sha256sum] = "ff92cf9c72cab7affa2e52de3fd5f3919573b64ca849fba2c32457c0949e24e2"

URI_x86_64_v2_libXfont2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libXfont2-devel-2.0.6-5.el10_2.3.x86_64_v2.rpm;name=x86_64_v2_libXfont2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXfont2-devel}"
SRC_URI[x86_64_v2_libXfont2-devel.sha256sum] = "58a00234bb000bd86f45d27d6472e923d86e2359b22573c00d6e41b887f182cb"

URI_aarch64_libXfont2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXfont2-2.0.6-5.el10_2.3.aarch64.rpm;name=aarch64_libXfont2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXfont2}"
SRC_URI[aarch64_libXfont2.sha256sum] = "bf986f9d14da7f869be28259df70799fa03d682f3778e08087f14ee8be621e4a"

URI_aarch64_libXfont2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libXfont2-devel-2.0.6-5.el10_2.3.aarch64.rpm;name=aarch64_libXfont2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXfont2-devel}"
SRC_URI[aarch64_libXfont2-devel.sha256sum] = "a46e532f7c905951d7a7cd2b3d65c22ce8a951235a08d88445a315de909b2879"

RDEPENDS:libXfont2 = " \
 freetype \
 glibc \
 libfontenc \
 zlib-ng-compat \
 "
RDEPENDS:libXfont2-devel = " \
 freetype-devel \
 libXfont2 \
 libfontenc-devel \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 zlib-ng-compat-devel \
 "
