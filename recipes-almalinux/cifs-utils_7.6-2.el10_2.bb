# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cifs-utils"
PV = "7.6"
PR = "2.el10_2"
PACKAGES = " \
 cifs-utils \
 cifs-utils-devel \
 pam_cifscreds \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cifs-utils-7.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c01946768c837dadba0787b7e1adff52cee7febd37c522dc2c4b4f92857aca3c"

URI_x86_64_v2_cifs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cifs-utils-7.6-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_cifs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cifs-utils}"
SRC_URI[x86_64_v2_cifs-utils.sha256sum] = "434f44e4859fd22b35430da9aa5ec29c7993b601fd6f09ae8f638716a3fd51bb"

URI_x86_64_v2_cifs-utils-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cifs-utils-devel-7.6-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_cifs-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cifs-utils-devel}"
SRC_URI[x86_64_v2_cifs-utils-devel.sha256sum] = "c37b70d1793ee9494fe6970288e20373ad17c375e5e2ac156ab82caa5285e3df"

URI_x86_64_v2_pam_cifscreds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pam_cifscreds-7.6-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_pam_cifscreds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_cifscreds}"
SRC_URI[x86_64_v2_pam_cifscreds.sha256sum] = "ea1d5b6257e551075fc7227202471e4daf627ed26cf95df635a48368669902b7"

URI_aarch64_cifs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cifs-utils-7.6-2.el10_2.aarch64.rpm;name=aarch64_cifs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_cifs-utils}"
SRC_URI[aarch64_cifs-utils.sha256sum] = "7651e64eed36b46ea8a38d3fda0e86833efee4534ddad65e09c98cdc461a3e47"

URI_aarch64_cifs-utils-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cifs-utils-devel-7.6-2.el10_2.aarch64.rpm;name=aarch64_cifs-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cifs-utils-devel}"
SRC_URI[aarch64_cifs-utils-devel.sha256sum] = "07918f6ae031745fd088bc06ff46e927e2b85a00eedfed3a54541225a979e51f"

URI_aarch64_pam_cifscreds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pam_cifscreds-7.6-2.el10_2.aarch64.rpm;name=aarch64_pam_cifscreds;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_cifscreds}"
SRC_URI[aarch64_pam_cifscreds.sha256sum] = "e3a4414c3ff57f870f4358df6f453a452307ea0aa7e7f4a94d299a68d6b1f4c4"

RDEPENDS:cifs-utils = " \
 alternatives \
 bash \
 glibc \
 keyutils \
 keyutils-libs \
 krb5-libs \
 libcap-ng \
 libtalloc \
 libwbclient \
 "
RDEPENDS:cifs-utils-devel = " \
 "
RDEPENDS:pam_cifscreds = " \
 glibc \
 keyutils-libs \
 libtalloc \
 pam-libs \
 "
