# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kded"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kded \
 kf6-kded-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kded-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "364d7c1b37f563968fa421d9be506cc01d2519b3ec4f0a5d0ff7f90e7d33314f"

URI_x86_64_v2_kf6-kded = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kded-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kded}"
SRC_URI[x86_64_v2_kf6-kded.sha256sum] = "282a17dcc631f58e4c69a2cabc66a7487c2652fdd950127f93ba0cd8f28b8318"

URI_x86_64_v2_kf6-kded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kded-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kded-devel}"
SRC_URI[x86_64_v2_kf6-kded-devel.sha256sum] = "1cacd726c91c62c4ed107f6addc64b3d6c0336d4f47c4e3bd54393694ca684fc"

URI_aarch64_kf6-kded = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kded-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kded;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kded}"
SRC_URI[aarch64_kf6-kded.sha256sum] = "b824779373eb4e50a7ad54302dcbacc6b8e9dff3e04451e0eacccfbb86932f9d"

URI_aarch64_kf6-kded-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kded-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kded-devel}"
SRC_URI[aarch64_kf6-kded-devel.sha256sum] = "a2f72a13ebe120534ea1caf6f735ad2191f6f4dce521a600a0e3266660db5831"

RDEPENDS:kf6-kded = " \
 bash \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kded-devel = " \
 cmake-filesystem \
 kf6-kded \
 "
