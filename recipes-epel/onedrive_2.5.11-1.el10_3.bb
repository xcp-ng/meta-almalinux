# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "onedrive"
PV = "2.5.11"
PR = "1.el10_3"
PACKAGES = " \
 onedrive \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/onedrive-2.5.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6a6d98cb0a10b0a2addb29f1a9a2bc19bf4c9381f9c94bc5b736cbc51e7005a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/onedrive-2.5.11-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_onedrive;unpack=0"
SRC_URI[x86_64_v2_onedrive.sha256sum] = "049acc83bd919bed0857d14446227fcec719a49a5e2ed8088e0a89fb8bd9507c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/onedrive-2.5.11-1.el10_3.aarch64.rpm;name=aarch64_onedrive;unpack=0"
SRC_URI[aarch64_onedrive.sha256sum] = "a9e2d5f3cd301d11a13544a510dbacfc5304845770a50757699068a17d986279"

RDEPENDS:onedrive = " \
 bash \
 dbus-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 ldc-libs \
 libgcc \
 libnotify \
 sqlite-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
