# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-google"
PV = "3.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-google+default-devel \
 rust-reqsign-google-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-google-3.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4d4b80d840c49793906e73ad43f4f613d4c436ef7688008c5a1b18c7de4d2ee"

URI_x86_64_v2_rust-reqsign-google+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-google+default-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-google+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-google+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-google+default-devel.sha256sum] = "0dfd0f168b7f373a579cbc629a5b4f042bae47dc6bed030d1677048b931a52d7"

URI_x86_64_v2_rust-reqsign-google-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-google-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-google-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-google-devel}"
SRC_URI[x86_64_v2_rust-reqsign-google-devel.sha256sum] = "759c6fddbd7c949fed2c79177e454393dd8a6c40756c42ada37319234c43e438"

URI_aarch64_rust-reqsign-google+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-google+default-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-google+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-google+default-devel}"
SRC_URI[aarch64_rust-reqsign-google+default-devel.sha256sum] = "b617ac84a942804756c4bd163a4081589058730eae5c556bd2d1a335922c00c4"

URI_aarch64_rust-reqsign-google-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-google-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-google-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-google-devel}"
SRC_URI[aarch64_rust-reqsign-google-devel.sha256sum] = "62632560b138353c8607304a057aa70d46accc753466050d6c93f4fcdbdc457f"

RDEPENDS:rust-reqsign-google+default-devel = " \
 cargo \
 rust-reqsign-google-devel \
 "
RDEPENDS:rust-reqsign-google-devel = " \
 cargo \
 rust \
 rust-form_urlencoded+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-aws-v4+default-devel \
 rust-reqsign-core+default-devel \
 rust-reqsign-core+jwt-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
