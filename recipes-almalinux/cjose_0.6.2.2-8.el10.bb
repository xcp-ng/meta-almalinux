# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cjose"
PV = "0.6.2.2"
PR = "8.el10"
PACKAGES = " \
 cjose \
 cjose-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cjose-0.6.2.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "df2630992e495a9d9d0ef7c82da40bb915ff098c0165e11d7f7ecdf227802461"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cjose-0.6.2.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_cjose;unpack=0"
SRC_URI[x86_64_v2_cjose.sha256sum] = "59461f3f2004e00ef3337eb9818026454b0d62bc0b41c3dc47efaef20e35f4de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cjose-devel-0.6.2.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_cjose-devel;unpack=0"
SRC_URI[x86_64_v2_cjose-devel.sha256sum] = "369829a6dc300adc536374898a9bf294f8bbd86870a3de12decc38ba98401294"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cjose-0.6.2.2-8.el10.aarch64.rpm;name=aarch64_cjose;unpack=0"
SRC_URI[aarch64_cjose.sha256sum] = "9fbfbf55de27fc0787e5782f6bf5ea9b7f3ceef44e9234ad956bece335f7e59d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cjose-devel-0.6.2.2-8.el10.aarch64.rpm;name=aarch64_cjose-devel;unpack=0"
SRC_URI[aarch64_cjose-devel.sha256sum] = "5592f7563e65aebae5c1d579e679ac3e3f80d3b700a45c29ca9abbe4d718bf24"

RDEPENDS:cjose = " \
 glibc \
 jansson \
 openssl-libs \
 "
RDEPENDS:cjose-devel = " \
 cjose \
 jansson-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
