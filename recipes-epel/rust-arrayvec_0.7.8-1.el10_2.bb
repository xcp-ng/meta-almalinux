# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrayvec"
PV = "0.7.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-arrayvec+default-devel \
 rust-arrayvec+serde-devel \
 rust-arrayvec+std-devel \
 rust-arrayvec+zeroize-devel \
 rust-arrayvec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrayvec-0.7.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57feea6582d1263abf5be9eb78232c59d6e9c0bac7b71a16301c7cdf41b3c038"

URI_x86_64_v2_rust-arrayvec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec+default-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec+default-devel}"
SRC_URI[x86_64_v2_rust-arrayvec+default-devel.sha256sum] = "7a8e5526113d82293563cbfa0e798c315ed9f22438cfaa3863362106d328b805"

URI_x86_64_v2_rust-arrayvec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec+serde-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec+serde-devel}"
SRC_URI[x86_64_v2_rust-arrayvec+serde-devel.sha256sum] = "440f4be9ba8f613ea738670147e409def279d327f74ecff0afd28dd233fa1c03"

URI_x86_64_v2_rust-arrayvec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec+std-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec+std-devel}"
SRC_URI[x86_64_v2_rust-arrayvec+std-devel.sha256sum] = "0470e8905c562bd2d0420b85243fed0291af5ccc59e374a3f1607408aac5fb21"

URI_x86_64_v2_rust-arrayvec+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec+zeroize-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec+zeroize-devel}"
SRC_URI[x86_64_v2_rust-arrayvec+zeroize-devel.sha256sum] = "40ecaf8fe9b87058744a0ef2b7624582cbc92a9763f70979ca6a87b962a87b3b"

URI_x86_64_v2_rust-arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec-devel}"
SRC_URI[x86_64_v2_rust-arrayvec-devel.sha256sum] = "0812ac60c2bd298924d1198a1b5ddc3509293ada2a32430c7a539d8f85bd3fc0"

URI_aarch64_rust-arrayvec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec+default-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-arrayvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec+default-devel}"
SRC_URI[aarch64_rust-arrayvec+default-devel.sha256sum] = "f5f023986bf23c3aa91631b932cea0aa2134abc41965459ba1408f45b1392fd0"

URI_aarch64_rust-arrayvec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec+serde-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-arrayvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec+serde-devel}"
SRC_URI[aarch64_rust-arrayvec+serde-devel.sha256sum] = "0b053a7e9f142d6ebd3482ffd41dfaa2346086d77ca40cb166d831e6367ad226"

URI_aarch64_rust-arrayvec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec+std-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-arrayvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec+std-devel}"
SRC_URI[aarch64_rust-arrayvec+std-devel.sha256sum] = "1ba4788700c26ec705a3dead1fd61ae6537991e2aa75273b81f33d25f7f344f6"

URI_aarch64_rust-arrayvec+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec+zeroize-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-arrayvec+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec+zeroize-devel}"
SRC_URI[aarch64_rust-arrayvec+zeroize-devel.sha256sum] = "b286bf0503ee991e74b8a7bd6a39eee6c3281a2a21af7cacf6bda2fc1f527450"

URI_aarch64_rust-arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec-devel}"
SRC_URI[aarch64_rust-arrayvec-devel.sha256sum] = "73ea54cca7c9172c9edec288c45917c1049e7fc587f3de03dc8c617161dc112f"

RDEPENDS:rust-arrayvec+default-devel = " \
 cargo \
 rust-arrayvec+std-devel \
 rust-arrayvec-devel \
 "
RDEPENDS:rust-arrayvec+serde-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-arrayvec+std-devel = " \
 cargo \
 rust-arrayvec-devel \
 "
RDEPENDS:rust-arrayvec+zeroize-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-arrayvec-devel = " \
 cargo \
 rust \
 "
