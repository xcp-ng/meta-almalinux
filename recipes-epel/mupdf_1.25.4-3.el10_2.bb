# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mupdf"
PV = "1.25.4"
PR = "3.el10_2"
PACKAGES = " \
 mupdf \
 mupdf-cpp-devel \
 mupdf-cpp-libs \
 mupdf-devel \
 mupdf-libs \
 python3-mupdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mupdf-1.25.4-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bab9bec19eea57dfd4e3b55492618a8ad9b3bf5cfc05fbdc23a74dac4365acf"

URI_x86_64_v2_mupdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-1.25.4-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf}"
SRC_URI[x86_64_v2_mupdf.sha256sum] = "a364c70f144292e191685927ab91d5e1da8b24de9d7374d28afc5af5faf23ee6"

URI_x86_64_v2_mupdf-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-cpp-devel-1.25.4-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf-cpp-devel}"
SRC_URI[x86_64_v2_mupdf-cpp-devel.sha256sum] = "7a6ddb4f77810ca9bcd8f8c7e8d10b09c72111e386d1a0365272fd8a08ab5303"

URI_x86_64_v2_mupdf-cpp-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-cpp-libs-1.25.4-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf-cpp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf-cpp-libs}"
SRC_URI[x86_64_v2_mupdf-cpp-libs.sha256sum] = "91f67c1353c94fc57cac8665638b78cb27435439bcdd45b3c7a91f60765d96fc"

URI_x86_64_v2_mupdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-devel-1.25.4-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf-devel}"
SRC_URI[x86_64_v2_mupdf-devel.sha256sum] = "84ef6b859d6aee693bf44de78e9c8faa9674e0ab1cb728dfb2cfd6619a5037a3"

URI_x86_64_v2_mupdf-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-libs-1.25.4-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf-libs}"
SRC_URI[x86_64_v2_mupdf-libs.sha256sum] = "aa5c7ab1037152f07b0b6870e082d9a6dbc1c8c2a818e5cc505d0167310e3fe1"

URI_x86_64_v2_python3-mupdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mupdf-1.25.4-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-mupdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mupdf}"
SRC_URI[x86_64_v2_python3-mupdf.sha256sum] = "4b351811ef8c008a552c06620aa54ebff6024ff0453cfb3ae8d3da495c46bdd5"

URI_aarch64_mupdf = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-1.25.4-3.el10_2.aarch64.rpm;name=aarch64_mupdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf}"
SRC_URI[aarch64_mupdf.sha256sum] = "c69343daef4ba7dd2263c0ed5da3f3b43fbf5bb54e2d37f94039969c7b0de103"

URI_aarch64_mupdf-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-cpp-devel-1.25.4-3.el10_2.aarch64.rpm;name=aarch64_mupdf-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf-cpp-devel}"
SRC_URI[aarch64_mupdf-cpp-devel.sha256sum] = "416b6107413502a6b75a387e14dd33b9f0656c61dcd0e2fe2e847b3050510a79"

URI_aarch64_mupdf-cpp-libs = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-cpp-libs-1.25.4-3.el10_2.aarch64.rpm;name=aarch64_mupdf-cpp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf-cpp-libs}"
SRC_URI[aarch64_mupdf-cpp-libs.sha256sum] = "0ad8a7c6d7c1e4bcf4c339685d25192ee050c48caca170fb8fc65abd2d87e3a8"

URI_aarch64_mupdf-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-devel-1.25.4-3.el10_2.aarch64.rpm;name=aarch64_mupdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf-devel}"
SRC_URI[aarch64_mupdf-devel.sha256sum] = "5f34ea1dc4a9b20e9240c08b5d5ebe594c8748d7b78c078715663c5d2943ac5e"

URI_aarch64_mupdf-libs = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-libs-1.25.4-3.el10_2.aarch64.rpm;name=aarch64_mupdf-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf-libs}"
SRC_URI[aarch64_mupdf-libs.sha256sum] = "6d11adb447764e70eb79714641966a0ebe0d86d8a2241a84b721a7705daeb8da"

URI_aarch64_python3-mupdf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mupdf-1.25.4-3.el10_2.aarch64.rpm;name=aarch64_python3-mupdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mupdf}"
SRC_URI[aarch64_python3-mupdf.sha256sum] = "53a96dcf03c92b0bc1b2af2109ba76845909c7fd9ec7c712458e02de5b215b02"

RDEPENDS:mupdf = " \
 freeglut \
 glibc \
 libX11 \
 libXext \
 libglvnd-glx \
 mupdf-libs \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:mupdf-cpp-devel = " \
 mupdf-cpp-libs \
 "
RDEPENDS:mupdf-cpp-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 mupdf-libs \
 "
RDEPENDS:mupdf-devel = " \
 mupdf-libs \
 "
RDEPENDS:mupdf-libs = " \
 freetype \
 glibc \
 gumbo-parser \
 harfbuzz \
 jbig2dec-libs \
 leptonica \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 openjpeg2 \
 tesseract \
 zlib-ng-compat \
 "
RDEPENDS:python3-mupdf = " \
 glibc \
 libgcc \
 libstdc++ \
 mupdf-cpp-libs \
 mupdf-libs \
 python3 \
 "
