# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-ARP"
PV = "1.0.12"
PR = "13.el10_1"
PACKAGES = " \
 perl-Net-ARP \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-ARP-1.0.12-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e129513c39a781a095b65e2c96acf5bb1bd6ec161ba58afe96aa706295dfe8b4"

URI_x86_64_v2_perl-Net-ARP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-ARP-1.0.12-13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Net-ARP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-ARP}"
SRC_URI[x86_64_v2_perl-Net-ARP.sha256sum] = "4b627eabe92569b0454ea2797a3ef2accaf042fded64527bc055b71a9ea02ec4"

URI_aarch64_perl-Net-ARP = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-ARP-1.0.12-13.el10_1.aarch64.rpm;name=aarch64_perl-Net-ARP;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-ARP}"
SRC_URI[aarch64_perl-Net-ARP.sha256sum] = "83d4d9c745db3982eaf0217086799d80aebd1b4ec442ae09c7fc12ae4083dc85"

RDEPENDS:perl-Net-ARP = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
