# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "samba"
PV = "4.21.3"
PR = "113.el10_0"
PACKAGES:x86_64_v2 = " \
 ldb-tools \
 libldb \
 libldb-devel \
 libnetapi \
 libnetapi-devel \
 libsmbclient \
 libsmbclient-devel \
 libwbclient \
 libwbclient-devel \
 python3-ldb \
 python3-samba \
 python3-samba-dc \
 python3-samba-test \
 samba \
 samba-client \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dc-libs \
 samba-dcerpc \
 samba-devel \
 samba-gpupdate \
 samba-krb5-printing \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-pidl \
 samba-test \
 samba-test-libs \
 samba-tools \
 samba-usershares \
 samba-vfs-iouring \
 samba-winbind \
 samba-winbind-clients \
 samba-winbind-krb5-locator \
 samba-winbind-modules \
 samba-winexe \
"
PACKAGES:aarch64 = " \
 ldb-tools \
 libldb \
 libldb-devel \
 libnetapi \
 libnetapi-devel \
 libsmbclient \
 libsmbclient-devel \
 libwbclient \
 libwbclient-devel \
 python3-ldb \
 python3-samba \
 python3-samba-dc \
 python3-samba-test \
 samba \
 samba-client \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dc-libs \
 samba-dcerpc \
 samba-devel \
 samba-gpupdate \
 samba-krb5-printing \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-pidl \
 samba-test \
 samba-test-libs \
 samba-tools \
 samba-usershares \
 samba-vfs-iouring \
 samba-winbind \
 samba-winbind-clients \
 samba-winbind-krb5-locator \
 samba-winbind-modules \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/samba-4.21.3-113.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "074cb4281d812ea20f34df905167d311fb6626c1ae16b6a04e8fc33d560491b9"

URI_x86_64_v2_ldb-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ldb-tools-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_ldb-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldb-tools}"
SRC_URI[x86_64_v2_ldb-tools.sha256sum] = "c5b5621f70a9dca6074fb86e1b37fc1524056537c80445f8519d4c43b8d9f907"

URI_x86_64_v2_libldb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libldb-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_libldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libldb}"
SRC_URI[x86_64_v2_libldb.sha256sum] = "e8384ddce63a601f555f154d54fc3954998cc38c78cfd7e06cd36af4a5562582"

URI_x86_64_v2_libldb-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libldb-devel-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_libldb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libldb-devel}"
SRC_URI[x86_64_v2_libldb-devel.sha256sum] = "0490dfcef94012ea00d3b25d2c701fa78f2f93be607fb51900c549be61ff6931"

URI_x86_64_v2_libnetapi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnetapi-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_libnetapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetapi}"
SRC_URI[x86_64_v2_libnetapi.sha256sum] = "87366ecf3212e84c1a4446d3157239b8724cc0f0aa04c001ffc33af35cdacf1a"

URI_x86_64_v2_libnetapi-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnetapi-devel-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_libnetapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetapi-devel}"
SRC_URI[x86_64_v2_libnetapi-devel.sha256sum] = "4dbd2cea2737505a16e6b48bd2a5767a4286d3d7c84cbed1b4e9f6c9b6d7c227"

URI_x86_64_v2_libsmbclient = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsmbclient-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_libsmbclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmbclient}"
SRC_URI[x86_64_v2_libsmbclient.sha256sum] = "4e463db0c4467577d22e81d2ea2ef91fb1a691ec2279e77aa35d865eff24c5a4"

URI_x86_64_v2_libsmbclient-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsmbclient-devel-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_libsmbclient-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmbclient-devel}"
SRC_URI[x86_64_v2_libsmbclient-devel.sha256sum] = "9a1f8a0335923025844c471f02634d440a49be845deee819c633cba4b80e9248"

URI_x86_64_v2_libwbclient = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libwbclient-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_libwbclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwbclient}"
SRC_URI[x86_64_v2_libwbclient.sha256sum] = "88029e56bf18e8263fab8455977688daf3d556644ffb1858ffb39db94b4f99db"

URI_x86_64_v2_libwbclient-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwbclient-devel-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_libwbclient-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwbclient-devel}"
SRC_URI[x86_64_v2_libwbclient-devel.sha256sum] = "8c30a57a74b53886b050582092f24c86bd0d7b06dae2bde3e977f5f336ab6e8b"

URI_x86_64_v2_python3-ldb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-ldb-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-ldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ldb}"
SRC_URI[x86_64_v2_python3-ldb.sha256sum] = "abd0c4ca3d91c3ea9b86aac170eeee68825403adf790bc138ce8fb0b623de41e"

URI_x86_64_v2_python3-samba = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-samba-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-samba}"
SRC_URI[x86_64_v2_python3-samba.sha256sum] = "4ebd83db83e9e5c0a20d33b999b811cb0ada58d8a5a079a18f18208b43c22510"

URI_x86_64_v2_python3-samba-dc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-samba-dc-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-samba-dc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-samba-dc}"
SRC_URI[x86_64_v2_python3-samba-dc.sha256sum] = "f84539c9456c0b6883319851a06080bbefe52feceb7dc0dba380399d9603fde2"

URI_x86_64_v2_python3-samba-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-samba-test-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-samba-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-samba-test}"
SRC_URI[x86_64_v2_python3-samba-test.sha256sum] = "3f123e08a100dada44707e20d2b997d03e4dc9982e92dc221404d3eebace6319"

URI_x86_64_v2_samba = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba}"
SRC_URI[x86_64_v2_samba.sha256sum] = "d53ebdb9caa0c82ed995ba3a0387c9337f6851c59bf34415f81773d99a0de53c"

URI_x86_64_v2_samba-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-client-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-client}"
SRC_URI[x86_64_v2_samba-client.sha256sum] = "3aac095480c9beb33fb9c162675e69e04203b58d864f35e31ec63ee6387d983c"

URI_x86_64_v2_samba-client-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-client-libs-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-client-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-client-libs}"
SRC_URI[x86_64_v2_samba-client-libs.sha256sum] = "0519ab89ddc5a2d69891107ae72eae1420f94e216c0cf30a580d7d64f29080c1"

URI_x86_64_v2_samba-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-4.21.3-113.el10_0.noarch.rpm;name=x86_64_v2_samba-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-common}"
SRC_URI[x86_64_v2_samba-common.sha256sum] = "6f0518d8a3611e4128757f6b37747e5d4535f1d73e9d8484018500af9326815d"

URI_x86_64_v2_samba-common-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-libs-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-common-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-common-libs}"
SRC_URI[x86_64_v2_samba-common-libs.sha256sum] = "5bf486dd12f08c8225510e68067774517f730c9d41140e9efbd1685525d997bf"

URI_x86_64_v2_samba-common-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-tools-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-common-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-common-tools}"
SRC_URI[x86_64_v2_samba-common-tools.sha256sum] = "4d82e49197859139f3bcfdb9a574d990f8461ab49c6e11c16ea94fc0cda41350"

URI_x86_64_v2_samba-dc-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-dc-libs-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-dc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-dc-libs}"
SRC_URI[x86_64_v2_samba-dc-libs.sha256sum] = "4ffbfcef8c02a71e0400dd6f79c2439d9045fc2311bcf9ba245fc753888e2844"

URI_x86_64_v2_samba-dcerpc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-dcerpc-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-dcerpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-dcerpc}"
SRC_URI[x86_64_v2_samba-dcerpc.sha256sum] = "a6b80c13906d340baf97aed268e2dab2b45fa407eeb52cf12066a8e48409483f"

URI_x86_64_v2_samba-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-devel-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-devel}"
SRC_URI[x86_64_v2_samba-devel.sha256sum] = "8db2659971777051d9a062dc49f981bc9858f433ebcc39a8f7df85b07aa46f08"

URI_x86_64_v2_samba-gpupdate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-gpupdate-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-gpupdate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-gpupdate}"
SRC_URI[x86_64_v2_samba-gpupdate.sha256sum] = "74859eb30594c276e6e9edc7cd872edc4277b86ce85e553481c47b5c064be644"

URI_x86_64_v2_samba-krb5-printing = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-krb5-printing-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-krb5-printing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-krb5-printing}"
SRC_URI[x86_64_v2_samba-krb5-printing.sha256sum] = "b286b8e38c9b2c2361f8d40b90855a6519d558a5a397ae900869b7e068a8f454"

URI_x86_64_v2_samba-ldb-ldap-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-ldb-ldap-modules-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-ldb-ldap-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-ldb-ldap-modules}"
SRC_URI[x86_64_v2_samba-ldb-ldap-modules.sha256sum] = "f92ea00d0f65c18aa6ab7ad7ff5b017d584c3630e12e51271dfa74682951ea74"

URI_x86_64_v2_samba-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-libs-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-libs}"
SRC_URI[x86_64_v2_samba-libs.sha256sum] = "44c4ed3c743ea86ad22440316d256ba2c4c7a6fcf87523dd3799cc1caee66cdd"

URI_x86_64_v2_samba-pidl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-pidl-4.21.3-113.el10_0.noarch.rpm;name=x86_64_v2_samba-pidl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-pidl}"
SRC_URI[x86_64_v2_samba-pidl.sha256sum] = "89cea9c3a4722bec9c780432da0ead29acf4fee34833ab6d7e6ebe0ce4fa83b3"

URI_x86_64_v2_samba-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-test-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-test}"
SRC_URI[x86_64_v2_samba-test.sha256sum] = "ae69f125d0467b9acd857854f33ca77eccdcbecec9eeb9e7a847cb755c1730a9"

URI_x86_64_v2_samba-test-libs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-test-libs-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-test-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-test-libs}"
SRC_URI[x86_64_v2_samba-test-libs.sha256sum] = "0b1f28f6eb7640724c0d45b1a72b2b62bcc9db088174fc48caeb2dba7c4a0763"

URI_x86_64_v2_samba-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-tools-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-tools}"
SRC_URI[x86_64_v2_samba-tools.sha256sum] = "e0e64925adadbff71a4e2678a0e42c14b353001579767af420c32c5c64c78ea9"

URI_x86_64_v2_samba-usershares = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-usershares-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-usershares;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-usershares}"
SRC_URI[x86_64_v2_samba-usershares.sha256sum] = "162a2c45ad2c4405162a244f74ba792dfde780cf19ba878151f72fb9b7cbee1b"

URI_x86_64_v2_samba-vfs-iouring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-vfs-iouring-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-vfs-iouring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-vfs-iouring}"
SRC_URI[x86_64_v2_samba-vfs-iouring.sha256sum] = "ca5674b0d344da50cefa56512c646643671c19057999072acb510999037b7b52"

URI_x86_64_v2_samba-winbind = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-winbind-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-winbind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind}"
SRC_URI[x86_64_v2_samba-winbind.sha256sum] = "9fd72ad74e99ba93f8180744bb56264b4f2ce7f0bae1933c7467318d9f4ce7c7"

URI_x86_64_v2_samba-winbind-clients = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winbind-clients-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind-clients}"
SRC_URI[x86_64_v2_samba-winbind-clients.sha256sum] = "28696c28496ae8f00d95336a6906368a41d5687bc21cb41fa3a64c5537c7e519"

URI_x86_64_v2_samba-winbind-krb5-locator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winbind-krb5-locator-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-krb5-locator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind-krb5-locator}"
SRC_URI[x86_64_v2_samba-winbind-krb5-locator.sha256sum] = "760b2f264d9044100af400ee39b9c9aeac434079ade5b1a8873bccd87f7f45dd"

URI_x86_64_v2_samba-winbind-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-winbind-modules-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind-modules}"
SRC_URI[x86_64_v2_samba-winbind-modules.sha256sum] = "716d458d2570d68bee49c40a5d6f4977b759658f94c8f5c38ee75ef66561d4de"

URI_x86_64_v2_samba-winexe = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winexe-4.21.3-113.el10_0.x86_64_v2.rpm;name=x86_64_v2_samba-winexe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winexe}"
SRC_URI[x86_64_v2_samba-winexe.sha256sum] = "c6c0ab9316f13e776ecd15452e40b0813aba8503e9e1ff9deb9158a0f362847b"

URI_aarch64_ldb-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ldb-tools-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_ldb-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldb-tools}"
SRC_URI[aarch64_ldb-tools.sha256sum] = "6b644e762333a3177d248dfe043c5a80caa1c2bc2ce7300145788408e7df4215"

URI_aarch64_libldb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libldb-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_libldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libldb}"
SRC_URI[aarch64_libldb.sha256sum] = "ce01d9e7f36588db0d42d0c9a9f2abc2875ca683b8808c3553d7514225a0452a"

URI_aarch64_libldb-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libldb-devel-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_libldb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libldb-devel}"
SRC_URI[aarch64_libldb-devel.sha256sum] = "66c3d7af6586f9bffa65f74bec7795dd64ca6b218f284c5c4e35ea8e1d9d0f92"

URI_aarch64_libnetapi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnetapi-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_libnetapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetapi}"
SRC_URI[aarch64_libnetapi.sha256sum] = "30f39ffa6045abda339be5e3ba27111328b70631c39f1b67f88c29e5d6a523e2"

URI_aarch64_libnetapi-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnetapi-devel-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_libnetapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetapi-devel}"
SRC_URI[aarch64_libnetapi-devel.sha256sum] = "7dd7e1d54e1ca6da9f8a4b19244458e1e7ac4005adc7f30e7b42cb34b5b9d040"

URI_aarch64_libsmbclient = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsmbclient-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_libsmbclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmbclient}"
SRC_URI[aarch64_libsmbclient.sha256sum] = "eb5e2cd5f37ddf7083527785edf7f9b4d20bed20732ea4e518e190f9b3edd429"

URI_aarch64_libsmbclient-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsmbclient-devel-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_libsmbclient-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmbclient-devel}"
SRC_URI[aarch64_libsmbclient-devel.sha256sum] = "fd7949f1dcdaafd4f4d38115ba007b702cd93446fe7c8593a34a94ea470da158"

URI_aarch64_libwbclient = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libwbclient-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_libwbclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwbclient}"
SRC_URI[aarch64_libwbclient.sha256sum] = "bb91fd81a4f98f0786a2776d13661ebeb0b33ceffd3a148370af03b1828a669b"

URI_aarch64_libwbclient-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwbclient-devel-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_libwbclient-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwbclient-devel}"
SRC_URI[aarch64_libwbclient-devel.sha256sum] = "25c670634ec384d48ba299cbb63938981cfe46aa348c344c6915cbc5b114d758"

URI_aarch64_python3-ldb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-ldb-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_python3-ldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ldb}"
SRC_URI[aarch64_python3-ldb.sha256sum] = "fc14daecee28282441e6485fb1f76c90cc746d1842bcd2fbe0bb0f75b01ba63b"

URI_aarch64_python3-samba = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-samba-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_python3-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-samba}"
SRC_URI[aarch64_python3-samba.sha256sum] = "77b2fa0c75a826500a43002df93f367636f78c8fc47f21b65e7053a179c048f7"

URI_aarch64_python3-samba-dc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-samba-dc-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_python3-samba-dc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-samba-dc}"
SRC_URI[aarch64_python3-samba-dc.sha256sum] = "c6f80070ea75079c714eea1da1fdb39ed3c7b7c992483b9585c0a4bb31b90f7b"

URI_aarch64_python3-samba-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-samba-test-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_python3-samba-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-samba-test}"
SRC_URI[aarch64_python3-samba-test.sha256sum] = "6f075edef8ec66852ee1528559c3debc1bb1e40e85e512518d5029e0e3277314"

URI_aarch64_samba = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba}"
SRC_URI[aarch64_samba.sha256sum] = "873015aca19e8cf79a3bc43841930121ea79538d019660f00d6ff14ff72cf193"

URI_aarch64_samba-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-client-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-client}"
SRC_URI[aarch64_samba-client.sha256sum] = "02bc5c306957626af0e2afbfb57d345d1272856ecb798f33596908dae2d1e20f"

URI_aarch64_samba-client-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-client-libs-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-client-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-client-libs}"
SRC_URI[aarch64_samba-client-libs.sha256sum] = "a6801a70c11503decff2e218d7177c7d0875be89f901b78f3afaad89d9ef859b"

URI_aarch64_samba-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-4.21.3-113.el10_0.noarch.rpm;name=aarch64_samba-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-common}"
SRC_URI[aarch64_samba-common.sha256sum] = "6f0518d8a3611e4128757f6b37747e5d4535f1d73e9d8484018500af9326815d"

URI_aarch64_samba-common-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-libs-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-common-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-common-libs}"
SRC_URI[aarch64_samba-common-libs.sha256sum] = "41bc4a344c32139efe6e6cf570b44a8087948146d7d961b6684b5f7f4fde332b"

URI_aarch64_samba-common-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-tools-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-common-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-common-tools}"
SRC_URI[aarch64_samba-common-tools.sha256sum] = "cd216c840d102eba4e70571b7327557f462d61f13dc09dfe9b18124d15202ccc"

URI_aarch64_samba-dc-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-dc-libs-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-dc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-dc-libs}"
SRC_URI[aarch64_samba-dc-libs.sha256sum] = "ad8d8c49f1c39641b2e3ebf02566d48e83ef2e7b41cd457a92ddfb3acb95de41"

URI_aarch64_samba-dcerpc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-dcerpc-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-dcerpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-dcerpc}"
SRC_URI[aarch64_samba-dcerpc.sha256sum] = "5bf5534e99930543d3beb0a078955bd11675f564972d9d8ec75e04c584a7c75a"

URI_aarch64_samba-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-devel-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-devel}"
SRC_URI[aarch64_samba-devel.sha256sum] = "69715e4863000a2670b754b8bd6c398fd9d596027d69477ba5511e95437d0f32"

URI_aarch64_samba-gpupdate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-gpupdate-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-gpupdate;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-gpupdate}"
SRC_URI[aarch64_samba-gpupdate.sha256sum] = "d779f414d6e5679fe861b9d471874eb12204ef2b9672af24b504b6cb1861c895"

URI_aarch64_samba-krb5-printing = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-krb5-printing-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-krb5-printing;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-krb5-printing}"
SRC_URI[aarch64_samba-krb5-printing.sha256sum] = "9d1bdeee6a4f2d2be189f826cfc1bcc18d83689afee9ccefb517da28cd6f596a"

URI_aarch64_samba-ldb-ldap-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-ldb-ldap-modules-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-ldb-ldap-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-ldb-ldap-modules}"
SRC_URI[aarch64_samba-ldb-ldap-modules.sha256sum] = "a7747a70064e6613292304127b168a5b4b4286aec42326cc6105582df94e32bb"

URI_aarch64_samba-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-libs-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-libs}"
SRC_URI[aarch64_samba-libs.sha256sum] = "33b4053494450d330dce3bb95161633703a2243f55d9647f7d60cef81572dbc8"

URI_aarch64_samba-pidl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-pidl-4.21.3-113.el10_0.noarch.rpm;name=aarch64_samba-pidl;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-pidl}"
SRC_URI[aarch64_samba-pidl.sha256sum] = "89cea9c3a4722bec9c780432da0ead29acf4fee34833ab6d7e6ebe0ce4fa83b3"

URI_aarch64_samba-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-test-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-test}"
SRC_URI[aarch64_samba-test.sha256sum] = "b697637ac85d8e92579bd8c2a777a1dea330d32115f44246d479da586520ccca"

URI_aarch64_samba-test-libs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-test-libs-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-test-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-test-libs}"
SRC_URI[aarch64_samba-test-libs.sha256sum] = "1b3fec9e9b611edb910279f5fe3152cddd37c5a90514d5a6bf73153215a9d0d4"

URI_aarch64_samba-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-tools-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-tools}"
SRC_URI[aarch64_samba-tools.sha256sum] = "6aac4ea875f7c5ea82da1db93740315865a95c424292bb02fd050a3a5a554a1f"

URI_aarch64_samba-usershares = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-usershares-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-usershares;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-usershares}"
SRC_URI[aarch64_samba-usershares.sha256sum] = "3019f531a9c0805a15dcaff992c0cdf682140cf1b7f351cc16874548612244e0"

URI_aarch64_samba-vfs-iouring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-vfs-iouring-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-vfs-iouring;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-vfs-iouring}"
SRC_URI[aarch64_samba-vfs-iouring.sha256sum] = "430e30505ae50ddb49936b20f5006edde9f0782ab3b071ac8b0505b9644ece3a"

URI_aarch64_samba-winbind = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-winbind-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-winbind;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind}"
SRC_URI[aarch64_samba-winbind.sha256sum] = "7e49e911ee46598e94dd70820c5e7348fbc9b4128b9377c2483015a44c7224a3"

URI_aarch64_samba-winbind-clients = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-winbind-clients-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-winbind-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind-clients}"
SRC_URI[aarch64_samba-winbind-clients.sha256sum] = "dfe04a849ab797c038f7a92de2dde8f9d5bfc5d3a8bcc3918746bdaa1eb38bb0"

URI_aarch64_samba-winbind-krb5-locator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-winbind-krb5-locator-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-winbind-krb5-locator;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind-krb5-locator}"
SRC_URI[aarch64_samba-winbind-krb5-locator.sha256sum] = "45ffd391d9d387b9adebbf1b91a5256cfdda1a0158e88c511706ae74ffa49032"

URI_aarch64_samba-winbind-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-winbind-modules-4.21.3-113.el10_0.aarch64.rpm;name=aarch64_samba-winbind-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind-modules}"
SRC_URI[aarch64_samba-winbind-modules.sha256sum] = "3e78ee46ac63711918e234b60e8a96754800201b5ebdfd6f68d162f4814f42b5"

RDEPENDS:ldb-tools = " \
 glibc \
 libldb \
 libtalloc \
 popt \
 "
RDEPENDS:libldb = " \
 glibc \
 libtalloc \
 libtdb \
 libtevent \
 lmdb-libs \
 "
RDEPENDS:libldb-devel = " \
 libldb \
 libtalloc-devel \
 libtdb-devel \
 libtevent-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libnetapi = " \
 glibc \
 gnutls \
 libgcc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 "
RDEPENDS:libnetapi-devel = " \
 libnetapi \
 pkgconf-pkg-config \
 "
RDEPENDS:libsmbclient = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 "
RDEPENDS:libsmbclient-devel = " \
 libsmbclient \
 pkgconf-pkg-config \
 "
RDEPENDS:libwbclient = " \
 bash \
 glibc \
 samba-client-libs \
 "
RDEPENDS:libwbclient-devel = " \
 libwbclient \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-ldb = " \
 glibc \
 libldb \
 libtalloc \
 python3 \
 python3-libs \
 python3-tdb \
 samba-client-libs \
 "
RDEPENDS:python3-samba = " \
 glibc \
 gnutls \
 krb5-libs \
 libgcc \
 libldb \
 libsmbclient \
 libtalloc \
 libtevent \
 libwbclient \
 python3 \
 python3-cryptography \
 python3-dns \
 python3-ldb \
 python3-libs \
 python3-requests \
 python3-talloc \
 python3-tdb \
 python3-tevent \
 samba-client-libs \
 samba-common-libs \
 samba-dc-libs \
 samba-libs \
 "
RDEPENDS:python3-samba-dc = " \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 python3 \
 python3-libs \
 python3-markdown \
 python3-samba \
 python3-talloc \
 samba-client-libs \
 samba-dc-libs \
 "
RDEPENDS:python3-samba-test = " \
 python3 \
 python3-samba \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba = " \
 bash \
 cups-libs \
 dbus-libs \
 glibc \
 gnutls \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 pam \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dcerpc \
 samba-libs \
 "
RDEPENDS:samba-client = " \
 alternatives \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libarchive \
 libcom_err \
 libldb \
 libsmbclient \
 libtalloc \
 libtevent \
 libwbclient \
 ncurses-libs \
 popt \
 readline \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 "
RDEPENDS:samba-client-libs = " \
 avahi-libs \
 glibc \
 glibc-gconv-extra \
 gnutls \
 jansson \
 krb5-libs \
 libacl \
 libcap \
 libcom_err \
 libgcc \
 libicu \
 libldb \
 libtalloc \
 libtasn1 \
 libtdb \
 libtevent \
 libtirpc \
 libwbclient \
 libxcrypt \
 openldap \
 pam-libs \
 popt \
 samba-common \
 samba-common-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:samba-common = " \
 bash \
 systemd \
 "
RDEPENDS:samba-common-libs = " \
 glibc \
 libldb \
 libtalloc \
 libtdb \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common \
 "
RDEPENDS:samba-common-tools = " \
 glibc \
 gnutls \
 jansson \
 krb5-libs \
 libcom_err \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 python3 \
 readline \
 samba-client-libs \
 samba-common-libs \
 samba-ldb-ldap-modules \
 samba-libs \
 "
RDEPENDS:samba-dc-libs = " \
 glibc \
 gnutls \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 samba-client-libs \
 samba-common-libs \
 samba-libs \
 "
RDEPENDS:samba-dcerpc = " \
 cups-libs \
 glibc \
 gnutls \
 jansson \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common-libs \
 samba-libs \
 "
RDEPENDS:samba-devel = " \
 libldb-devel \
 libnetapi \
 libtalloc-devel \
 libtevent-devel \
 pkgconf-pkg-config \
 samba-client-libs \
 samba-dc-libs \
 samba-devel \
 samba-libs \
 "
RDEPENDS:samba-gpupdate = " \
 cepces-certmonger \
 certmonger \
 python3 \
 python3-samba \
 python3-samba-dc \
 samba-ldb-ldap-modules \
 "
RDEPENDS:samba-krb5-printing = " \
 alternatives \
 bash \
 glibc \
 krb5-libs \
 samba-client \
 samba-client-libs \
 "
RDEPENDS:samba-ldb-ldap-modules = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 openldap \
 samba-client-libs \
 samba-common-libs \
 "
RDEPENDS:samba-libs = " \
 glibc \
 libldb \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common-libs \
 "
RDEPENDS:samba-pidl = " \
 perl-Exporter \
 perl-File-Basename \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Parse-Yapp \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-parent \
 perl-vars \
 samba-pidl \
 "
RDEPENDS:samba-test = " \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libnetapi \
 libsmbclient \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 perl-Archive-Tar \
 popt \
 python3-samba \
 readline \
 samba \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-dc-libs \
 samba-libs \
 samba-test-libs \
 samba-winbind \
 "
RDEPENDS:samba-test-libs = " \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-common-libs \
 samba-libs \
 "
RDEPENDS:samba-tools = " \
 python3 \
 python3-samba \
 python3-samba-dc \
 "
RDEPENDS:samba-usershares = " \
 bash \
 samba \
 samba-common-tools \
 "
RDEPENDS:samba-vfs-iouring = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 liburing \
 libwbclient \
 samba \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba-winbind = " \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dcerpc \
 samba-libs \
 samba-winbind-modules \
 "
RDEPENDS:samba-winbind-clients = " \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-libs \
 samba-winbind \
 "
RDEPENDS:samba-winbind-krb5-locator = " \
 alternatives \
 bash \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-winbind \
 "
RDEPENDS:samba-winbind-modules = " \
 glibc \
 libtalloc \
 libwbclient \
 pam \
 pam-libs \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba-winexe = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common-libs \
 "
