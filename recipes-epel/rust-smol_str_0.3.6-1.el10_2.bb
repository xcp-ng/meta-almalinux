# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smol_str"
PV = "0.3.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-smol_str+arbitrary-devel \
 rust-smol_str+default-devel \
 rust-smol_str+serde-devel \
 rust-smol_str+std-devel \
 rust-smol_str-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-smol_str-0.3.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "445b92b1251f4df08de24a5b2580c40d3b3fee0ffc861d903e913ba90c921a58"

URI_x86_64_v2_rust-smol_str+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str+arbitrary-devel-0.3.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-smol_str+arbitrary-devel.sha256sum] = "1ff96a98a3247cbc0ab5384a4b43141e64a422df72607fd5b5d60ce143245313"

URI_x86_64_v2_rust-smol_str+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str+default-devel-0.3.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str+default-devel}"
SRC_URI[x86_64_v2_rust-smol_str+default-devel.sha256sum] = "f7f0cf1b32641a421e2ed933c6a4353e5a478c4cbeba393410ae675e0bcb3031"

URI_x86_64_v2_rust-smol_str+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str+serde-devel-0.3.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str+serde-devel}"
SRC_URI[x86_64_v2_rust-smol_str+serde-devel.sha256sum] = "afda78d38f52469ede76dbbc480400d45e2cc0b1112448771220fdefa9540c46"

URI_x86_64_v2_rust-smol_str+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str+std-devel-0.3.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str+std-devel}"
SRC_URI[x86_64_v2_rust-smol_str+std-devel.sha256sum] = "71b05720e0f714958c26595b9534a905bf0a397408c4e1baece7b25042689bd8"

URI_x86_64_v2_rust-smol_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str-devel-0.3.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str-devel}"
SRC_URI[x86_64_v2_rust-smol_str-devel.sha256sum] = "cd55c9d2f7d4dd9f11d424e82290eaf6a53c545a3f322cf41569f7cda90ff937"

URI_aarch64_rust-smol_str+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str+arbitrary-devel-0.3.6-1.el10_2.noarch.rpm;name=aarch64_rust-smol_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str+arbitrary-devel}"
SRC_URI[aarch64_rust-smol_str+arbitrary-devel.sha256sum] = "ba0f4ee85b228ca314a7a32e8330028f4b6f382045e0a15e4fdcf50f86641a2f"

URI_aarch64_rust-smol_str+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str+default-devel-0.3.6-1.el10_2.noarch.rpm;name=aarch64_rust-smol_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str+default-devel}"
SRC_URI[aarch64_rust-smol_str+default-devel.sha256sum] = "0119c6c8438f93026f46f0d167010d5aa94c522938668622b5fb1da254607501"

URI_aarch64_rust-smol_str+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str+serde-devel-0.3.6-1.el10_2.noarch.rpm;name=aarch64_rust-smol_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str+serde-devel}"
SRC_URI[aarch64_rust-smol_str+serde-devel.sha256sum] = "bd63892a884de61229e8d4ba841acd59822a070301439d310931cf599469c25b"

URI_aarch64_rust-smol_str+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str+std-devel-0.3.6-1.el10_2.noarch.rpm;name=aarch64_rust-smol_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str+std-devel}"
SRC_URI[aarch64_rust-smol_str+std-devel.sha256sum] = "e4761eddc9994d7427f5f73cee9e6da364d59c9e0a568d407d5a87aa3dadda7d"

URI_aarch64_rust-smol_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str-devel-0.3.6-1.el10_2.noarch.rpm;name=aarch64_rust-smol_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str-devel}"
SRC_URI[aarch64_rust-smol_str-devel.sha256sum] = "470a3aac59765cc4222bb0b82ccd7c99724e43838ab0c756523eaf06a24b155d"

RDEPENDS:rust-smol_str+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-smol_str+default-devel = " \
 cargo \
 rust-smol_str+std-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-smol_str+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-smol_str+std-devel = " \
 cargo \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-smol_str-devel = " \
 cargo \
 rust \
 "
