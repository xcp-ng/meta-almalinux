# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_ignored"
PV = "0.1.14"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde_ignored+default-devel \
 rust-serde_ignored-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-serde_ignored-0.1.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b370d1be63220b8390f370a4938574dd0f5ea56240141fd25a3da3ac4035ef36"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_ignored+default-devel-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_ignored+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_ignored+default-devel.sha256sum] = "c39686d18e2f942c58ce04cc8a332e6286821e0cd30574d401504dbc521435ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_ignored-devel-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_ignored-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_ignored-devel.sha256sum] = "616740be5477df74b29858a646b76cba4caebf90ead934fe2f9259ec18fe1f3a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_ignored+default-devel-0.1.14-1.el10_0.noarch.rpm;name=aarch64_rust-serde_ignored+default-devel;unpack=0"
SRC_URI[aarch64_rust-serde_ignored+default-devel.sha256sum] = "117d7b62c9a346d2aa2c12733f965539f1c871073bb53f6da35358027a8c8024"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_ignored-devel-0.1.14-1.el10_0.noarch.rpm;name=aarch64_rust-serde_ignored-devel;unpack=0"
SRC_URI[aarch64_rust-serde_ignored-devel.sha256sum] = "f2a55a18d10fd0df1f346efe9f251462ef6e594b3d749075609cfc0e78e28a77"

RDEPENDS:rust-serde_ignored+default-devel = " \
 cargo \
 rust-serde_ignored-devel \
 "
RDEPENDS:rust-serde_ignored-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
