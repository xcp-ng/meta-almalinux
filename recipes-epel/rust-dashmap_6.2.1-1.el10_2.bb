# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dashmap"
PV = "6.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-dashmap+arbitrary-devel \
 rust-dashmap+default-devel \
 rust-dashmap+inline-devel \
 rust-dashmap+raw-api-devel \
 rust-dashmap+rayon-devel \
 rust-dashmap+serde-devel \
 rust-dashmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dashmap-6.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1de92d7eece6ce51be9e611d2e39ca59cdab004f23f0086c0d575e7be2fd0be7"

URI_x86_64_v2_rust-dashmap+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+arbitrary-devel-6.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-dashmap+arbitrary-devel.sha256sum] = "de5c13a27ba9fa1222c7774254a99ab53601b9da7e650adef3ef5bc5c1838911"

URI_x86_64_v2_rust-dashmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+default-devel-6.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+default-devel}"
SRC_URI[x86_64_v2_rust-dashmap+default-devel.sha256sum] = "68b60707686497784b455e0a6179c439470a872b73dcc58702ab8a66b5c206a8"

URI_x86_64_v2_rust-dashmap+inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+inline-devel-6.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+inline-devel}"
SRC_URI[x86_64_v2_rust-dashmap+inline-devel.sha256sum] = "00ff43a3f8603690f833c07c7831d92d3cba06cf59be0b53847dbb559726f663"

URI_x86_64_v2_rust-dashmap+raw-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+raw-api-devel-6.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+raw-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+raw-api-devel}"
SRC_URI[x86_64_v2_rust-dashmap+raw-api-devel.sha256sum] = "dfa99cf808567a2f2461ab86b51defb605aefd68596e3594311bb2711eb51f8e"

URI_x86_64_v2_rust-dashmap+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+rayon-devel-6.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+rayon-devel}"
SRC_URI[x86_64_v2_rust-dashmap+rayon-devel.sha256sum] = "3897a6bb7c6c2322529cb52debde98c78ec9b933810d3aadb4b8fe0f0670bbb2"

URI_x86_64_v2_rust-dashmap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+serde-devel-6.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+serde-devel}"
SRC_URI[x86_64_v2_rust-dashmap+serde-devel.sha256sum] = "7acb591c717303e3fcfe82ff956126f8bf26226f73a1cfe8198724c864deffdd"

URI_x86_64_v2_rust-dashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap-devel-6.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap-devel}"
SRC_URI[x86_64_v2_rust-dashmap-devel.sha256sum] = "bdd4c5417805c45d30a1ffbacfcc054cc79c1d51c12721c9809d9101c24a7f9b"

URI_aarch64_rust-dashmap+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+arbitrary-devel-6.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-dashmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+arbitrary-devel}"
SRC_URI[aarch64_rust-dashmap+arbitrary-devel.sha256sum] = "a1b20ea9d25c544d92b77d50daa883c5183e3011e533e45a471d4658a7524acb"

URI_aarch64_rust-dashmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+default-devel-6.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-dashmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+default-devel}"
SRC_URI[aarch64_rust-dashmap+default-devel.sha256sum] = "9ceb1343701c2f39117257621ef65c026f1a8ae581aeeadc793f1f8063abbcda"

URI_aarch64_rust-dashmap+inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+inline-devel-6.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-dashmap+inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+inline-devel}"
SRC_URI[aarch64_rust-dashmap+inline-devel.sha256sum] = "dc4999ba6e6d81eeb0b497211adb0926cb0aeeced4088d197bd89ce093fdea12"

URI_aarch64_rust-dashmap+raw-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+raw-api-devel-6.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-dashmap+raw-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+raw-api-devel}"
SRC_URI[aarch64_rust-dashmap+raw-api-devel.sha256sum] = "1253a25a2c03466293344ebd5ed82c4def9101a2400ef7d47a4977bf6f819b4e"

URI_aarch64_rust-dashmap+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+rayon-devel-6.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-dashmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+rayon-devel}"
SRC_URI[aarch64_rust-dashmap+rayon-devel.sha256sum] = "8860bd12507bbe109372c92d9c9bae567090eae65e15e58b7918c1b752017a4d"

URI_aarch64_rust-dashmap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+serde-devel-6.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-dashmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+serde-devel}"
SRC_URI[aarch64_rust-dashmap+serde-devel.sha256sum] = "022c6cffa356a1a609b7590f3a4895ce7786e9b75eaa7bb009bdac7b7149b721"

URI_aarch64_rust-dashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap-devel-6.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap-devel}"
SRC_URI[aarch64_rust-dashmap-devel.sha256sum] = "253709291d0fa66e0da542163b1ce544a70fd463507bea2677ac00ae5c7d4937"

RDEPENDS:rust-dashmap+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-dashmap-devel \
 "
RDEPENDS:rust-dashmap+default-devel = " \
 cargo \
 rust-dashmap-devel \
 "
RDEPENDS:rust-dashmap+inline-devel = " \
 cargo \
 rust-dashmap-devel \
 rust-hashbrown0.14+inline-more-devel \
 "
RDEPENDS:rust-dashmap+raw-api-devel = " \
 cargo \
 rust-dashmap-devel \
 "
RDEPENDS:rust-dashmap+rayon-devel = " \
 cargo \
 rust-dashmap-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-dashmap+serde-devel = " \
 cargo \
 rust-dashmap-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-dashmap-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-crossbeam-utils+default-devel \
 rust-hashbrown0.14+raw-devel \
 rust-hashbrown0.14-devel \
 rust-lock_api+default-devel \
 rust-once_cell+default-devel \
 rust-parking_lot_core+default-devel \
 "
