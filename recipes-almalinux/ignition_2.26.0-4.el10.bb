# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ignition"
PV = "2.26.0"
PR = "4.el10"
PACKAGES = " \
 ignition \
 ignition-edge \
 ignition-grub \
 ignition-validate \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ignition-2.26.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1a327a06875b0d856f27c42eed7c78e4401bea160c1adf92e28eed682b47716"

URI_x86_64_v2_ignition = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-2.26.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_ignition;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition}"
SRC_URI[x86_64_v2_ignition.sha256sum] = "b3ab5dd285a5bb08a4e82f310d1b7fa26c5cd94060854566649286d23e602ccf"

URI_x86_64_v2_ignition-edge = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-edge-2.26.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_ignition-edge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition-edge}"
SRC_URI[x86_64_v2_ignition-edge.sha256sum] = "a98fba0e03e65f36d55c3ddd002f84aafbf7b18e1cfc672d0673f50b88bd3ae6"

URI_x86_64_v2_ignition-grub = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-grub-2.26.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_ignition-grub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition-grub}"
SRC_URI[x86_64_v2_ignition-grub.sha256sum] = "a2ad34bad98f270f096b578f26d843700a05bb370cd4cdd75e6e0bc9ddca9549"

URI_x86_64_v2_ignition-validate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-validate-2.26.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_ignition-validate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition-validate}"
SRC_URI[x86_64_v2_ignition-validate.sha256sum] = "b1a4040a0130d73c22ebe987693fab14b694476cce71ddcdb22d53d14ccb2871"

URI_aarch64_ignition = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-2.26.0-4.el10.aarch64.rpm;name=aarch64_ignition;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition}"
SRC_URI[aarch64_ignition.sha256sum] = "34895b41db10d6d82453fe7fbb12f41a3c2d133841ee0741fe488965d3a44a88"

URI_aarch64_ignition-edge = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-edge-2.26.0-4.el10.aarch64.rpm;name=aarch64_ignition-edge;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition-edge}"
SRC_URI[aarch64_ignition-edge.sha256sum] = "34f1ead01119280dedf704c8d45dd1ca45998050ce8ebf94de78aa416f65244e"

URI_aarch64_ignition-grub = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-grub-2.26.0-4.el10.aarch64.rpm;name=aarch64_ignition-grub;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition-grub}"
SRC_URI[aarch64_ignition-grub.sha256sum] = "23ba53d80e62a80bfd5ee347eecec6c2dbf8ea5d98b48fcab383657df053c247"

URI_aarch64_ignition-validate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-validate-2.26.0-4.el10.aarch64.rpm;name=aarch64_ignition-validate;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition-validate}"
SRC_URI[aarch64_ignition-validate.sha256sum] = "30f92e265e9cc0ddf22b40b980ba85daece3c208a55a7261e09cd7865ae88cc9"

RDEPENDS:ignition = " \
 bash \
 dosfstools \
 dracut \
 dracut-network \
 glibc \
 libblkid \
 libgcc \
 libstdc++ \
 libuuid \
 popt \
 "
RDEPENDS:ignition-edge = " \
 bash \
 "
RDEPENDS:ignition-grub = " \
 "
RDEPENDS:ignition-validate = " \
 glibc \
 "
