# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sqlx-macros"
PV = "0.8.6"
PR = "4.el10_2"
PACKAGES = " \
 rust-sqlx-macros+_rt-tokio-devel \
 rust-sqlx-macros+_tls-native-tls-devel \
 rust-sqlx-macros+_tls-rustls-ring-native-roots-devel \
 rust-sqlx-macros+_tls-rustls-ring-webpki-devel \
 rust-sqlx-macros+bigdecimal-devel \
 rust-sqlx-macros+bit-vec-devel \
 rust-sqlx-macros+chrono-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+derive-devel \
 rust-sqlx-macros+ipnet-devel \
 rust-sqlx-macros+ipnetwork-devel \
 rust-sqlx-macros+json-devel \
 rust-sqlx-macros+mac_address-devel \
 rust-sqlx-macros+macros-devel \
 rust-sqlx-macros+migrate-devel \
 rust-sqlx-macros+mysql-devel \
 rust-sqlx-macros+postgres-devel \
 rust-sqlx-macros+rust_decimal-devel \
 rust-sqlx-macros+sqlite-devel \
 rust-sqlx-macros+sqlite-unbundled-devel \
 rust-sqlx-macros+time-devel \
 rust-sqlx-macros+uuid-devel \
 rust-sqlx-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sqlx-macros-0.8.6-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8144e55490f7d5c90c75cdcf5498d5b2a1d2978f38d9d3ca95f4f4ce578cca3b"

URI_x86_64_v2_rust-sqlx-macros+_rt-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+_rt-tokio-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+_rt-tokio-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+_rt-tokio-devel.sha256sum] = "e6434dbe14e1ec6b106b50e4eb9b351d7dcedbf4ffd426ddf7191cb45d0546f8"

URI_x86_64_v2_rust-sqlx-macros+_tls-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+_tls-native-tls-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+_tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+_tls-native-tls-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+_tls-native-tls-devel.sha256sum] = "6cc508ddda345f4670e159fb09576762b64e079ea1d08a7eb2b8dead3a541f85"

URI_x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+_tls-rustls-ring-native-roots-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel.sha256sum] = "04939839c606547e51bf8d731ae2c286d26772c52e887109db796e4eeae6e29c"

URI_x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-webpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+_tls-rustls-ring-webpki-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-webpki-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-webpki-devel.sha256sum] = "7e39fc1b26dc92349aa5166978562a935150b3d498b05232c600d3f5e69247df"

URI_x86_64_v2_rust-sqlx-macros+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+bigdecimal-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+bigdecimal-devel.sha256sum] = "fa48f21ae81e01b2f767a4bc78f927c23e62b43f354a983dcc9effd64d22582f"

URI_x86_64_v2_rust-sqlx-macros+bit-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+bit-vec-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+bit-vec-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+bit-vec-devel.sha256sum] = "abd4b2872020d9b999a571397e5a98f0b9b863f5eaeebc4f4ce5e1287df5e124"

URI_x86_64_v2_rust-sqlx-macros+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+chrono-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+chrono-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+chrono-devel.sha256sum] = "d0598814d3b248e8819de528a26c756843e35f3a2b94d2d84865faa965a7b528"

URI_x86_64_v2_rust-sqlx-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+default-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+default-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+default-devel.sha256sum] = "0ca8b408ff588d6ad347a7a454b48ee59c648b85d206e8adc22780789dc27e4c"

URI_x86_64_v2_rust-sqlx-macros+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+derive-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+derive-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+derive-devel.sha256sum] = "7f0d67ec8d485ff83499dfd3997c07a0fcc7a9d611db12db9787cef706457c3a"

URI_x86_64_v2_rust-sqlx-macros+ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+ipnet-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+ipnet-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+ipnet-devel.sha256sum] = "16b733596d82842a6c6ae1e6c607b97eddeb77ae1a754ff680c99a8f396ec386"

URI_x86_64_v2_rust-sqlx-macros+ipnetwork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+ipnetwork-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+ipnetwork-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+ipnetwork-devel.sha256sum] = "4f4c83fe623e6077b6f6cd7bef5419e9ce699b6ed90cef4f0c9312e1bdc01c81"

URI_x86_64_v2_rust-sqlx-macros+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+json-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+json-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+json-devel.sha256sum] = "901e5b75e0f57fdeec7119f79d1acb7d79a142af3d8572962b436d56863cba6f"

URI_x86_64_v2_rust-sqlx-macros+mac_address-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+mac_address-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+mac_address-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+mac_address-devel.sha256sum] = "6355ee51635936cf6bd4499605849129efa06365d81e7fea000c3c373af870d3"

URI_x86_64_v2_rust-sqlx-macros+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+macros-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+macros-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+macros-devel.sha256sum] = "c51c20330bd07b2730f333253e1592b7b6bde479424cb787b6aad5c12da73d82"

URI_x86_64_v2_rust-sqlx-macros+migrate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+migrate-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+migrate-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+migrate-devel.sha256sum] = "c81fc5befb5a7fade8b17db0064e773648312c704a8e753ee249bbae711c2e95"

URI_x86_64_v2_rust-sqlx-macros+mysql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+mysql-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+mysql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+mysql-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+mysql-devel.sha256sum] = "16690a1b19d4d22ddab6c2057d97058b86994bca71ade8b7533f8ffc3bbfa1ef"

URI_x86_64_v2_rust-sqlx-macros+postgres-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+postgres-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+postgres-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+postgres-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+postgres-devel.sha256sum] = "080afe0389835ddd30f648b57e4bbe892b65d9395fd799379103f5b5181c4c95"

URI_x86_64_v2_rust-sqlx-macros+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+rust_decimal-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+rust_decimal-devel.sha256sum] = "47b434e815134befbc499d83b81a9e9f5250bef130c6391fa498671d1d0f0f35"

URI_x86_64_v2_rust-sqlx-macros+sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+sqlite-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+sqlite-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+sqlite-devel.sha256sum] = "f8cbd15efc2078ee45820e0a99e9eb899d08bff2caa1b558ee3863851d228f6b"

URI_x86_64_v2_rust-sqlx-macros+sqlite-unbundled-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+sqlite-unbundled-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+sqlite-unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+sqlite-unbundled-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+sqlite-unbundled-devel.sha256sum] = "2f248525f52a66ee05223b05a798fc1bf94d61369a4d47ce4c73384e7f819dc4"

URI_x86_64_v2_rust-sqlx-macros+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+time-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+time-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+time-devel.sha256sum] = "ff1d6e8d46bd3e45974871eed732b0bb0f9d7649ed99c0f86d3989a58ad57682"

URI_x86_64_v2_rust-sqlx-macros+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+uuid-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+uuid-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+uuid-devel.sha256sum] = "f5da5704e9c8649a3b8c355380ea17d321b95b4ba5252782eb9e592a1eec6a0d"

URI_x86_64_v2_rust-sqlx-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-devel.sha256sum] = "a9230f0c0f9de6532cf4525e52d6ecaab0c52a91ddaa89301267d46a1ef74318"

URI_aarch64_rust-sqlx-macros+_rt-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+_rt-tokio-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+_rt-tokio-devel}"
SRC_URI[aarch64_rust-sqlx-macros+_rt-tokio-devel.sha256sum] = "242af618c69d9491ea826974841760c6da6af72c27293e97a963e3090395e8c4"

URI_aarch64_rust-sqlx-macros+_tls-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+_tls-native-tls-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+_tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+_tls-native-tls-devel}"
SRC_URI[aarch64_rust-sqlx-macros+_tls-native-tls-devel.sha256sum] = "5c7025d8bcc8a328299011ad94e406246f6d6ac9df7a19342b8fe7936a50f60d"

URI_aarch64_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+_tls-rustls-ring-native-roots-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel}"
SRC_URI[aarch64_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel.sha256sum] = "c74dbd3e09b9d85343c299d0b4b22f76e0997458647f317dd9e5642b39054915"

URI_aarch64_rust-sqlx-macros+_tls-rustls-ring-webpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+_tls-rustls-ring-webpki-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+_tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+_tls-rustls-ring-webpki-devel}"
SRC_URI[aarch64_rust-sqlx-macros+_tls-rustls-ring-webpki-devel.sha256sum] = "f0d843858a5b9a6af8bac19a0b75c668b44f8c25bbcc329d3442397c8535d632"

URI_aarch64_rust-sqlx-macros+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+bigdecimal-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+bigdecimal-devel}"
SRC_URI[aarch64_rust-sqlx-macros+bigdecimal-devel.sha256sum] = "7a90afe964e5a8211fa87d0b95ebc9f075544ba23222892e3fc145f3d7f39d61"

URI_aarch64_rust-sqlx-macros+bit-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+bit-vec-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+bit-vec-devel}"
SRC_URI[aarch64_rust-sqlx-macros+bit-vec-devel.sha256sum] = "c504fa323446873110e651fa52cefc51816176dbe09d6e9f76f9e6395495ca69"

URI_aarch64_rust-sqlx-macros+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+chrono-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+chrono-devel}"
SRC_URI[aarch64_rust-sqlx-macros+chrono-devel.sha256sum] = "629eb97dd4a8f35746c2852e617fa9e1d22da9b63be685dfe283612341bcfa92"

URI_aarch64_rust-sqlx-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+default-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+default-devel}"
SRC_URI[aarch64_rust-sqlx-macros+default-devel.sha256sum] = "d183f6fbcf3bf2145c3215db52c80a6403da97cda716ab2e21903af6ebf38695"

URI_aarch64_rust-sqlx-macros+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+derive-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+derive-devel}"
SRC_URI[aarch64_rust-sqlx-macros+derive-devel.sha256sum] = "c3fe49cf2caa4156f68d853b27bdde1c51a6a2ae1111fe131eb0bbb449b8ae2e"

URI_aarch64_rust-sqlx-macros+ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+ipnet-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+ipnet-devel}"
SRC_URI[aarch64_rust-sqlx-macros+ipnet-devel.sha256sum] = "6c782dd5602235aec1e7de464648909c61808c739e3ff47b274d413a65e6668c"

URI_aarch64_rust-sqlx-macros+ipnetwork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+ipnetwork-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+ipnetwork-devel}"
SRC_URI[aarch64_rust-sqlx-macros+ipnetwork-devel.sha256sum] = "2c748ec0a85021f694e18fca4b0588dda6129c428ffa32db0986f6b0e30fefef"

URI_aarch64_rust-sqlx-macros+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+json-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+json-devel}"
SRC_URI[aarch64_rust-sqlx-macros+json-devel.sha256sum] = "3296344884b097a4a41ae03b2d2be11a7b74f1f3dfaf3bf79bbecced356d2f88"

URI_aarch64_rust-sqlx-macros+mac_address-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+mac_address-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+mac_address-devel}"
SRC_URI[aarch64_rust-sqlx-macros+mac_address-devel.sha256sum] = "136f50ebaf2d6fc388b96faa7ff1c790949d39c20547fef828a0b81b2230d61a"

URI_aarch64_rust-sqlx-macros+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+macros-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+macros-devel}"
SRC_URI[aarch64_rust-sqlx-macros+macros-devel.sha256sum] = "c4e363113d3278af2199ecd4c562658e0715c7e08f0e1ce6c2c3c6b5edb2c34d"

URI_aarch64_rust-sqlx-macros+migrate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+migrate-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+migrate-devel}"
SRC_URI[aarch64_rust-sqlx-macros+migrate-devel.sha256sum] = "b6fedd03676fbc58f6c96c071210aab204e8e3d8a79d70b115083ca597bcc0ee"

URI_aarch64_rust-sqlx-macros+mysql-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+mysql-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+mysql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+mysql-devel}"
SRC_URI[aarch64_rust-sqlx-macros+mysql-devel.sha256sum] = "1e0ec44b2243582dacaa270b8ba96f0dffe1556050e7e7d10944d26a25cc9db9"

URI_aarch64_rust-sqlx-macros+postgres-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+postgres-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+postgres-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+postgres-devel}"
SRC_URI[aarch64_rust-sqlx-macros+postgres-devel.sha256sum] = "767de6274b37c765c11b71b53e20401900999e0c943a4634be07d2fd3c20c81a"

URI_aarch64_rust-sqlx-macros+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+rust_decimal-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+rust_decimal-devel}"
SRC_URI[aarch64_rust-sqlx-macros+rust_decimal-devel.sha256sum] = "d7f33b0340b08ab6957489f91107d5a9c8d725b7b3e054b78b405ee36da936ec"

URI_aarch64_rust-sqlx-macros+sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+sqlite-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+sqlite-devel}"
SRC_URI[aarch64_rust-sqlx-macros+sqlite-devel.sha256sum] = "ca5b56e5f0bbc6d9fab1c191fc68d38ec333188ac42e2b86f8f622c6ee90e310"

URI_aarch64_rust-sqlx-macros+sqlite-unbundled-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+sqlite-unbundled-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+sqlite-unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+sqlite-unbundled-devel}"
SRC_URI[aarch64_rust-sqlx-macros+sqlite-unbundled-devel.sha256sum] = "171bdad223cd2b7d20e78463af94e26ff2be3309ddb36ae8910996206c59191b"

URI_aarch64_rust-sqlx-macros+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+time-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+time-devel}"
SRC_URI[aarch64_rust-sqlx-macros+time-devel.sha256sum] = "077dd3e0f2ac6dd1c58ea35479d58280c7c39ef9932c305e63c05670e9db48d6"

URI_aarch64_rust-sqlx-macros+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+uuid-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+uuid-devel}"
SRC_URI[aarch64_rust-sqlx-macros+uuid-devel.sha256sum] = "a933152347f2b83fcf141acc4fc0b6e640077b8f9ce75eaf1d61d17c7b1ad2e5"

URI_aarch64_rust-sqlx-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-devel}"
SRC_URI[aarch64_rust-sqlx-macros-devel.sha256sum] = "b366b6e6975516018df5fd141d7da2e5e08f3daf6d840363d01f85ab4c2c840c"

RDEPENDS:rust-sqlx-macros+_rt-tokio-devel = " \
 cargo \
 rust-sqlx-macros-core+_rt-tokio-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+_tls-native-tls-devel = " \
 cargo \
 rust-sqlx-macros-core+_tls-native-tls-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+_tls-rustls-ring-native-roots-devel = " \
 cargo \
 rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+_tls-rustls-ring-webpki-devel = " \
 cargo \
 rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+bigdecimal-devel = " \
 cargo \
 rust-sqlx-macros-core+bigdecimal-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+bit-vec-devel = " \
 cargo \
 rust-sqlx-macros-core+bit-vec-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+chrono-devel = " \
 cargo \
 rust-sqlx-macros-core+chrono-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+default-devel = " \
 cargo \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+derive-devel = " \
 cargo \
 rust-sqlx-macros-core+derive-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+ipnet-devel = " \
 cargo \
 rust-sqlx-macros-core+ipnet-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+ipnetwork-devel = " \
 cargo \
 rust-sqlx-macros-core+ipnetwork-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+json-devel = " \
 cargo \
 rust-sqlx-macros-core+json-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+mac_address-devel = " \
 cargo \
 rust-sqlx-macros-core+mac_address-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+macros-devel = " \
 cargo \
 rust-sqlx-macros-core+macros-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+migrate-devel = " \
 cargo \
 rust-sqlx-macros-core+migrate-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+mysql-devel = " \
 cargo \
 rust-sqlx-macros-core+mysql-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+postgres-devel = " \
 cargo \
 rust-sqlx-macros-core+postgres-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+rust_decimal-devel = " \
 cargo \
 rust-sqlx-macros-core+rust_decimal-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+sqlite-devel = " \
 cargo \
 rust-sqlx-macros-core+sqlite-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+sqlite-unbundled-devel = " \
 cargo \
 rust-sqlx-macros-core+sqlite-unbundled-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+time-devel = " \
 cargo \
 rust-sqlx-macros-core+time-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+uuid-devel = " \
 cargo \
 rust-sqlx-macros-core+uuid-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros-devel = " \
 cargo \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-sqlx-core+any-devel \
 rust-sqlx-core+default-devel \
 rust-sqlx-macros-core+default-devel \
 rust-syn+parsing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
