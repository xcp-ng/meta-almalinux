# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ctor-proc-macro"
PV = "0.0.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-ctor-proc-macro+default-devel \
 rust-ctor-proc-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ctor-proc-macro-0.0.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "077a30ab0d2ca108e636be941bb2d43b612a94c8a068fe20fae6454f6ea6ba58"

URI_x86_64_v2_rust-ctor-proc-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor-proc-macro+default-devel-0.0.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor-proc-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctor-proc-macro+default-devel}"
SRC_URI[x86_64_v2_rust-ctor-proc-macro+default-devel.sha256sum] = "33d9bd51100106b64f867312379b1dfedd308e994f5362b650e34902b6c7ff4c"

URI_x86_64_v2_rust-ctor-proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor-proc-macro-devel-0.0.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor-proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctor-proc-macro-devel}"
SRC_URI[x86_64_v2_rust-ctor-proc-macro-devel.sha256sum] = "ea4d97d79e7add365904c7147a004e8686563af44e7244276187ea2736253a23"

URI_aarch64_rust-ctor-proc-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor-proc-macro+default-devel-0.0.13-1.el10_3.noarch.rpm;name=aarch64_rust-ctor-proc-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctor-proc-macro+default-devel}"
SRC_URI[aarch64_rust-ctor-proc-macro+default-devel.sha256sum] = "2bb92cbc74ee6f2a18fd85abf5b8687bf637fd8ea89dc4eacffdbbf349db86d9"

URI_aarch64_rust-ctor-proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor-proc-macro-devel-0.0.13-1.el10_3.noarch.rpm;name=aarch64_rust-ctor-proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctor-proc-macro-devel}"
SRC_URI[aarch64_rust-ctor-proc-macro-devel.sha256sum] = "2dbb896f14cca09330f2ba65b698fbb889b32522c4b1fc830dd22ea4b645c266"

RDEPENDS:rust-ctor-proc-macro+default-devel = " \
 cargo \
 rust-ctor-proc-macro-devel \
 "
RDEPENDS:rust-ctor-proc-macro-devel = " \
 cargo \
 "
