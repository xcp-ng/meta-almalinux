# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-masterminds-goutils"
PV = "1.1.0"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-masterminds-goutils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-masterminds-goutils-1.1.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efb78661c809bdcc52aa56885022d756eb03c37accf408b74f34e7c34244c6dd"

URI_x86_64_v2_golang-github-masterminds-goutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-masterminds-goutils-devel-1.1.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-masterminds-goutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-masterminds-goutils-devel}"
SRC_URI[x86_64_v2_golang-github-masterminds-goutils-devel.sha256sum] = "98bfdd5a788e22d65fa1fe6a7113c77ae4deb4c43df6892b47fc10bacecaab37"

URI_aarch64_golang-github-masterminds-goutils-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-masterminds-goutils-devel-1.1.0-14.el10_0.noarch.rpm;name=aarch64_golang-github-masterminds-goutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-masterminds-goutils-devel}"
SRC_URI[aarch64_golang-github-masterminds-goutils-devel.sha256sum] = "666c4b13f530d924ec6776fcce24fe3ca38ec8a2290082bbd4ee671fdbe53ffa"

RDEPENDS:golang-github-masterminds-goutils-devel = " \
 go-filesystem \
 "
