# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lv2"
PV = "0.6.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-lv2+default-devel \
 rust-lv2+full-devel \
 rust-lv2+lv2-atom-devel \
 rust-lv2+lv2-core-devel \
 rust-lv2+lv2-midi-devel \
 rust-lv2+lv2-state-devel \
 rust-lv2+lv2-sys-devel \
 rust-lv2+lv2-time-devel \
 rust-lv2+lv2-units-devel \
 rust-lv2+lv2-urid-devel \
 rust-lv2+lv2-worker-devel \
 rust-lv2+minimal_plugin-devel \
 rust-lv2+plugin-devel \
 rust-lv2+urid-devel \
 rust-lv2+wmidi-devel \
 rust-lv2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lv2-0.6.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e3ee3b654710cae9d7f0a3158afe1d2e37ca653ddb82b6e8dd74cb3ede4d682"

URI_x86_64_v2_rust-lv2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+default-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+default-devel}"
SRC_URI[x86_64_v2_rust-lv2+default-devel.sha256sum] = "b3ad929c4f0daafa278ff77710f92ffd8faaa848d62df35ce97909784f64bccf"

URI_x86_64_v2_rust-lv2+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+full-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+full-devel}"
SRC_URI[x86_64_v2_rust-lv2+full-devel.sha256sum] = "bd6d1fb07c97ead4b0f068b97e71f63145a82bb7c53a666c2092064c36c2b86a"

URI_x86_64_v2_rust-lv2+lv2-atom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+lv2-atom-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+lv2-atom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+lv2-atom-devel}"
SRC_URI[x86_64_v2_rust-lv2+lv2-atom-devel.sha256sum] = "e2ba8dfc1f3285ddff53a3176b79dcabfb3fc018d24241dd4b0f13e72b541277"

URI_x86_64_v2_rust-lv2+lv2-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+lv2-core-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+lv2-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+lv2-core-devel}"
SRC_URI[x86_64_v2_rust-lv2+lv2-core-devel.sha256sum] = "dbe3b7c2135191fc5542c5c163536af43cab04be83ab493699aa91691d7d3379"

URI_x86_64_v2_rust-lv2+lv2-midi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+lv2-midi-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+lv2-midi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+lv2-midi-devel}"
SRC_URI[x86_64_v2_rust-lv2+lv2-midi-devel.sha256sum] = "3a588c2645b9316f61fbb024751cd4d8219385c503689beed03011cb4ad596a6"

URI_x86_64_v2_rust-lv2+lv2-state-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+lv2-state-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+lv2-state-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+lv2-state-devel}"
SRC_URI[x86_64_v2_rust-lv2+lv2-state-devel.sha256sum] = "16ea8d0519c3fe2221f675fa9201b1636b3a7d48f7800436cf0d4a9977937104"

URI_x86_64_v2_rust-lv2+lv2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+lv2-sys-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+lv2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+lv2-sys-devel}"
SRC_URI[x86_64_v2_rust-lv2+lv2-sys-devel.sha256sum] = "a2e7f6d53b966d34d5a12fb55f43a83f2d2af6b0b4f6b52f7f492237c7417a87"

URI_x86_64_v2_rust-lv2+lv2-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+lv2-time-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+lv2-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+lv2-time-devel}"
SRC_URI[x86_64_v2_rust-lv2+lv2-time-devel.sha256sum] = "8896ea12ead5504373853737dc8fd816a2ca19954e0da9d191b066aed77d4523"

URI_x86_64_v2_rust-lv2+lv2-units-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+lv2-units-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+lv2-units-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+lv2-units-devel}"
SRC_URI[x86_64_v2_rust-lv2+lv2-units-devel.sha256sum] = "5f27dc2dc35cdcde3ed6391dfac71724d65a0070abcc2767ed8cf56ef4e54903"

URI_x86_64_v2_rust-lv2+lv2-urid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+lv2-urid-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+lv2-urid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+lv2-urid-devel}"
SRC_URI[x86_64_v2_rust-lv2+lv2-urid-devel.sha256sum] = "ec70e6737c21c9d8a5a9c406a6e71780f2aa6d5d88f38c467c45589146d072ef"

URI_x86_64_v2_rust-lv2+lv2-worker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+lv2-worker-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+lv2-worker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+lv2-worker-devel}"
SRC_URI[x86_64_v2_rust-lv2+lv2-worker-devel.sha256sum] = "e0c3431fb8752dbf1e13b1f462da05111f5910fb5a6606d05a0681cf915a7aa8"

URI_x86_64_v2_rust-lv2+minimal_plugin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+minimal_plugin-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+minimal_plugin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+minimal_plugin-devel}"
SRC_URI[x86_64_v2_rust-lv2+minimal_plugin-devel.sha256sum] = "923f3a8827299851debdae6f4752ff5f7a25769df5d9999e4a3ea0f80da372c6"

URI_x86_64_v2_rust-lv2+plugin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+plugin-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+plugin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+plugin-devel}"
SRC_URI[x86_64_v2_rust-lv2+plugin-devel.sha256sum] = "94ca35d4a8d82af4531aa1ed63da91577942cde56b651d8b271586e75f5f77da"

URI_x86_64_v2_rust-lv2+urid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+urid-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+urid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+urid-devel}"
SRC_URI[x86_64_v2_rust-lv2+urid-devel.sha256sum] = "fee3ea4eb8f9decefe806a61ee07ee299aefc6222f2148a677b83d174f94dcea"

URI_x86_64_v2_rust-lv2+wmidi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2+wmidi-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2+wmidi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2+wmidi-devel}"
SRC_URI[x86_64_v2_rust-lv2+wmidi-devel.sha256sum] = "9e6d79c5d18cc7ccc2624765f67139f339860230041f2bb3f49a54be35127997"

URI_x86_64_v2_rust-lv2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-devel}"
SRC_URI[x86_64_v2_rust-lv2-devel.sha256sum] = "f499d4d612fca540537549e56c9b06e22192e90eddd7ce72105893061d46a272"

URI_aarch64_rust-lv2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+default-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+default-devel}"
SRC_URI[aarch64_rust-lv2+default-devel.sha256sum] = "06afef7eaee196dd524f0ce276859a3e81556cb7507043c0711ff087d9773050"

URI_aarch64_rust-lv2+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+full-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+full-devel}"
SRC_URI[aarch64_rust-lv2+full-devel.sha256sum] = "f502291068cc54022d458c66536b264426d50306ce8c9117090d13eecb13595f"

URI_aarch64_rust-lv2+lv2-atom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+lv2-atom-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+lv2-atom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+lv2-atom-devel}"
SRC_URI[aarch64_rust-lv2+lv2-atom-devel.sha256sum] = "e07f56a818abbbeac9e5ef67e5a33b0f100efa4b5091a55360a1ae44de566fd5"

URI_aarch64_rust-lv2+lv2-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+lv2-core-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+lv2-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+lv2-core-devel}"
SRC_URI[aarch64_rust-lv2+lv2-core-devel.sha256sum] = "f4068a60afc5a41230ac5383c9fde9be23f805083cf6821c2de745dfeeeab57b"

URI_aarch64_rust-lv2+lv2-midi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+lv2-midi-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+lv2-midi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+lv2-midi-devel}"
SRC_URI[aarch64_rust-lv2+lv2-midi-devel.sha256sum] = "3c585e281cd4974d34fd58b35701e4490030e85c10c55e9cf6e4ccbcb695e362"

URI_aarch64_rust-lv2+lv2-state-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+lv2-state-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+lv2-state-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+lv2-state-devel}"
SRC_URI[aarch64_rust-lv2+lv2-state-devel.sha256sum] = "86fa5da10d134133f1a0aa8e9df24b8f8173df87906a2f60cec63c721d25723e"

URI_aarch64_rust-lv2+lv2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+lv2-sys-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+lv2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+lv2-sys-devel}"
SRC_URI[aarch64_rust-lv2+lv2-sys-devel.sha256sum] = "7d8a6702846ce791aeb2d01a624366e7a4cc191d49d300803852f3ba4a5eea22"

URI_aarch64_rust-lv2+lv2-time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+lv2-time-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+lv2-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+lv2-time-devel}"
SRC_URI[aarch64_rust-lv2+lv2-time-devel.sha256sum] = "f9c4f6011736535cc6b05f6086930e9907ab6510df5ccef8ab898af8e63c4fc1"

URI_aarch64_rust-lv2+lv2-units-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+lv2-units-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+lv2-units-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+lv2-units-devel}"
SRC_URI[aarch64_rust-lv2+lv2-units-devel.sha256sum] = "bb562301e54c23c215acacb8e0ca4df3a093f00882ea2ba391630cc912252ac8"

URI_aarch64_rust-lv2+lv2-urid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+lv2-urid-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+lv2-urid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+lv2-urid-devel}"
SRC_URI[aarch64_rust-lv2+lv2-urid-devel.sha256sum] = "be371c86bbb0c08fcc88c0c6d4705ae0735ff2e5c7ae48f84066e81da34e8948"

URI_aarch64_rust-lv2+lv2-worker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+lv2-worker-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+lv2-worker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+lv2-worker-devel}"
SRC_URI[aarch64_rust-lv2+lv2-worker-devel.sha256sum] = "e4965c255fc235a4f88eb20504fe0e4858c247cf2c5d86ea03dd7be3dc0e0067"

URI_aarch64_rust-lv2+minimal_plugin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+minimal_plugin-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+minimal_plugin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+minimal_plugin-devel}"
SRC_URI[aarch64_rust-lv2+minimal_plugin-devel.sha256sum] = "403cb64c9a272f6cfc31ea639c101ceff9b9a76ad31e387a23acbb37aa30d1cb"

URI_aarch64_rust-lv2+plugin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+plugin-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+plugin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+plugin-devel}"
SRC_URI[aarch64_rust-lv2+plugin-devel.sha256sum] = "5cfc841bc28275b93ae02047899d548177a0951413fbf6f1d93ae8e7d1ed070f"

URI_aarch64_rust-lv2+urid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+urid-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+urid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+urid-devel}"
SRC_URI[aarch64_rust-lv2+urid-devel.sha256sum] = "97c78c4dfc626746926b21104b41182c55a51cf14b5299ca5bd2ed3083ebcfec"

URI_aarch64_rust-lv2+wmidi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2+wmidi-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2+wmidi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2+wmidi-devel}"
SRC_URI[aarch64_rust-lv2+wmidi-devel.sha256sum] = "3fea1875e2dbd4b09c40e9fc8705a71710a3ac9828ef691cafa8933593d87010"

URI_aarch64_rust-lv2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-devel}"
SRC_URI[aarch64_rust-lv2-devel.sha256sum] = "710c440c34597a51b46f5273e5394a1a0e17f648bcdf0d275d4d2f576ca3c554"

RDEPENDS:rust-lv2+default-devel = " \
 cargo \
 rust-lv2+plugin-devel \
 rust-lv2-devel \
 "
RDEPENDS:rust-lv2+full-devel = " \
 cargo \
 rust-lv2+lv2-atom-devel \
 rust-lv2+lv2-core-devel \
 rust-lv2+lv2-midi-devel \
 rust-lv2+lv2-state-devel \
 rust-lv2+lv2-sys-devel \
 rust-lv2+lv2-time-devel \
 rust-lv2+lv2-units-devel \
 rust-lv2+lv2-urid-devel \
 rust-lv2+lv2-worker-devel \
 rust-lv2+urid-devel \
 rust-lv2-devel \
 "
RDEPENDS:rust-lv2+lv2-atom-devel = " \
 cargo \
 rust-lv2-atom+default-devel \
 rust-lv2-devel \
 "
RDEPENDS:rust-lv2+lv2-core-devel = " \
 cargo \
 rust-lv2-core+default-devel \
 rust-lv2-devel \
 "
RDEPENDS:rust-lv2+lv2-midi-devel = " \
 cargo \
 rust-lv2-devel \
 rust-lv2-midi+default-devel \
 "
RDEPENDS:rust-lv2+lv2-state-devel = " \
 cargo \
 rust-lv2-devel \
 rust-lv2-state+default-devel \
 "
RDEPENDS:rust-lv2+lv2-sys-devel = " \
 cargo \
 rust-lv2-devel \
 rust-lv2-sys+default-devel \
 "
RDEPENDS:rust-lv2+lv2-time-devel = " \
 cargo \
 rust-lv2-devel \
 rust-lv2-time+default-devel \
 "
RDEPENDS:rust-lv2+lv2-units-devel = " \
 cargo \
 rust-lv2-devel \
 rust-lv2-units+default-devel \
 "
RDEPENDS:rust-lv2+lv2-urid-devel = " \
 cargo \
 rust-lv2-devel \
 rust-lv2-urid+default-devel \
 "
RDEPENDS:rust-lv2+lv2-worker-devel = " \
 cargo \
 rust-lv2-devel \
 rust-lv2-worker+default-devel \
 "
RDEPENDS:rust-lv2+minimal_plugin-devel = " \
 cargo \
 rust-lv2+lv2-core-devel \
 rust-lv2+urid-devel \
 rust-lv2-devel \
 "
RDEPENDS:rust-lv2+plugin-devel = " \
 cargo \
 rust-lv2+lv2-atom-devel \
 rust-lv2+lv2-midi-devel \
 rust-lv2+lv2-units-devel \
 rust-lv2+lv2-urid-devel \
 rust-lv2+minimal_plugin-devel \
 rust-lv2+wmidi-devel \
 rust-lv2-devel \
 "
RDEPENDS:rust-lv2+urid-devel = " \
 cargo \
 rust-lv2-devel \
 rust-urid+default-devel \
 "
RDEPENDS:rust-lv2+wmidi-devel = " \
 cargo \
 rust-lv2+lv2-midi-devel \
 rust-lv2-devel \
 rust-lv2-midi+default-devel \
 rust-lv2-midi+wmidi-devel \
 "
RDEPENDS:rust-lv2-devel = " \
 bash \
 cargo \
 python3 \
 "
