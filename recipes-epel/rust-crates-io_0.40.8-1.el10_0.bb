# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crates-io"
PV = "0.40.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-crates-io+default-devel \
 rust-crates-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crates-io-0.40.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c0fbeb6ef4d61d19dedf3f7488238a962c13aa7f4a87d06e7646621425d5075"

URI_x86_64_v2_rust-crates-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crates-io+default-devel-0.40.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crates-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crates-io+default-devel}"
SRC_URI[x86_64_v2_rust-crates-io+default-devel.sha256sum] = "3f9dca640d06aa4ed19d52a732d4981d80f3349238d461ae0cbb08dd5e6b2ecb"

URI_x86_64_v2_rust-crates-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crates-io-devel-0.40.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crates-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crates-io-devel}"
SRC_URI[x86_64_v2_rust-crates-io-devel.sha256sum] = "159d81500eb8c39804c833d14daa19e8745bfb8e26fff67c71b371efb109cc67"

URI_aarch64_rust-crates-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crates-io+default-devel-0.40.8-1.el10_0.noarch.rpm;name=aarch64_rust-crates-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crates-io+default-devel}"
SRC_URI[aarch64_rust-crates-io+default-devel.sha256sum] = "774dd7a88f23b336926a3da637d543123d0d5f01ab127419fae411d5ae70cc22"

URI_aarch64_rust-crates-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crates-io-devel-0.40.8-1.el10_0.noarch.rpm;name=aarch64_rust-crates-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crates-io-devel}"
SRC_URI[aarch64_rust-crates-io-devel.sha256sum] = "0bbbdd92dbde051aeafbd7477bbbad1bd59512bc41ff3994e281027b0d44ecce"

RDEPENDS:rust-crates-io+default-devel = " \
 cargo \
 rust-crates-io-devel \
 "
RDEPENDS:rust-crates-io-devel = " \
 cargo \
 rust \
 rust-curl+default-devel \
 rust-percent-encoding+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror1+default-devel \
 rust-url+default-devel \
 "
