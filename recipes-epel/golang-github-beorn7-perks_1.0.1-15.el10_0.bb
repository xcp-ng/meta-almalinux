# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-beorn7-perks"
PV = "1.0.1"
PR = "15.el10_0"
PACKAGES = " \
 golang-github-beorn7-perks-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-beorn7-perks-1.0.1-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70c622e22b28ed8ba11727f44c1a8bdd0b76b9e9c07b49f599c1569b24b6600b"

URI_x86_64_v2_golang-github-beorn7-perks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-beorn7-perks-devel-1.0.1-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-beorn7-perks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-beorn7-perks-devel}"
SRC_URI[x86_64_v2_golang-github-beorn7-perks-devel.sha256sum] = "c52730c580c3e1b10e171742640ad5219563bea52a948059558cad94269012ff"

URI_aarch64_golang-github-beorn7-perks-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-beorn7-perks-devel-1.0.1-15.el10_0.noarch.rpm;name=aarch64_golang-github-beorn7-perks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-beorn7-perks-devel}"
SRC_URI[aarch64_golang-github-beorn7-perks-devel.sha256sum] = "e8e504e92b370b062ab697481a4ba25f43278c78de2bfe6eb214ec1d8e6d8e66"

RDEPENDS:golang-github-beorn7-perks-devel = " \
 go-filesystem \
 "
