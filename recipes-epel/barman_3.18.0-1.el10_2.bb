# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "barman"
PV = "3.18.0"
PR = "1.el10_2"
PACKAGES = " \
 barman \
 barman-cli \
 python3-barman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/barman-3.18.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb7fa121e047fd9fb3ad57242c495b67570cf476c2cecafca3b3a5942c7d8dad"

URI_x86_64_v2_barman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/barman-3.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_barman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_barman}"
SRC_URI[x86_64_v2_barman.sha256sum] = "f5604047fd02188eed313a19ee6a763209f675a4bbbd46faee736651a15b71a5"

URI_x86_64_v2_barman-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/barman-cli-3.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_barman-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_barman-cli}"
SRC_URI[x86_64_v2_barman-cli.sha256sum] = "3f1a26716edbc3fb785405d1d936450a82f742df1cb4c943c11e417fb8b01828"

URI_x86_64_v2_python3-barman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-barman-3.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-barman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-barman}"
SRC_URI[x86_64_v2_python3-barman.sha256sum] = "8930acb1d4b3c2d4948f2ee35c2c0e388296e4ba63187f1f9cfffba446e95fdf"

URI_aarch64_barman = "${EPEL_MIRROR}/aarch64/Packages/b/barman-3.18.0-1.el10_2.noarch.rpm;name=aarch64_barman;unpack=0"
SRC_URI:append = " ${URI_aarch64_barman}"
SRC_URI[aarch64_barman.sha256sum] = "2c846621c4da87bd8b9ed8abbd985a28e5f809979c405ff9e67146449cd352c9"

URI_aarch64_barman-cli = "${EPEL_MIRROR}/aarch64/Packages/b/barman-cli-3.18.0-1.el10_2.noarch.rpm;name=aarch64_barman-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_barman-cli}"
SRC_URI[aarch64_barman-cli.sha256sum] = "348ae6caf2fe9dc6e3191c4d55ab90e5e3bded78375a645ae9dca58b55b961b8"

URI_aarch64_python3-barman = "${EPEL_MIRROR}/aarch64/Packages/p/python3-barman-3.18.0-1.el10_2.noarch.rpm;name=aarch64_python3-barman;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-barman}"
SRC_URI[aarch64_python3-barman.sha256sum] = "1f496fe9ca14d69869d7d054a2fa3048a097a04206afab958b59c3f4eb30ca41"

RDEPENDS:barman = " \
 bash \
 cronie \
 logrotate \
 python3 \
 python3-argcomplete \
 python3-barman \
 rsync \
 shadow-utils \
 "
RDEPENDS:barman-cli = " \
 python3 \
 python3-barman \
 "
RDEPENDS:python3-barman = " \
 python3 \
 python3-dateutil \
 python3-psycopg2 \
 python3-setuptools \
 "
