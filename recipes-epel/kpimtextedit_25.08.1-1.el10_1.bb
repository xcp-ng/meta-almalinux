# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpimtextedit"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kpimtextedit \
 kpimtextedit-devel \
 kpimtextedit-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpimtextedit-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ec6226454ae013eb0e3602036d03b7170c9bee599bab74e94bc0ff6424a8e35"

URI_x86_64_v2_kpimtextedit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpimtextedit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpimtextedit}"
SRC_URI[x86_64_v2_kpimtextedit.sha256sum] = "f215ca04427d2bf79f8e6b00588c5e5326c17064c8b2aa0e993d4655173ba4de"

URI_x86_64_v2_kpimtextedit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpimtextedit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpimtextedit-devel}"
SRC_URI[x86_64_v2_kpimtextedit-devel.sha256sum] = "f57bf727b5f607b1358cc574303f84d0aca321c8a3fd6bdbecb0376b10fa76c8"

URI_x86_64_v2_kpimtextedit-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kpimtextedit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpimtextedit-doc}"
SRC_URI[x86_64_v2_kpimtextedit-doc.sha256sum] = "41c221b6da37a98a4f19331ee064220d046f8e2320796a668b0207ec20292573"

URI_aarch64_kpimtextedit = "${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kpimtextedit;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpimtextedit}"
SRC_URI[aarch64_kpimtextedit.sha256sum] = "be8f662bce210b59fb45bf34b60589f9531a892d8863c0fc3d61142e74ed9fd3"

URI_aarch64_kpimtextedit-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kpimtextedit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpimtextedit-devel}"
SRC_URI[aarch64_kpimtextedit-devel.sha256sum] = "0e0fab3d493b4babd8debce3bde46a3c8879a5eb285106e3be395ca0c65b9331"

URI_aarch64_kpimtextedit-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kpimtextedit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpimtextedit-doc}"
SRC_URI[aarch64_kpimtextedit-doc.sha256sum] = "cf0f55cf6f0d0c8010741079f33cd4292866675bf4a87cfd631512770a4f773a"

RDEPENDS:kpimtextedit = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kpimtextedit-devel = " \
 cmake-filesystem \
 kf6-ktextwidgets-devel \
 kpimtextedit \
 "
RDEPENDS:kpimtextedit-doc = " \
 "
