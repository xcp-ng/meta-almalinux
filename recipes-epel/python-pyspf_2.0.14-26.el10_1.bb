# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyspf"
PV = "2.0.14"
PR = "26.el10_1"
PACKAGES = " \
 python3-pyspf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyspf-2.0.14-26.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3f707b13ccfcd034f8ca3512ec29527e1a21a6ca6df34bba0dc5cf8226182fa"

URI_x86_64_v2_python3-pyspf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyspf-2.0.14-26.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyspf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyspf}"
SRC_URI[x86_64_v2_python3-pyspf.sha256sum] = "7c5cc332a1d43e8521335728b50f2bd36f049f71a0350f4dcfe77d53dc6780bf"

URI_aarch64_python3-pyspf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyspf-2.0.14-26.el10_1.noarch.rpm;name=aarch64_python3-pyspf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyspf}"
SRC_URI[aarch64_python3-pyspf.sha256sum] = "60c7845114a0e6e42a2fa073e8a66d992dff93938450f921bd06dc6b2d8de100"

RDEPENDS:python3-pyspf = " \
 python3 \
 python3-py3dns \
 "
