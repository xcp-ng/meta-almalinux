# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_shuf"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_shuf+default-devel \
 rust-uu_shuf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_shuf-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9ac7a4546c6651905fdbadd538490bd392f55af8476d4eb36efdce0737f560f"

URI_x86_64_v2_rust-uu_shuf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_shuf+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_shuf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_shuf+default-devel}"
SRC_URI[x86_64_v2_rust-uu_shuf+default-devel.sha256sum] = "c28a1587a29f2ae0612599d3bfa12f61f1cfaaab61cdb54f9709176f4fdefb7b"

URI_x86_64_v2_rust-uu_shuf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_shuf-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_shuf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_shuf-devel}"
SRC_URI[x86_64_v2_rust-uu_shuf-devel.sha256sum] = "7997728065d27786df7d0ebff74517274fb8494da44b802c8fd5f3db5ece4778"

URI_aarch64_rust-uu_shuf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_shuf+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_shuf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_shuf+default-devel}"
SRC_URI[aarch64_rust-uu_shuf+default-devel.sha256sum] = "a8125ad35f8753fe147095dbff03fde6e8dedaa004689307f34e032e2e58b802"

URI_aarch64_rust-uu_shuf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_shuf-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_shuf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_shuf-devel}"
SRC_URI[aarch64_rust-uu_shuf-devel.sha256sum] = "911d9965ce0ba00858d8b4b865a0c30d7ae7eef516fb24a3124b4fcbfad4a4f7"

RDEPENDS:rust-uu_shuf+default-devel = " \
 cargo \
 rust-uu_shuf-devel \
 "
RDEPENDS:rust-uu_shuf-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-itoa+default-devel \
 rust-rand0.9+default-devel \
 rust-rand0.9+small_rng-devel \
 rust-rand_chacha0.9+default-devel \
 rust-rustc-hash+default-devel \
 rust-sha3+default-devel \
 rust-uucore+default-devel \
 "
