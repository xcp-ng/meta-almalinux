# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ffmpegthumbnailer"
PV = "2.3.0"
PR = "1.el10_2"
PACKAGES = " \
 ffmpegthumbnailer \
 ffmpegthumbnailer-devel \
 ffmpegthumbnailer-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/ffmpegthumbnailer-2.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ebdc960c04f6aa729ffa8feec74349c4e91b3daf7c39b363e98041ff05dbd59"

URI_x86_64_v2_ffmpegthumbnailer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ffmpegthumbnailer-2.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ffmpegthumbnailer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ffmpegthumbnailer}"
SRC_URI[x86_64_v2_ffmpegthumbnailer.sha256sum] = "9dbb8fc92e381dd5b983389dbd79ffcc2dfaa657ec9bdf176015e2128d096d61"

URI_x86_64_v2_ffmpegthumbnailer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ffmpegthumbnailer-devel-2.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ffmpegthumbnailer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ffmpegthumbnailer-devel}"
SRC_URI[x86_64_v2_ffmpegthumbnailer-devel.sha256sum] = "14771c2b9f61aadb5152eb9c4de697a9af7825d1ddd6283f47d91c34caada11e"

URI_x86_64_v2_ffmpegthumbnailer-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ffmpegthumbnailer-libs-2.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ffmpegthumbnailer-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ffmpegthumbnailer-libs}"
SRC_URI[x86_64_v2_ffmpegthumbnailer-libs.sha256sum] = "7378b8cc29f7e8f3b542188a76415daffcc624ce9a4a34d2984b71c173d9a654"

URI_aarch64_ffmpegthumbnailer = "${EPEL_MIRROR}/aarch64/Packages/f/ffmpegthumbnailer-2.3.0-1.el10_2.aarch64.rpm;name=aarch64_ffmpegthumbnailer;unpack=0"
SRC_URI:append = " ${URI_aarch64_ffmpegthumbnailer}"
SRC_URI[aarch64_ffmpegthumbnailer.sha256sum] = "143e30a3da89e3a5f04ee18062f440c9b09774a028aeabc1dce53681f3b89820"

URI_aarch64_ffmpegthumbnailer-devel = "${EPEL_MIRROR}/aarch64/Packages/f/ffmpegthumbnailer-devel-2.3.0-1.el10_2.aarch64.rpm;name=aarch64_ffmpegthumbnailer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ffmpegthumbnailer-devel}"
SRC_URI[aarch64_ffmpegthumbnailer-devel.sha256sum] = "402c5848ed452b6677cd26a0fe8fd5476c8357f48e9e9bf78779660453c85f75"

URI_aarch64_ffmpegthumbnailer-libs = "${EPEL_MIRROR}/aarch64/Packages/f/ffmpegthumbnailer-libs-2.3.0-1.el10_2.aarch64.rpm;name=aarch64_ffmpegthumbnailer-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ffmpegthumbnailer-libs}"
SRC_URI[aarch64_ffmpegthumbnailer-libs.sha256sum] = "abd015b6fa281e4ef5594d65ada7ba109fb1563643773e28ba233fcd5b645993"

RDEPENDS:ffmpegthumbnailer = " \
 ffmpegthumbnailer-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:ffmpegthumbnailer-devel = " \
 ffmpegthumbnailer-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:ffmpegthumbnailer-libs = " \
 glibc \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 "
