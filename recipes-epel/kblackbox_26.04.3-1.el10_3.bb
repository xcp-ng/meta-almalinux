# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kblackbox"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kblackbox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kblackbox-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e43a9e00dd4793ce326f94a5d6a1e4b0275abd76414a030ca735c87805ea001"

URI_x86_64_v2_kblackbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kblackbox-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kblackbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kblackbox}"
SRC_URI[x86_64_v2_kblackbox.sha256sum] = "8e7a342bf5f0777464a55af93ffeeacb5b656b54e05ab07b720baace9c10cd33"

URI_aarch64_kblackbox = "${EPEL_MIRROR}/aarch64/Packages/k/kblackbox-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kblackbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_kblackbox}"
SRC_URI[aarch64_kblackbox.sha256sum] = "75d65d3599a9632a8920e071372ba5739a1114f8d3bd255e7e273c00201ecf64"

RDEPENDS:kblackbox = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
