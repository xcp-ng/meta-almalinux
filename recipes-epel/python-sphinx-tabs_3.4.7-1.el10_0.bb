# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-tabs"
PV = "3.4.7"
PR = "1.el10_0"
PACKAGES = " \
 python3-sphinx-tabs \
 python3-sphinx-tabs-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-tabs-3.4.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c566670dcfc653cd64ac3b174f7176f2e6a7a09365def4809ee98869b581d18d"

URI_x86_64_v2_python3-sphinx-tabs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-tabs-3.4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-tabs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-tabs}"
SRC_URI[x86_64_v2_python3-sphinx-tabs.sha256sum] = "1101a69666fceab0118f7a5cf33a763a771b3bac3653138316e009485e71776a"

URI_x86_64_v2_python3-sphinx-tabs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-tabs-doc-3.4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-tabs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-tabs-doc}"
SRC_URI[x86_64_v2_python3-sphinx-tabs-doc.sha256sum] = "ad4ee48260d7179bd67a56ca32631a423e455d4151b846c04353030078ae6ca8"

URI_aarch64_python3-sphinx-tabs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-tabs-3.4.7-1.el10_0.noarch.rpm;name=aarch64_python3-sphinx-tabs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-tabs}"
SRC_URI[aarch64_python3-sphinx-tabs.sha256sum] = "de5e6e0e8b7e32c4254e271f6d14ab40ab73cbe6bf13d5112e8e228d02dcd354"

URI_aarch64_python3-sphinx-tabs-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-tabs-doc-3.4.7-1.el10_0.noarch.rpm;name=aarch64_python3-sphinx-tabs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-tabs-doc}"
SRC_URI[aarch64_python3-sphinx-tabs-doc.sha256sum] = "3387ab34d4f11ba3802c4a2805be23980d803d612405ec740c907cee773a80f5"

RDEPENDS:python3-sphinx-tabs = " \
 python3 \
 python3-docutils \
 python3-pygments \
 python3-sphinx \
 "
RDEPENDS:python3-sphinx-tabs-doc = " \
 python3-sphinx-tabs \
 "
