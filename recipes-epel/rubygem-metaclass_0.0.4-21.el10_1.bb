# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-metaclass"
PV = "0.0.4"
PR = "21.el10_1"
PACKAGES = " \
 rubygem-metaclass \
 rubygem-metaclass-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-metaclass-0.0.4-21.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5b3b716fadda1c33fb6ce0d1532d56588d3d6756092b86df9caf85606d247f4"

URI_x86_64_v2_rubygem-metaclass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-metaclass-0.0.4-21.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-metaclass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-metaclass}"
SRC_URI[x86_64_v2_rubygem-metaclass.sha256sum] = "91e68b4a90fa84f57f29c02932fe79729d0c474666b7fd2574865022f29442a4"

URI_x86_64_v2_rubygem-metaclass-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-metaclass-doc-0.0.4-21.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-metaclass-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-metaclass-doc}"
SRC_URI[x86_64_v2_rubygem-metaclass-doc.sha256sum] = "a98b4d19db5ad01312c149650d6eeb607a9ba21641a52979b5b7906a60d9c0e4"

URI_aarch64_rubygem-metaclass = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-metaclass-0.0.4-21.el10_1.noarch.rpm;name=aarch64_rubygem-metaclass;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-metaclass}"
SRC_URI[aarch64_rubygem-metaclass.sha256sum] = "a112fc2ba392575826d5ead1077bc611d07b6de92a96f6696a24ac1f40f6a7e5"

URI_aarch64_rubygem-metaclass-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-metaclass-doc-0.0.4-21.el10_1.noarch.rpm;name=aarch64_rubygem-metaclass-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-metaclass-doc}"
SRC_URI[aarch64_rubygem-metaclass-doc.sha256sum] = "6cbdb56e32a2fea02fe69d453459803a440bd346cf2e4ea682f96d3b9a1f480d"

RDEPENDS:rubygem-metaclass = " \
 rubygems \
 "
RDEPENDS:rubygem-metaclass-doc = " \
 rubygem-metaclass \
 "
