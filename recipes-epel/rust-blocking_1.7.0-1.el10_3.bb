# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blocking"
PV = "1.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-blocking+default-devel \
 rust-blocking+tracing-devel \
 rust-blocking-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-blocking-1.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6c31d2f69a0170debafd49dd916472df267b5268f8ca78cb1ae7b5ac9b573c7a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blocking+default-devel-1.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blocking+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blocking+default-devel.sha256sum] = "b60e981c0155a0ebeb4bbb3cb858a56c8ec535f5f484459d9a45b60cb5008085"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blocking+tracing-devel-1.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blocking+tracing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blocking+tracing-devel.sha256sum] = "30fd32a04ff786f7c6500effd7a851ac5e9866251896faa1e9f7d516281b1884"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blocking-devel-1.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blocking-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blocking-devel.sha256sum] = "92980a7291848b076800d372c276d80e881ba14739bfaf616a4184fc495b3d96"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blocking+default-devel-1.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-blocking+default-devel;unpack=0"
SRC_URI[aarch64_rust-blocking+default-devel.sha256sum] = "64dfb89545d01d1c213d201c36ee488fc51b1943e7545a4bb5c25101873c1ae2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blocking+tracing-devel-1.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-blocking+tracing-devel;unpack=0"
SRC_URI[aarch64_rust-blocking+tracing-devel.sha256sum] = "b150d84c999b7b1ee49510f41e29776d1377cec61b960a82bc7ff7d1a156fc53"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blocking-devel-1.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-blocking-devel;unpack=0"
SRC_URI[aarch64_rust-blocking-devel.sha256sum] = "16ec097333d791032006518459f412252b092018a64dfeb23a2c83dcf4e03a0a"

RDEPENDS:rust-blocking+default-devel = " \
 cargo \
 rust-blocking-devel \
 "
RDEPENDS:rust-blocking+tracing-devel = " \
 cargo \
 rust-blocking-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-blocking-devel = " \
 cargo \
 rust \
 rust-async-channel+default-devel \
 rust-async-task+default-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-lite-devel \
 rust-piper+default-devel \
 "
