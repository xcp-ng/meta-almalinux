# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-ia"
PV = "0.20050628"
PR = "30.el10"
PACKAGES = " \
 hyphen-ia \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-ia-0.20050628-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7de90de557b4e1d3c755c318a401b28c53c6b2c99d2633fb379d5860abdd2f8b"

URI_x86_64_v2_hyphen-ia = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-ia-0.20050628-30.el10.noarch.rpm;name=x86_64_v2_hyphen-ia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-ia}"
SRC_URI[x86_64_v2_hyphen-ia.sha256sum] = "a145e66de9992e95ef035023dc001b97c7cc3c43571977cf53c33c3cb829801f"

URI_aarch64_hyphen-ia = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-ia-0.20050628-30.el10.noarch.rpm;name=aarch64_hyphen-ia;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-ia}"
SRC_URI[aarch64_hyphen-ia.sha256sum] = "a145e66de9992e95ef035023dc001b97c7cc3c43571977cf53c33c3cb829801f"

RDEPENDS:hyphen-ia = " \
 hyphen \
 "
