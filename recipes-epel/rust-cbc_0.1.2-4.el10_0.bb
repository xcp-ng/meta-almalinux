# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cbc"
PV = "0.1.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-cbc+alloc-devel \
 rust-cbc+block-padding-devel \
 rust-cbc+default-devel \
 rust-cbc+std-devel \
 rust-cbc+zeroize-devel \
 rust-cbc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cbc-0.1.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a52d8f5494459f633aecd7c92854adc97c7f716ed0870c3123cd31aeb2b43f5a"

URI_x86_64_v2_rust-cbc+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc+alloc-devel-0.1.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc+alloc-devel}"
SRC_URI[x86_64_v2_rust-cbc+alloc-devel.sha256sum] = "c9b23f90a2a543eb17fa65642eea0c2a05dca6b9684de989a85e8cc6b2bd7551"

URI_x86_64_v2_rust-cbc+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc+block-padding-devel-0.1.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc+block-padding-devel}"
SRC_URI[x86_64_v2_rust-cbc+block-padding-devel.sha256sum] = "4c51e254e4f70faa6560e7be68e2e09dc442606cfef9bfaa8cac9e481a1a99ee"

URI_x86_64_v2_rust-cbc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc+default-devel-0.1.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc+default-devel}"
SRC_URI[x86_64_v2_rust-cbc+default-devel.sha256sum] = "43cca27ecaeae196dd60a200c4d30f1795881fcc2882ba658ab002b2264f2ecf"

URI_x86_64_v2_rust-cbc+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc+std-devel-0.1.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc+std-devel}"
SRC_URI[x86_64_v2_rust-cbc+std-devel.sha256sum] = "d729302f0af5ac6d299b83ca0b6f08d15f78562a2f39c6573c803a7459f8c71c"

URI_x86_64_v2_rust-cbc+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc+zeroize-devel-0.1.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc+zeroize-devel}"
SRC_URI[x86_64_v2_rust-cbc+zeroize-devel.sha256sum] = "323ac41f90af66ebc77ebc5aa9ce01b950da3f1649f0328093215798b62938c6"

URI_x86_64_v2_rust-cbc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc-devel-0.1.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc-devel}"
SRC_URI[x86_64_v2_rust-cbc-devel.sha256sum] = "e2b03a5b4c21dfc5a3b4e4b07c772c412e90faa002d22bcbbf478f2992c99326"

URI_aarch64_rust-cbc+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc+alloc-devel-0.1.2-4.el10_0.noarch.rpm;name=aarch64_rust-cbc+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc+alloc-devel}"
SRC_URI[aarch64_rust-cbc+alloc-devel.sha256sum] = "1b3e091b4924aff198c92d8bdfe401246a8c573b9e45e52274226477e749dd15"

URI_aarch64_rust-cbc+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc+block-padding-devel-0.1.2-4.el10_0.noarch.rpm;name=aarch64_rust-cbc+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc+block-padding-devel}"
SRC_URI[aarch64_rust-cbc+block-padding-devel.sha256sum] = "5fd530e7ec3ea24af864c99e0a842b79beda7b2cb7579ffde1413548376f1d96"

URI_aarch64_rust-cbc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc+default-devel-0.1.2-4.el10_0.noarch.rpm;name=aarch64_rust-cbc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc+default-devel}"
SRC_URI[aarch64_rust-cbc+default-devel.sha256sum] = "394098b25d8225b0241f065933378aa7c06ceafc248522ae5e8880d6402b11a4"

URI_aarch64_rust-cbc+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc+std-devel-0.1.2-4.el10_0.noarch.rpm;name=aarch64_rust-cbc+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc+std-devel}"
SRC_URI[aarch64_rust-cbc+std-devel.sha256sum] = "b62d4cf4beb45a88bdee55503d8eaae057f6b95519a4c2d2e4cb5d6383230888"

URI_aarch64_rust-cbc+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc+zeroize-devel-0.1.2-4.el10_0.noarch.rpm;name=aarch64_rust-cbc+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc+zeroize-devel}"
SRC_URI[aarch64_rust-cbc+zeroize-devel.sha256sum] = "aba4f8bc929db9b74ff3b3eb70e4f2c0578de9f8b7a2dddb9b09c2d49d350153"

URI_aarch64_rust-cbc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc-devel-0.1.2-4.el10_0.noarch.rpm;name=aarch64_rust-cbc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc-devel}"
SRC_URI[aarch64_rust-cbc-devel.sha256sum] = "d7f365c2adfe27ce0ea0f33f177ba3d1d4b50bb6b1305f9422cb5879d0bd8987"

RDEPENDS:rust-cbc+alloc-devel = " \
 cargo \
 rust-cbc-devel \
 rust-cipher0.4+alloc-devel \
 "
RDEPENDS:rust-cbc+block-padding-devel = " \
 cargo \
 rust-cbc-devel \
 rust-cipher0.4+block-padding-devel \
 "
RDEPENDS:rust-cbc+default-devel = " \
 cargo \
 rust-cbc+block-padding-devel \
 rust-cbc-devel \
 "
RDEPENDS:rust-cbc+std-devel = " \
 cargo \
 rust-cbc+alloc-devel \
 rust-cbc-devel \
 rust-cipher0.4+std-devel \
 "
RDEPENDS:rust-cbc+zeroize-devel = " \
 cargo \
 rust-cbc-devel \
 rust-cipher0.4+zeroize-devel \
 "
RDEPENDS:rust-cbc-devel = " \
 cargo \
 rust \
 rust-cipher0.4+default-devel \
 "
