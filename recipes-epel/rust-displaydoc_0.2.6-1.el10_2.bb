# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-displaydoc"
PV = "0.2.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-displaydoc+default-devel \
 rust-displaydoc+std-devel \
 rust-displaydoc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-displaydoc-0.2.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88f5a789b9f23982f04e29ad9fec5772ce39cb6ec2c165294caec8a6797800c3"

URI_x86_64_v2_rust-displaydoc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-displaydoc+default-devel-0.2.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-displaydoc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-displaydoc+default-devel}"
SRC_URI[x86_64_v2_rust-displaydoc+default-devel.sha256sum] = "374682e2a6b7f276fe1ed27f265bfa2fca2870f3fec970236295e2151ecc2aaf"

URI_x86_64_v2_rust-displaydoc+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-displaydoc+std-devel-0.2.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-displaydoc+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-displaydoc+std-devel}"
SRC_URI[x86_64_v2_rust-displaydoc+std-devel.sha256sum] = "8aadf82dcc3d60aca518615259ccbe23fb200075302cd81c84ad41e5812b9c76"

URI_x86_64_v2_rust-displaydoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-displaydoc-devel-0.2.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-displaydoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-displaydoc-devel}"
SRC_URI[x86_64_v2_rust-displaydoc-devel.sha256sum] = "f69a8c43931526e90c56a1d8f302c41419e610e3197df273a038b6c519fcb908"

URI_aarch64_rust-displaydoc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-displaydoc+default-devel-0.2.6-1.el10_2.noarch.rpm;name=aarch64_rust-displaydoc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-displaydoc+default-devel}"
SRC_URI[aarch64_rust-displaydoc+default-devel.sha256sum] = "b38c7dca13b6b0ed12aeb3a898fc2568f9593f39ff20b464b2be082e273e2928"

URI_aarch64_rust-displaydoc+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-displaydoc+std-devel-0.2.6-1.el10_2.noarch.rpm;name=aarch64_rust-displaydoc+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-displaydoc+std-devel}"
SRC_URI[aarch64_rust-displaydoc+std-devel.sha256sum] = "0a358e21882c1917935f93d75fa7fae9ac0645e80817ac88b334293f57203cbb"

URI_aarch64_rust-displaydoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-displaydoc-devel-0.2.6-1.el10_2.noarch.rpm;name=aarch64_rust-displaydoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-displaydoc-devel}"
SRC_URI[aarch64_rust-displaydoc-devel.sha256sum] = "2cdcdbbff2647596b50164eebb97f95ce6960cd19a2e7fb22d6b76b5ded2af3d"

RDEPENDS:rust-displaydoc+default-devel = " \
 cargo \
 rust-displaydoc+std-devel \
 rust-displaydoc-devel \
 "
RDEPENDS:rust-displaydoc+std-devel = " \
 cargo \
 rust-displaydoc-devel \
 "
RDEPENDS:rust-displaydoc-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
