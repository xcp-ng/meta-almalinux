# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-google-genproto"
PV = "0"
PR = "30.20240805gitef581f9.el10_0~bootstrap"
PACKAGES = " \
 golang-google-genproto-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-google-genproto-0-30.20240805gitef581f9.el10_0~bootstrap.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "299e1a7a48cb295f96abc1308cc735abe0b6cae27b2d458a49ebecafd6c29cca"

URI_aarch64_golang-google-genproto-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-google-genproto-devel-0-30.20240805gitef581f9.el10_0~bootstrap.noarch.rpm;name=aarch64_golang-google-genproto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-google-genproto-devel}"
SRC_URI[aarch64_golang-google-genproto-devel.sha256sum] = "db6ed793ef8254978d907911f764ea40739071390aff362fe06689928fb47440"

RDEPENDS:golang-google-genproto-devel = " \
 go-filesystem \
 "
