# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-iri-string"
PV = "0.7.13"
PR = "1.el10_2"
PACKAGES = " \
 rust-iri-string+alloc-devel \
 rust-iri-string+default-devel \
 rust-iri-string+memchr-devel \
 rust-iri-string+serde-devel \
 rust-iri-string+std-devel \
 rust-iri-string-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-iri-string-0.7.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b95c90e339dfdb4b93700f8935a3fa4dd13ffa07845d46a113a23bb24fc22b2"

URI_x86_64_v2_rust-iri-string+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+alloc-devel-0.7.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+alloc-devel}"
SRC_URI[x86_64_v2_rust-iri-string+alloc-devel.sha256sum] = "c47a43dccacce46fdfe41659bf501f50e83ae6ed1965be4a4ee0a0a9f545f668"

URI_x86_64_v2_rust-iri-string+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+default-devel-0.7.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+default-devel}"
SRC_URI[x86_64_v2_rust-iri-string+default-devel.sha256sum] = "f1584d34b6ac85cf230e42feb71d9f977d62a0fe278f815dd805d08534e0e3a6"

URI_x86_64_v2_rust-iri-string+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+memchr-devel-0.7.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+memchr-devel}"
SRC_URI[x86_64_v2_rust-iri-string+memchr-devel.sha256sum] = "7084d858f9a7d5cd58d18c19a1e6b84d6c1df9e9d9a2a8dddb054eaaa34d3d49"

URI_x86_64_v2_rust-iri-string+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+serde-devel-0.7.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+serde-devel}"
SRC_URI[x86_64_v2_rust-iri-string+serde-devel.sha256sum] = "2d48e4861a30ebbfb06410e19f4007de0910125b539f1d50170210ef5894647e"

URI_x86_64_v2_rust-iri-string+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+std-devel-0.7.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+std-devel}"
SRC_URI[x86_64_v2_rust-iri-string+std-devel.sha256sum] = "83c1061f44a85ed97630572f04317d6197c2bf42d839eded94ebf3d202bdee48"

URI_x86_64_v2_rust-iri-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string-devel-0.7.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string-devel}"
SRC_URI[x86_64_v2_rust-iri-string-devel.sha256sum] = "31064cdc1dee46dd9a022218637948a5c1d8f48f15d8cf071a726c4e32181271"

URI_aarch64_rust-iri-string+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+alloc-devel-0.7.13-1.el10_2.noarch.rpm;name=aarch64_rust-iri-string+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+alloc-devel}"
SRC_URI[aarch64_rust-iri-string+alloc-devel.sha256sum] = "13a0ac20a69bfe9bdfc72e49fbce2f1ad22fbc7cd48ba169a0dd391f3d3c0d5a"

URI_aarch64_rust-iri-string+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+default-devel-0.7.13-1.el10_2.noarch.rpm;name=aarch64_rust-iri-string+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+default-devel}"
SRC_URI[aarch64_rust-iri-string+default-devel.sha256sum] = "d71b91f0b297ba49ad59beb02b6e87eb51af72508fd8b87d0b293aea598c3752"

URI_aarch64_rust-iri-string+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+memchr-devel-0.7.13-1.el10_2.noarch.rpm;name=aarch64_rust-iri-string+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+memchr-devel}"
SRC_URI[aarch64_rust-iri-string+memchr-devel.sha256sum] = "ed2553c9f841531ff0cd6b5d6501819fb1f84cb2680d00fbad224b629eeab1e1"

URI_aarch64_rust-iri-string+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+serde-devel-0.7.13-1.el10_2.noarch.rpm;name=aarch64_rust-iri-string+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+serde-devel}"
SRC_URI[aarch64_rust-iri-string+serde-devel.sha256sum] = "4a4cb039990c4830dbb75754e5492a94adb6377e3c91d0502f1486b744fc3b19"

URI_aarch64_rust-iri-string+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+std-devel-0.7.13-1.el10_2.noarch.rpm;name=aarch64_rust-iri-string+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+std-devel}"
SRC_URI[aarch64_rust-iri-string+std-devel.sha256sum] = "3a28b6d2a9bddc65c557eb300bbf115c73943fcf7031a8a027363da19a3fa787"

URI_aarch64_rust-iri-string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string-devel-0.7.13-1.el10_2.noarch.rpm;name=aarch64_rust-iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string-devel}"
SRC_URI[aarch64_rust-iri-string-devel.sha256sum] = "d23b9ae4e062ff154b5acf033e4937869b0b81fd4c6a77f5d43e83b098875de4"

RDEPENDS:rust-iri-string+alloc-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string+default-devel = " \
 cargo \
 rust-iri-string+std-devel \
 rust-iri-string-devel \
 "
RDEPENDS:rust-iri-string+memchr-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-iri-string+serde-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string+std-devel = " \
 cargo \
 rust-iri-string+alloc-devel \
 rust-iri-string-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string-devel = " \
 cargo \
 rust \
 "
