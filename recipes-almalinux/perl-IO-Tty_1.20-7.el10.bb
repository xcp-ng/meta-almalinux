# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Tty"
PV = "1.20"
PR = "7.el10"
PACKAGES = " \
 perl-IO-Tty \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-IO-Tty-1.20-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62f1834428517b05644bcf6e249b2babcf74623b6e2df183e567a04ab464e416"

URI_x86_64_v2_perl-IO-Tty = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-IO-Tty-1.20-7.el10.x86_64_v2.rpm;name=x86_64_v2_perl-IO-Tty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Tty}"
SRC_URI[x86_64_v2_perl-IO-Tty.sha256sum] = "084b95874a0c36b2538ac50df1a53a88f3b87b164c9d696f2ed542c291cea6ce"

URI_aarch64_perl-IO-Tty = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-IO-Tty-1.20-7.el10.aarch64.rpm;name=aarch64_perl-IO-Tty;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Tty}"
SRC_URI[aarch64_perl-IO-Tty.sha256sum] = "54d27cc13bc5d9db4b96b09693693b65c2a8b8facfc92294ccaaa0dae1f8df0a"

RDEPENDS:perl-IO-Tty = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-IO \
 perl-IO-Tty \
 perl-POSIX \
 perl-libs \
 perl-vars \
 "
