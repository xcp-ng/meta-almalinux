# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nv-codec-headers"
PV = "12.2.72.0"
PR = "1.el10_0"
PACKAGES = " \
 nv-codec-headers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nv-codec-headers-12.2.72.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "479a57aec39f57b95f7a94c9631c0a8216a058cb9671977fec7aab0d9653df2d"

URI_x86_64_v2_nv-codec-headers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nv-codec-headers-12.2.72.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nv-codec-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nv-codec-headers}"
SRC_URI[x86_64_v2_nv-codec-headers.sha256sum] = "85ac798261a992df0e5d99e36dd0eddcd4a53aa198bdf3f801978f36ec4189fa"

URI_aarch64_nv-codec-headers = "${EPEL_MIRROR}/aarch64/Packages/n/nv-codec-headers-12.2.72.0-1.el10_0.noarch.rpm;name=aarch64_nv-codec-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_nv-codec-headers}"
SRC_URI[aarch64_nv-codec-headers.sha256sum] = "957db76bcb9ef551936e01bf05479d76c1ab85e37ffeb68d6e84056253eb22cc"

RDEPENDS:nv-codec-headers = " \
 pkgconf-pkg-config \
 "
