# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plantuml"
PE = "1"
PV = "1.2025.4"
PR = "1.el10_1"
PACKAGES = " \
 plantuml \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plantuml-1.2025.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5759bf2db59eb93e8c22088e88a9b821ef858cafd5c7cf466fc7c0f94c04f68a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plantuml-1.2025.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_plantuml;unpack=0"
SRC_URI[x86_64_v2_plantuml.sha256sum] = "a1ae27e3b3e02355672ca20cb08ed646cf3850d810f1c05247705a4483f7f6c0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plantuml-1.2025.4-1.el10_1.noarch.rpm;name=aarch64_plantuml;unpack=0"
SRC_URI[aarch64_plantuml.sha256sum] = "f9f77864b62cb46eebac23af5bbdbd1d826f296206527230fe49374d3c6f1219"

RDEPENDS:plantuml = " \
 bash \
 graphviz \
 java-21-openjdk \
 javapackages-filesystem \
 javapackages-tools \
 "
