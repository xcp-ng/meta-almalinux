# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cpanel-JSON-XS"
PV = "4.40"
PR = "1.el10_1"
PACKAGES = " \
 perl-Cpanel-JSON-XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cpanel-JSON-XS-4.40-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fbd6c5e6122a7a9b40aa99ab73eaba0f10c070e47c4793ab067c66b344b95d0"

URI_x86_64_v2_perl-Cpanel-JSON-XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cpanel-JSON-XS-4.40-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Cpanel-JSON-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cpanel-JSON-XS}"
SRC_URI[x86_64_v2_perl-Cpanel-JSON-XS.sha256sum] = "b07aa10758889a3bca27d75d2928d1bc76fad57f552bfcf390cca0bf6d7817e5"

URI_aarch64_perl-Cpanel-JSON-XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cpanel-JSON-XS-4.40-1.el10_1.aarch64.rpm;name=aarch64_perl-Cpanel-JSON-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cpanel-JSON-XS}"
SRC_URI[aarch64_perl-Cpanel-JSON-XS.sha256sum] = "3b59c75a8dc64620e71e361476fa639469d1fcdae52f4f61b5ad0b225c20463f"

RDEPENDS:perl-Cpanel-JSON-XS = " \
 glibc \
 perl-Carp \
 perl-Cpanel-JSON-XS \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-overload \
 "
