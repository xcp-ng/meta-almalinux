# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ncview"
PV = "2.1.11"
PR = "1.el10_1"
PACKAGES = " \
 ncview \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ncview-2.1.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc6210d2a7643ebb65d1a81d8d858aba515d221ad8f6fa48d307969117447603"

URI_x86_64_v2_ncview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ncview-2.1.11-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ncview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncview}"
SRC_URI[x86_64_v2_ncview.sha256sum] = "182f8f3bd4ef2ef312197b94d1baf9741131733b0b79c50a348f54f70842b7fb"

URI_aarch64_ncview = "${EPEL_MIRROR}/aarch64/Packages/n/ncview-2.1.11-1.el10_1.aarch64.rpm;name=aarch64_ncview;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncview}"
SRC_URI[aarch64_ncview.sha256sum] = "638aa73238543fc54f47245b2a4b12e4ca94ff6ff8d88502b926e31c96a21c5d"

RDEPENDS:ncview = " \
 expat \
 glibc \
 libICE \
 libSM \
 libX11 \
 libXaw \
 libXt \
 libpng \
 netcdf \
 udunits2 \
 "
