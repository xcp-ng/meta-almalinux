# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Password-zxcvbn"
PV = "1.1.2"
PR = "4.el10_0"
PACKAGES = " \
 perl-Data-Password-zxcvbn \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Password-zxcvbn-1.1.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94dabf440def5c958c3c9d3688f94fcc8299be07d7fef8dc5db60151b6f8a457"

URI_x86_64_v2_perl-Data-Password-zxcvbn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Password-zxcvbn-1.1.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Password-zxcvbn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Password-zxcvbn}"
SRC_URI[x86_64_v2_perl-Data-Password-zxcvbn.sha256sum] = "b8270b7c5937b551ea6ee3c7b30bf39f90e9303d532b99e0f242ec7b900a61ea"

URI_aarch64_perl-Data-Password-zxcvbn = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Password-zxcvbn-1.1.2-4.el10_0.noarch.rpm;name=aarch64_perl-Data-Password-zxcvbn;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Password-zxcvbn}"
SRC_URI[aarch64_perl-Data-Password-zxcvbn.sha256sum] = "52160cefb9872dc3b5378a629c113731c523543fb73c428d0d5e5f771945e042"

RDEPENDS:perl-Data-Password-zxcvbn = " \
 perl-Carp \
 perl-Data-Password-zxcvbn \
 perl-Exporter \
 perl-Getopt-Long \
 perl-List-AllUtils \
 perl-Module-Runtime \
 perl-Moo \
 perl-interpreter \
 perl-libs \
 perl-mro \
 perl-overload \
 "
