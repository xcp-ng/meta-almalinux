# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aardvark-dns"
PE = "2"
PV = "2.0.0"
PR = "1.el10"
PACKAGES = " \
 aardvark-dns \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/aardvark-dns-2.0.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0466500d3ed8308d1af08bed28a3c29bcf733542f025496d96ecf976d8226289"

URI_x86_64_v2_aardvark-dns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aardvark-dns-2.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_aardvark-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aardvark-dns}"
SRC_URI[x86_64_v2_aardvark-dns.sha256sum] = "7c3beae14b0091f3a4fea4e535135692d4cba1191623ce0feaf4bb243384bfb9"

URI_aarch64_aardvark-dns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aardvark-dns-2.0.0-1.el10.aarch64.rpm;name=aarch64_aardvark-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_aardvark-dns}"
SRC_URI[aarch64_aardvark-dns.sha256sum] = "2378755e7d7e206b86dcc535ed8ad58da30f9665158f8f1fcd446151efc62682"

RDEPENDS:aardvark-dns = " \
 glibc \
 libgcc \
 "
