# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Ref-Util-XS"
PV = "0.117"
PR = "18.el10_0"
PACKAGES = " \
 perl-Ref-Util-XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Ref-Util-XS-0.117-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7596557cf3ba26dd910ccf96be233c74b7340eeccb78e46d36822ea3dff7a45e"

URI_x86_64_v2_perl-Ref-Util-XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Ref-Util-XS-0.117-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Ref-Util-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Ref-Util-XS}"
SRC_URI[x86_64_v2_perl-Ref-Util-XS.sha256sum] = "c3d12d49e61d3ba3f2ec0b34dc329c28616a4b6598afbfdd13a787f24a12eb6b"

URI_aarch64_perl-Ref-Util-XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Ref-Util-XS-0.117-18.el10_0.aarch64.rpm;name=aarch64_perl-Ref-Util-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Ref-Util-XS}"
SRC_URI[aarch64_perl-Ref-Util-XS.sha256sum] = "3fec75a9f12c68c2ce257310ded187bdc4ebe66fbb50d522a9457b5cb70d5d95"

RDEPENDS:perl-Ref-Util-XS = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
