# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-bsb-http-chunked"
PV = "0.0.0.4"
PR = "29.el10_0"
PACKAGES = " \
 ghc-bsb-http-chunked \
 ghc-bsb-http-chunked-devel \
 ghc-bsb-http-chunked-doc \
 ghc-bsb-http-chunked-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-bsb-http-chunked-0.0.0.4-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64ddfa797860e40b030a016aec929b67bfd0ec6aef46f1ff42dd159097a01e51"

URI_x86_64_v2_ghc-bsb-http-chunked = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bsb-http-chunked-0.0.0.4-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bsb-http-chunked;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bsb-http-chunked}"
SRC_URI[x86_64_v2_ghc-bsb-http-chunked.sha256sum] = "6401e8d925020d900da2eae0d4b4b033a07ee8a7d6e70233bb7af7c199334d42"

URI_x86_64_v2_ghc-bsb-http-chunked-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bsb-http-chunked-devel-0.0.0.4-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bsb-http-chunked-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bsb-http-chunked-devel}"
SRC_URI[x86_64_v2_ghc-bsb-http-chunked-devel.sha256sum] = "c9fe2bf4ba1a2fe5939dd9c560a849f025107ed123504a36c399f8ecc8ed8186"

URI_x86_64_v2_ghc-bsb-http-chunked-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bsb-http-chunked-doc-0.0.0.4-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-bsb-http-chunked-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bsb-http-chunked-doc}"
SRC_URI[x86_64_v2_ghc-bsb-http-chunked-doc.sha256sum] = "853155cb7f59ea297b21f9c72fc494d892fccb3e6a9f414634945e419b6779fe"

URI_x86_64_v2_ghc-bsb-http-chunked-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bsb-http-chunked-prof-0.0.0.4-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bsb-http-chunked-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bsb-http-chunked-prof}"
SRC_URI[x86_64_v2_ghc-bsb-http-chunked-prof.sha256sum] = "807dc6dcf81b6c92fc825bb682cabffe61a4b8af23fb2ef76e942990c66ea5f7"

URI_aarch64_ghc-bsb-http-chunked = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bsb-http-chunked-0.0.0.4-29.el10_0.aarch64.rpm;name=aarch64_ghc-bsb-http-chunked;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bsb-http-chunked}"
SRC_URI[aarch64_ghc-bsb-http-chunked.sha256sum] = "46303874fd0f7aed3078fc9e657d0056b5cc56e480df7ca3221c7cd28f915563"

URI_aarch64_ghc-bsb-http-chunked-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bsb-http-chunked-devel-0.0.0.4-29.el10_0.aarch64.rpm;name=aarch64_ghc-bsb-http-chunked-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bsb-http-chunked-devel}"
SRC_URI[aarch64_ghc-bsb-http-chunked-devel.sha256sum] = "64814d9f44b53df26690d29ebbf9c352043c8cff8c7898f41c1d2ed7a12e31dd"

URI_aarch64_ghc-bsb-http-chunked-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bsb-http-chunked-doc-0.0.0.4-29.el10_0.noarch.rpm;name=aarch64_ghc-bsb-http-chunked-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bsb-http-chunked-doc}"
SRC_URI[aarch64_ghc-bsb-http-chunked-doc.sha256sum] = "8c0cac5ec6284f33989a66c0599dfd39e62164008ee7b7d941dd3398a4eb287c"

URI_aarch64_ghc-bsb-http-chunked-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bsb-http-chunked-prof-0.0.0.4-29.el10_0.aarch64.rpm;name=aarch64_ghc-bsb-http-chunked-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bsb-http-chunked-prof}"
SRC_URI[aarch64_ghc-bsb-http-chunked-prof.sha256sum] = "299133864e83846c50247c8808bc62eb5183f5c98af05b076a6e17d77b91e569"

RDEPENDS:ghc-bsb-http-chunked = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-bsb-http-chunked-devel = " \
 ghc-base-devel \
 ghc-bsb-http-chunked \
 ghc-bytestring-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-bsb-http-chunked-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-bsb-http-chunked-prof = " \
 ghc-base-prof \
 ghc-bsb-http-chunked-devel \
 ghc-bytestring-prof \
 "
