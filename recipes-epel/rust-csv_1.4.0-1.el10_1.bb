# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-csv"
PV = "1.4.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-csv+default-devel \
 rust-csv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-csv-1.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f36df85cab922ece10a7000a6a0ef2fec7bd24f029a040839d2cc37a48ffb09"

URI_x86_64_v2_rust-csv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv+default-devel-1.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv+default-devel}"
SRC_URI[x86_64_v2_rust-csv+default-devel.sha256sum] = "d4627e7f56d428390d3a97a8faf0ef38c666df394ff85a36845d289f698ec07c"

URI_x86_64_v2_rust-csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv-devel-1.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv-devel}"
SRC_URI[x86_64_v2_rust-csv-devel.sha256sum] = "a1adc93e762e2f52ac5d32dc60c009d152f591ffc6688278b63cefb08322dead"

URI_aarch64_rust-csv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv+default-devel-1.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-csv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv+default-devel}"
SRC_URI[aarch64_rust-csv+default-devel.sha256sum] = "eddffd78c44cbae966ba699254a200fec0e90b3a0fe6e3a7a37a8c15e8836ba8"

URI_aarch64_rust-csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv-devel-1.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv-devel}"
SRC_URI[aarch64_rust-csv-devel.sha256sum] = "8251f84afa9ff756c68a4e1648be6e7618a3ab15bfcddda202e9d5b0d9065880"

RDEPENDS:rust-csv+default-devel = " \
 cargo \
 rust-csv-devel \
 "
RDEPENDS:rust-csv-devel = " \
 cargo \
 rust \
 rust-csv-core+default-devel \
 rust-itoa+default-devel \
 rust-ryu+default-devel \
 rust-serde_core+default-devel \
 "
