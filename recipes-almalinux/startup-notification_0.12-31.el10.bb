# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "startup-notification"
PV = "0.12"
PR = "31.el10"
PACKAGES = " \
 startup-notification \
 startup-notification-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/startup-notification-0.12-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f15cbc6235aad8704bbed604d775ba6eb99aed8f77b1b401192419fc4262ae58"

URI_x86_64_v2_startup-notification = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/startup-notification-0.12-31.el10.x86_64_v2.rpm;name=x86_64_v2_startup-notification;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_startup-notification}"
SRC_URI[x86_64_v2_startup-notification.sha256sum] = "75eb985e6dc20eae5d4ea51a239ec9968270cde395a71202076cd41cd8f0d088"

URI_x86_64_v2_startup-notification-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/startup-notification-devel-0.12-31.el10.x86_64_v2.rpm;name=x86_64_v2_startup-notification-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_startup-notification-devel}"
SRC_URI[x86_64_v2_startup-notification-devel.sha256sum] = "70ed0c4b5478d24b60d78653c35207c491b04b6dcb1ccc98ea68e83ea4476cfc"

URI_aarch64_startup-notification = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/startup-notification-0.12-31.el10.aarch64.rpm;name=aarch64_startup-notification;unpack=0"
SRC_URI:append = " ${URI_aarch64_startup-notification}"
SRC_URI[aarch64_startup-notification.sha256sum] = "161cbce88fafc274f39f1796089ec425f3dc45d4867153c89bb4480c32ee63de"

URI_aarch64_startup-notification-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/startup-notification-devel-0.12-31.el10.aarch64.rpm;name=aarch64_startup-notification-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_startup-notification-devel}"
SRC_URI[aarch64_startup-notification-devel.sha256sum] = "30f62bf4a70f8bd343f9680d9b32e8272c145ba4d11f3a958b595fc762d1cc41"

RDEPENDS:startup-notification = " \
 glibc \
 libX11 \
 libX11-xcb \
 libxcb \
 xcb-util \
 "
RDEPENDS:startup-notification-devel = " \
 libX11-devel \
 pkgconf-pkg-config \
 startup-notification \
 "
