# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-tools"
PV = "1.4.304.0"
PR = "1.el10"
PACKAGES = " \
 vulkan-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-tools-1.4.304.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee95d2378d480ce32e5ddd2f21d039b92fcb99e4c9134e1416bb32b0bebca103"

URI_x86_64_v2_vulkan-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-tools-1.4.304.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-tools}"
SRC_URI[x86_64_v2_vulkan-tools.sha256sum] = "8b9bdc6c46e478faf29757bca85902d4177dff82c2a83e651978263c4f03962a"

URI_aarch64_vulkan-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-tools-1.4.304.0-1.el10.aarch64.rpm;name=aarch64_vulkan-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-tools}"
SRC_URI[aarch64_vulkan-tools.sha256sum] = "3ca67cccbe350d90837f703e9f113e8e03963970f8e285455634b300414e8f3f"

RDEPENDS:vulkan-tools = " \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 "
