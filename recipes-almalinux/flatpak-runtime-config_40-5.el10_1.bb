# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak-runtime-config"
PV = "40"
PR = "5.el10_1"
PACKAGES = " \
 flatpak-runtime-config \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/flatpak-runtime-config-40-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88116bc2bae1dc2a21a6a406565a388c7438e3af495297b4fd05fdba9415d1a0"

URI_x86_64_v2_flatpak-runtime-config = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/flatpak-runtime-config-40-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_flatpak-runtime-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-runtime-config}"
SRC_URI[x86_64_v2_flatpak-runtime-config.sha256sum] = "85903574b800b6d30f18f6b1f5c370fb4ff5da92591c3b643766c57ad227a2b4"

URI_aarch64_flatpak-runtime-config = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/flatpak-runtime-config-40-5.el10_1.aarch64.rpm;name=aarch64_flatpak-runtime-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-runtime-config}"
SRC_URI[aarch64_flatpak-runtime-config.sha256sum] = "0e5082d315c89c496f965900af980244cce72b34c7e631cb70472de81a0bf8b4"

RDEPENDS:flatpak-runtime-config = " \
 bash \
 findutils \
 fonts-filesystem \
 glibc \
 "
