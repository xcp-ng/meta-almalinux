# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "umbrello"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 umbrello \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/umbrello-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f555ec44726adee9063f42273f65a4d1eaf34aa583e14b4043614e72841013e3"

URI_x86_64_v2_umbrello = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/umbrello-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_umbrello;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_umbrello}"
SRC_URI[x86_64_v2_umbrello.sha256sum] = "0070da305ce315f5f3610e98fa5ec336c4fb06f75abbbf445404197fcc284477"

URI_aarch64_umbrello = "${EPEL_MIRROR}/aarch64/Packages/u/umbrello-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_umbrello;unpack=0"
SRC_URI:append = " ${URI_aarch64_umbrello}"
SRC_URI[aarch64_umbrello.sha256sum] = "001b197a741bb744a0838f287bd4b4b625be6dfe2ddc1ea4f22d5a2eebbe6444"

RDEPENDS:umbrello = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 libxml2 \
 libxslt \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
