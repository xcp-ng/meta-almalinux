# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sysinfo"
PV = "0.33.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-sysinfo+c-interface-devel \
 rust-sysinfo+component-devel \
 rust-sysinfo+debug-devel \
 rust-sysinfo+default-devel \
 rust-sysinfo+disk-devel \
 rust-sysinfo+linux-netdevs-devel \
 rust-sysinfo+linux-tmpfs-devel \
 rust-sysinfo+multithread-devel \
 rust-sysinfo+network-devel \
 rust-sysinfo+serde-devel \
 rust-sysinfo+system-devel \
 rust-sysinfo+user-devel \
 rust-sysinfo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sysinfo-0.33.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cd2af7f1566663f40c4b527ab60c9c5e02a811b0ce8f4a234712bdbc2ccd3fe"

URI_x86_64_v2_rust-sysinfo+c-interface-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+c-interface-devel-0.33.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+c-interface-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+c-interface-devel.sha256sum] = "8e96f5ae8a0379d1d5842791007da71e89865386f2b9046190b61d837d1f72ca"

URI_x86_64_v2_rust-sysinfo+component-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+component-devel-0.33.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+component-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+component-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+component-devel.sha256sum] = "11a7c07975a5e3cf9bdfb64cc2eb907740df47f3b371f8aae19034ebb92f4c56"

URI_x86_64_v2_rust-sysinfo+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+debug-devel-0.33.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+debug-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+debug-devel.sha256sum] = "1f2a3763ce095f7845c44747bc14b37a2686067c16455943cf463f89482d10d5"

URI_x86_64_v2_rust-sysinfo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+default-devel-0.33.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+default-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+default-devel.sha256sum] = "c8ee2453b3b40617c3ab63761e0dc59c58b4637862366a336ba9d4be0ddfaaa8"

URI_x86_64_v2_rust-sysinfo+disk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+disk-devel-0.33.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+disk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+disk-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+disk-devel.sha256sum] = "0d0754d5952aa057e97a5183b9e14ca849f596ed2960383a6d078ffcfebd22b4"

URI_x86_64_v2_rust-sysinfo+linux-netdevs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+linux-netdevs-devel-0.33.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+linux-netdevs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+linux-netdevs-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+linux-netdevs-devel.sha256sum] = "a6550942702da3b7e54dfb24c27bf79227ce76221418e278d414a0d72d7270b0"

URI_x86_64_v2_rust-sysinfo+linux-tmpfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+linux-tmpfs-devel-0.33.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+linux-tmpfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+linux-tmpfs-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+linux-tmpfs-devel.sha256sum] = "e83c3a2e327aa3659426315f7be1470d761254ec7c212603dcf96d0e7e9f0d85"

URI_x86_64_v2_rust-sysinfo+multithread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+multithread-devel-0.33.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+multithread-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+multithread-devel.sha256sum] = "4f4ae06accbd8c15e849d721c64d27162dfc55da1bfd328c3c6e77b5b567cd53"

URI_x86_64_v2_rust-sysinfo+network-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+network-devel-0.33.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+network-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+network-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+network-devel.sha256sum] = "daf180ca7666b1b08f36a1219c82c1221adb00c9b2554698b068024ceafc56b3"

URI_x86_64_v2_rust-sysinfo+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+serde-devel-0.33.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+serde-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+serde-devel.sha256sum] = "d6be3007896003e265c25fb9e06084debabbc16f781773e3a1e98e711c035c96"

URI_x86_64_v2_rust-sysinfo+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+system-devel-0.33.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+system-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+system-devel.sha256sum] = "1231e4295a098deebeda9a595b514727afb1e50fdf6b446de3332d77d2f54b2c"

URI_x86_64_v2_rust-sysinfo+user-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+user-devel-0.33.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+user-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+user-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+user-devel.sha256sum] = "c28b7b70cf4483d84aa0ee2128f7560d2d1b981ce2bc920d246eba66b6084819"

URI_x86_64_v2_rust-sysinfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo-devel-0.33.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo-devel}"
SRC_URI[x86_64_v2_rust-sysinfo-devel.sha256sum] = "5e4a4dcedd8e91c72179dccba426351bc35d21c0d86bfb343c371927a5472740"

URI_aarch64_rust-sysinfo+c-interface-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+c-interface-devel-0.33.1-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+c-interface-devel}"
SRC_URI[aarch64_rust-sysinfo+c-interface-devel.sha256sum] = "d53ba1707efaf37519d24fb1c756705a2e8573cb6c4a9dd02a730c1555f5e196"

URI_aarch64_rust-sysinfo+component-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+component-devel-0.33.1-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo+component-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+component-devel}"
SRC_URI[aarch64_rust-sysinfo+component-devel.sha256sum] = "4c3f937fddfc8ef59479d76fcaf98b703b241789492a0ac99cae14715b5113db"

URI_aarch64_rust-sysinfo+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+debug-devel-0.33.1-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+debug-devel}"
SRC_URI[aarch64_rust-sysinfo+debug-devel.sha256sum] = "7a0f930f841915d941160dfc0e7569f242bd5916686821ea042aad2a77747502"

URI_aarch64_rust-sysinfo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+default-devel-0.33.1-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+default-devel}"
SRC_URI[aarch64_rust-sysinfo+default-devel.sha256sum] = "bc2509efb2cf93ebe5a7f995700fc026a714b81507830476ef9d71656c8134de"

URI_aarch64_rust-sysinfo+disk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+disk-devel-0.33.1-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo+disk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+disk-devel}"
SRC_URI[aarch64_rust-sysinfo+disk-devel.sha256sum] = "2b26d0fd787dcafcbdeddec774d96a345ba137e5214532ef2005442f7bf67860"

URI_aarch64_rust-sysinfo+linux-netdevs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+linux-netdevs-devel-0.33.1-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo+linux-netdevs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+linux-netdevs-devel}"
SRC_URI[aarch64_rust-sysinfo+linux-netdevs-devel.sha256sum] = "fc2c01a028ff6fd2ee6880d68ab3ebbd4292d1f698d3ba01536935b039c6eacc"

URI_aarch64_rust-sysinfo+linux-tmpfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+linux-tmpfs-devel-0.33.1-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo+linux-tmpfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+linux-tmpfs-devel}"
SRC_URI[aarch64_rust-sysinfo+linux-tmpfs-devel.sha256sum] = "045850ea1a89c4236863c85c4e4c8a8bd8e97e907d6f03a5160c8ed82aba5108"

URI_aarch64_rust-sysinfo+multithread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+multithread-devel-0.33.1-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+multithread-devel}"
SRC_URI[aarch64_rust-sysinfo+multithread-devel.sha256sum] = "62cf8a393340f50361e68acb7cddd9f41830a2c2fcb8d1662d10553b9262d392"

URI_aarch64_rust-sysinfo+network-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+network-devel-0.33.1-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo+network-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+network-devel}"
SRC_URI[aarch64_rust-sysinfo+network-devel.sha256sum] = "592d5df2679f50256daee3ec252462dcf1ae0bcf24c2bbbbc92a200460eca35f"

URI_aarch64_rust-sysinfo+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+serde-devel-0.33.1-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+serde-devel}"
SRC_URI[aarch64_rust-sysinfo+serde-devel.sha256sum] = "72ac4ef5584d38e572cc5332a4be1512444af6ebd430bcc3da356ba0c798e99d"

URI_aarch64_rust-sysinfo+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+system-devel-0.33.1-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+system-devel}"
SRC_URI[aarch64_rust-sysinfo+system-devel.sha256sum] = "5aea3dead1d209d7576ee8079c3b22e2d994ff576a1412f5dcc2e8a2d403e518"

URI_aarch64_rust-sysinfo+user-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+user-devel-0.33.1-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo+user-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+user-devel}"
SRC_URI[aarch64_rust-sysinfo+user-devel.sha256sum] = "f3882f7a0471c56fa0423c40824919ae947cd23f2fcf946b31487e19ba63f703"

URI_aarch64_rust-sysinfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo-devel-0.33.1-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo-devel}"
SRC_URI[aarch64_rust-sysinfo-devel.sha256sum] = "098f2d5fb3271418eba7edc8a5d865606849a41c1a47ae9def7fc1f4f7f60501"

RDEPENDS:rust-sysinfo+c-interface-devel = " \
 cargo \
 rust-sysinfo+default-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+component-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+debug-devel = " \
 cargo \
 rust-libc+extra_traits-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+default-devel = " \
 cargo \
 rust-sysinfo+component-devel \
 rust-sysinfo+disk-devel \
 rust-sysinfo+multithread-devel \
 rust-sysinfo+network-devel \
 rust-sysinfo+system-devel \
 rust-sysinfo+user-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+disk-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+linux-netdevs-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+linux-tmpfs-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+multithread-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+network-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+system-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+user-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
