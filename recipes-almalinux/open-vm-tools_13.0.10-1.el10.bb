# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "open-vm-tools"
PV = "13.0.10"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 open-vm-tools \
 open-vm-tools-desktop \
 open-vm-tools-salt-minion \
 open-vm-tools-sdmp \
 open-vm-tools-test \
"
PACKAGES:aarch64 = " \
 open-vm-tools \
 open-vm-tools-desktop \
 open-vm-tools-test \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/open-vm-tools-13.0.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afb8985ba7e337ccb97ed3f36740b2dd55c7ffaaa3a8827cf56e0ce87d64c275"

URI_x86_64_v2_open-vm-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-13.0.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_open-vm-tools}"
SRC_URI[x86_64_v2_open-vm-tools.sha256sum] = "459406d378fc35e56ab46772e4e1800f1faee6486e18aa2a5ab78fa2ea7680ad"

URI_x86_64_v2_open-vm-tools-desktop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-desktop-13.0.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_open-vm-tools-desktop}"
SRC_URI[x86_64_v2_open-vm-tools-desktop.sha256sum] = "d69d801af3b36ee1048bbeb1acf9937c31c0426ba3f57bbd6102d22dc0520f63"

URI_x86_64_v2_open-vm-tools-salt-minion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-salt-minion-13.0.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools-salt-minion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_open-vm-tools-salt-minion}"
SRC_URI[x86_64_v2_open-vm-tools-salt-minion.sha256sum] = "32d1cded817271bd00ef9eb025277723086d49dc6d4463fece01b2c8e3290480"

URI_x86_64_v2_open-vm-tools-sdmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-sdmp-13.0.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools-sdmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_open-vm-tools-sdmp}"
SRC_URI[x86_64_v2_open-vm-tools-sdmp.sha256sum] = "ee2476fd239ea0aed395b5787f6c0ab8774995b1c7673dbddbb3db8ecacf52dc"

URI_x86_64_v2_open-vm-tools-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-test-13.0.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_open-vm-tools-test}"
SRC_URI[x86_64_v2_open-vm-tools-test.sha256sum] = "5cac1fbc1dbde6ff1f9395d822c17b5c4ca8c1d29a3e207dda02d521c5c72d7f"

URI_aarch64_open-vm-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/open-vm-tools-13.0.10-1.el10.aarch64.rpm;name=aarch64_open-vm-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_open-vm-tools}"
SRC_URI[aarch64_open-vm-tools.sha256sum] = "3b22355ae36bd83cae5f7d77eba9f51e8c21a39acb0d4f2f077157f8bf4abfe3"

URI_aarch64_open-vm-tools-desktop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/open-vm-tools-desktop-13.0.10-1.el10.aarch64.rpm;name=aarch64_open-vm-tools-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_open-vm-tools-desktop}"
SRC_URI[aarch64_open-vm-tools-desktop.sha256sum] = "aec785e1db26e26022ec90ed34ab476d765a7e62e768cbd7a4b8b0e5a449e084"

URI_aarch64_open-vm-tools-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/open-vm-tools-test-13.0.10-1.el10.aarch64.rpm;name=aarch64_open-vm-tools-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_open-vm-tools-test}"
SRC_URI[aarch64_open-vm-tools-test.sha256sum] = "9ceb4fda21d637b713825c94adcfcc3a26f03d7533d35a4966fabab75ba3a277"

RDEPENDS:open-vm-tools:x86_64_v2 = " \
 bash \
 dbus-tools \
 fuse3 \
 fuse3-libs \
 glib2 \
 glibc \
 grep \
 iproute \
 libdrm \
 libgcc \
 libmspack \
 libtirpc \
 libxml2 \
 openssl-libs \
 pciutils \
 sed \
 systemd \
 systemd-libs \
 tar \
 util-linux \
 virtual/coreutils \
 which \
 xmlsec1 \
 xmlsec1-openssl \
"
RDEPENDS:open-vm-tools:aarch64 = " \
 bash \
 dbus-tools \
 fuse3 \
 fuse3-libs \
 glib2 \
 glibc \
 grep \
 iproute \
 libdrm \
 libmspack \
 libtirpc \
 libxml2 \
 openssl-libs \
 pciutils \
 sed \
 systemd \
 systemd-libs \
 tar \
 util-linux \
 virtual/coreutils \
 which \
 xmlsec1 \
 xmlsec1-openssl \
"
RDEPENDS:open-vm-tools-desktop = " \
 atk \
 bash \
 cairo \
 fuse3-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libX11 \
 libXext \
 libXi \
 libXinerama \
 libXrandr \
 libXtst \
 libdrm \
 libgcc \
 libstdc++ \
 libtirpc \
 open-vm-tools \
 pango \
 systemd-libs \
 "
RDEPENDS:open-vm-tools-salt-minion = " \
 bash \
 curl \
 gawk \
 grep \
 open-vm-tools \
 systemd \
 virtual/coreutils \
 "
RDEPENDS:open-vm-tools-sdmp = " \
 bash \
 gawk \
 glib2 \
 glibc \
 glibc-common \
 grep \
 iproute \
 open-vm-tools \
 procps-ng \
 virtual/coreutils \
 "
RDEPENDS:open-vm-tools-test = " \
 glib2 \
 glibc \
 open-vm-tools \
 "
