# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-oracle"
PV = "2.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqsign-oracle+default-devel \
 rust-reqsign-oracle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-oracle-2.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a2e3d68e1d8bcfd566af346bd703a2ac77d3b7937131e205c4fe10c030f6d6e"

URI_x86_64_v2_rust-reqsign-oracle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-oracle+default-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-oracle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-oracle+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-oracle+default-devel.sha256sum] = "01c1b72ddad7f68d1f7b9c51a2ed49cbbf8431e8d3e99baa03bc8ec14e2cf431"

URI_x86_64_v2_rust-reqsign-oracle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-oracle-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-oracle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-oracle-devel}"
SRC_URI[x86_64_v2_rust-reqsign-oracle-devel.sha256sum] = "34aba756d97d06a9b4079880c29422f63bc59e5b61b04b16abbc4790a25429e2"

URI_aarch64_rust-reqsign-oracle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-oracle+default-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-oracle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-oracle+default-devel}"
SRC_URI[aarch64_rust-reqsign-oracle+default-devel.sha256sum] = "7ad40b6f4b8076a260aecb400379d0144a7b94aabce0edd8c54be087f5546e5c"

URI_aarch64_rust-reqsign-oracle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-oracle-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-oracle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-oracle-devel}"
SRC_URI[aarch64_rust-reqsign-oracle-devel.sha256sum] = "40c549cc41efac307733a6489ef8fb374a2b08de3c6d5ca4a9e1f1fe21163553"

RDEPENDS:rust-reqsign-oracle+default-devel = " \
 cargo \
 rust-reqsign-oracle-devel \
 "
RDEPENDS:rust-reqsign-oracle-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-base64+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-reqsign-core+default-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-rust-ini+default-devel \
 "
