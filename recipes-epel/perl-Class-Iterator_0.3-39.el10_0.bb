# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Iterator"
PV = "0.3"
PR = "39.el10_0"
PACKAGES = " \
 perl-Class-Iterator \
 perl-Class-Iterator-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Iterator-0.3-39.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17086bfd1706ac640389070082ed3ebc0f742926398b023e0f1bed3956173012"

URI_x86_64_v2_perl-Class-Iterator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Iterator-0.3-39.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Iterator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Iterator}"
SRC_URI[x86_64_v2_perl-Class-Iterator.sha256sum] = "28a667d134f2eb699e17b4dfcf85b06ab9f03a2ab397f6472e7c277f80c2eeaa"

URI_x86_64_v2_perl-Class-Iterator-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Iterator-tests-0.3-39.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Iterator-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Iterator-tests}"
SRC_URI[x86_64_v2_perl-Class-Iterator-tests.sha256sum] = "9939721d95c7f7715decd65b8e8d9a2a19f5e849f70fb6f0f88e76f18c6c3adb"

URI_aarch64_perl-Class-Iterator = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Iterator-0.3-39.el10_0.noarch.rpm;name=aarch64_perl-Class-Iterator;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Iterator}"
SRC_URI[aarch64_perl-Class-Iterator.sha256sum] = "2a7f1f7015bf634583e9f49ffbe4a8cf6794c8d81b792ec46b67563133b65664"

URI_aarch64_perl-Class-Iterator-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Iterator-tests-0.3-39.el10_0.noarch.rpm;name=aarch64_perl-Class-Iterator-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Iterator-tests}"
SRC_URI[aarch64_perl-Class-Iterator-tests.sha256sum] = "19bb404055306cd4976974ae807ff1afb122f3cee5bb08a7119f8616d5fce7c6"

RDEPENDS:perl-Class-Iterator = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Class-Iterator-tests = " \
 bash \
 perl-Class-Iterator \
 perl-Test-Harness \
 perl-Test-Simple \
 "
