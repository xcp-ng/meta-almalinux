# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyotp"
PV = "2.9.0"
PR = "7.el10_0"
PACKAGES = " \
 python3-pyotp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyotp-2.9.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "358b34b2b92c64ddf757b6adf28e5a74dc4670a0be417ab624e7fee1672cb0ca"

URI_x86_64_v2_python3-pyotp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyotp-2.9.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyotp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyotp}"
SRC_URI[x86_64_v2_python3-pyotp.sha256sum] = "262da0ab47beee51074950fbe4f7776ce3828e094e18b4cbdf7a13edd0b3def8"

URI_aarch64_python3-pyotp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyotp-2.9.0-7.el10_0.noarch.rpm;name=aarch64_python3-pyotp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyotp}"
SRC_URI[aarch64_python3-pyotp.sha256sum] = "e6ee1bd73677646910288495911e4bd4c0f3d1add9331e65b597b7148b38856b"

RDEPENDS:python3-pyotp = " \
 python3 \
 "
