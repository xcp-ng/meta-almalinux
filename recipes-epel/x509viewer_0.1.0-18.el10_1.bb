# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "x509viewer"
PV = "0.1.0"
PR = "18.el10_1"
PACKAGES = " \
 x509viewer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/x509viewer-0.1.0-18.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69eb606079bc2fafedc28e8fef333e2eb2726d6be0fb1fce44709567a88c6f87"

URI_x86_64_v2_x509viewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/x509viewer-0.1.0-18.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_x509viewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_x509viewer}"
SRC_URI[x86_64_v2_x509viewer.sha256sum] = "922e3d9513f1ff9a99407b5fa05b11e3739ef5214952649469507ad43396eaa5"

URI_aarch64_x509viewer = "${EPEL_MIRROR}/aarch64/Packages/x/x509viewer-0.1.0-18.el10_1.noarch.rpm;name=aarch64_x509viewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_x509viewer}"
SRC_URI[aarch64_x509viewer.sha256sum] = "2bccf38d10ada1753bbfc071a3ce64c77c7ed89649f44e4fe5abe0254f50f2fd"

RDEPENDS:x509viewer = " \
 openssl \
 perl-Fcntl \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-interpreter \
 perl-libs \
 "
