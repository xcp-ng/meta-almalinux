# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "composer"
PV = "2.10.2"
PR = "1.el10_3"
PACKAGES = " \
 composer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/composer-2.10.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d55ae3b30414351415ab21f16f70c96b9caecfc0fed487c6eea3a4228524f6dd"

URI_x86_64_v2_composer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/composer-2.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_composer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_composer}"
SRC_URI[x86_64_v2_composer.sha256sum] = "a5ba33594cecb4cf956fb6d5970e9173d0ae99d126dcda2860e017ee91a7fa5b"

URI_aarch64_composer = "${EPEL_MIRROR}/aarch64/Packages/c/composer-2.10.2-1.el10_3.noarch.rpm;name=aarch64_composer;unpack=0"
SRC_URI:append = " ${URI_aarch64_composer}"
SRC_URI[aarch64_composer.sha256sum] = "38aca27b0ba73768ea529b1d723368ff13a551b2a3be7f8960f3af69c24777d9"

RDEPENDS:composer = " \
 bash \
 ca-certificates \
 virtual//usr/bin/php \
 virtual/php-cli \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-date \
 virtual/php-dom \
 virtual/php-filter \
 virtual/php-hash \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-libxml \
 virtual/php-mbstring \
 virtual/php-openssl \
 virtual/php-pcntl \
 virtual/php-pcre \
 virtual/php-phar \
 virtual/php-posix \
 virtual/php-reflection \
 virtual/php-spl \
 virtual/php-tokenizer \
 virtual/php-xsl \
 virtual/php-zip \
 virtual/php-zlib \
 virtual/php_language__ge_7.2.5 \
 "
