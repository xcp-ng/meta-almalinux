# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-foreign-types"
PV = "0.5.0"
PR = "11.el10_0"
PACKAGES = " \
 rust-foreign-types+default-devel \
 rust-foreign-types+std-devel \
 rust-foreign-types-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-foreign-types-0.5.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3f4b8eaf58c9cdd0b34a4e581428796eb176283c9d19d0f3008699f20fa76db"

URI_x86_64_v2_rust-foreign-types+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foreign-types+default-devel-0.5.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foreign-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foreign-types+default-devel}"
SRC_URI[x86_64_v2_rust-foreign-types+default-devel.sha256sum] = "158830621b44c2585eab6ab6da5690eefb400104e2c3d188e6292764e617d749"

URI_x86_64_v2_rust-foreign-types+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foreign-types+std-devel-0.5.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foreign-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foreign-types+std-devel}"
SRC_URI[x86_64_v2_rust-foreign-types+std-devel.sha256sum] = "2e3d469cb5a50ccfc646cefe194083e4aed9fd4bbba1554203cdf391d916bc34"

URI_x86_64_v2_rust-foreign-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foreign-types-devel-0.5.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foreign-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foreign-types-devel}"
SRC_URI[x86_64_v2_rust-foreign-types-devel.sha256sum] = "07cd00282dd64235e71c4a5021213be56111451eca9f87a3aabc7f923c96bb45"

URI_aarch64_rust-foreign-types+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foreign-types+default-devel-0.5.0-11.el10_0.noarch.rpm;name=aarch64_rust-foreign-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foreign-types+default-devel}"
SRC_URI[aarch64_rust-foreign-types+default-devel.sha256sum] = "bbe87fc96859ce1f6e0d814468472a3d8a46d6692cfd96702d5063ec65bbb0a6"

URI_aarch64_rust-foreign-types+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foreign-types+std-devel-0.5.0-11.el10_0.noarch.rpm;name=aarch64_rust-foreign-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foreign-types+std-devel}"
SRC_URI[aarch64_rust-foreign-types+std-devel.sha256sum] = "5a4a4394fb26495d84e40fbb58c8718fc8559d669a5edde723ac2fb7800c869e"

URI_aarch64_rust-foreign-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foreign-types-devel-0.5.0-11.el10_0.noarch.rpm;name=aarch64_rust-foreign-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foreign-types-devel}"
SRC_URI[aarch64_rust-foreign-types-devel.sha256sum] = "e8906a3690196fae95225d3d619d9529227a4a0bcad231170675c53ee1370efc"

RDEPENDS:rust-foreign-types+default-devel = " \
 cargo \
 rust-foreign-types+std-devel \
 rust-foreign-types-devel \
 "
RDEPENDS:rust-foreign-types+std-devel = " \
 cargo \
 rust-foreign-types-devel \
 rust-foreign-types-macros+std-devel \
 "
RDEPENDS:rust-foreign-types-devel = " \
 cargo \
 rust-foreign-types-macros+default-devel \
 rust-foreign-types-shared+default-devel \
 "
