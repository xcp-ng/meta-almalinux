# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jsonref"
PV = "1.1.0"
PR = "9.el10_1"
PACKAGES = " \
 python3-jsonref \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jsonref-1.1.0-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb78478db6d9bc106976b9629f14ed84bf4a319cd6c7eebf3f40d92185df18f5"

URI_x86_64_v2_python3-jsonref = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jsonref-1.1.0-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jsonref;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jsonref}"
SRC_URI[x86_64_v2_python3-jsonref.sha256sum] = "c82937b3282f557991f2a26ae2cd7f6c9385e297eef6aa6eef05b8366f65d7d7"

URI_aarch64_python3-jsonref = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jsonref-1.1.0-9.el10_1.noarch.rpm;name=aarch64_python3-jsonref;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jsonref}"
SRC_URI[aarch64_python3-jsonref.sha256sum] = "8475766f9c2d2c7515a23109f7b84fde72fd6b00943290eaf27092d878a2cdff"

RDEPENDS:python3-jsonref = " \
 python3 \
 "
