# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memmap2"
PV = "0.9.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-memmap2+default-devel \
 rust-memmap2+stable_deref_trait-devel \
 rust-memmap2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memmap2-0.9.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ad7bd03371988662a9d5409d85da4ded942c392fb6e648411d5ef6e1c839be7"

URI_x86_64_v2_rust-memmap2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2+default-devel-0.9.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2+default-devel}"
SRC_URI[x86_64_v2_rust-memmap2+default-devel.sha256sum] = "4d68feeb5d2f7cbf8e3af43107674e1707fa0e9c36887c110e235cb0dfdda955"

URI_x86_64_v2_rust-memmap2+stable_deref_trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2+stable_deref_trait-devel-0.9.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2+stable_deref_trait-devel}"
SRC_URI[x86_64_v2_rust-memmap2+stable_deref_trait-devel.sha256sum] = "1217b038fb19c52ad4e103355f8a00cc45bdf1b80318d49c77cbf91918c58774"

URI_x86_64_v2_rust-memmap2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2-devel-0.9.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2-devel}"
SRC_URI[x86_64_v2_rust-memmap2-devel.sha256sum] = "29aad3ec1f128617f0405db892ed959e8d7f7ec153261bc6a9313738cec6e232"

URI_aarch64_rust-memmap2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2+default-devel-0.9.11-1.el10_2.noarch.rpm;name=aarch64_rust-memmap2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2+default-devel}"
SRC_URI[aarch64_rust-memmap2+default-devel.sha256sum] = "194f50e2a11552c172858596c95616c9c3d3e676fb0c818fba837c852a6b9bf2"

URI_aarch64_rust-memmap2+stable_deref_trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2+stable_deref_trait-devel-0.9.11-1.el10_2.noarch.rpm;name=aarch64_rust-memmap2+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2+stable_deref_trait-devel}"
SRC_URI[aarch64_rust-memmap2+stable_deref_trait-devel.sha256sum] = "540cfdaee5ad64a992178488d6280dfceb3717d4dbd874d1ec864b8ef7ff4f0e"

URI_aarch64_rust-memmap2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2-devel-0.9.11-1.el10_2.noarch.rpm;name=aarch64_rust-memmap2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2-devel}"
SRC_URI[aarch64_rust-memmap2-devel.sha256sum] = "39c61af569187a1c3a0957cf6e7ce46e731bc7ff73725a068e41729e694cc568"

RDEPENDS:rust-memmap2+default-devel = " \
 cargo \
 rust-memmap2-devel \
 "
RDEPENDS:rust-memmap2+stable_deref_trait-devel = " \
 cargo \
 rust-memmap2-devel \
 rust-stable_deref_trait+default-devel \
 "
RDEPENDS:rust-memmap2-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
