# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "transmission"
PV = "4.1.3"
PR = "2.el10_3"
PACKAGES = " \
 transmission \
 transmission-cli \
 transmission-common \
 transmission-daemon \
 transmission-gtk \
 transmission-qt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/transmission-4.1.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8544f942454e23fa8fdcc385e1f99abc37e6f58ea34a8ac3f7e1dfd8ea4f9f1"

URI_x86_64_v2_transmission = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/transmission-4.1.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_transmission;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_transmission}"
SRC_URI[x86_64_v2_transmission.sha256sum] = "db2af14dc6987c4a46c753345aa3f3a9a12717250adc0e5f4a4a6b80f9bbd976"

URI_x86_64_v2_transmission-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/transmission-cli-4.1.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_transmission-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_transmission-cli}"
SRC_URI[x86_64_v2_transmission-cli.sha256sum] = "3fc622225a6c98d69be3f6e7b5ed8dbdbacd55f9b9b666e445a8bf19f3c8555e"

URI_x86_64_v2_transmission-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/transmission-common-4.1.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_transmission-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_transmission-common}"
SRC_URI[x86_64_v2_transmission-common.sha256sum] = "e4992f2fd60423443167e7b0a53d512cd57c7790336a1ab627e356b640374193"

URI_x86_64_v2_transmission-daemon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/transmission-daemon-4.1.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_transmission-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_transmission-daemon}"
SRC_URI[x86_64_v2_transmission-daemon.sha256sum] = "92ab43108c2b5242f6fee27ca9369bfda569c9c45c0f218e4a317fd734c5164b"

URI_x86_64_v2_transmission-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/transmission-gtk-4.1.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_transmission-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_transmission-gtk}"
SRC_URI[x86_64_v2_transmission-gtk.sha256sum] = "9e208bd0ee17ffb89d79c5c7f2fa6ca17eaddeaad9e9085df58094c6e4026ad7"

URI_x86_64_v2_transmission-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/transmission-qt-4.1.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_transmission-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_transmission-qt}"
SRC_URI[x86_64_v2_transmission-qt.sha256sum] = "075b306c8bdf305d49ff566c3d9fb295b8cab9813d3bd83c29b7527d6de3dc8f"

URI_aarch64_transmission = "${EPEL_MIRROR}/aarch64/Packages/t/transmission-4.1.3-2.el10_3.aarch64.rpm;name=aarch64_transmission;unpack=0"
SRC_URI:append = " ${URI_aarch64_transmission}"
SRC_URI[aarch64_transmission.sha256sum] = "77105ee4bb826e6aed08b55f9d183f061cffd74982db8035683942f050ed9aa0"

URI_aarch64_transmission-cli = "${EPEL_MIRROR}/aarch64/Packages/t/transmission-cli-4.1.3-2.el10_3.aarch64.rpm;name=aarch64_transmission-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_transmission-cli}"
SRC_URI[aarch64_transmission-cli.sha256sum] = "43bad21a2a8bc3b37d72e28779d9314c9f5c7244644063fd4a5ba844cb135ed3"

URI_aarch64_transmission-common = "${EPEL_MIRROR}/aarch64/Packages/t/transmission-common-4.1.3-2.el10_3.aarch64.rpm;name=aarch64_transmission-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_transmission-common}"
SRC_URI[aarch64_transmission-common.sha256sum] = "3664785bc7181d388d30e1e2d0ac96274a46de12f5b79e829c0c121200ce9747"

URI_aarch64_transmission-daemon = "${EPEL_MIRROR}/aarch64/Packages/t/transmission-daemon-4.1.3-2.el10_3.aarch64.rpm;name=aarch64_transmission-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_transmission-daemon}"
SRC_URI[aarch64_transmission-daemon.sha256sum] = "8152f4d3ce15d0ca65c1589b94f607c8021c9c88092919fedb8704ac786dc086"

URI_aarch64_transmission-gtk = "${EPEL_MIRROR}/aarch64/Packages/t/transmission-gtk-4.1.3-2.el10_3.aarch64.rpm;name=aarch64_transmission-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_transmission-gtk}"
SRC_URI[aarch64_transmission-gtk.sha256sum] = "cc713ec3dccb2a0ebe56735bbebeefb34f28067aa1578ff55916b52adaf3d8a0"

URI_aarch64_transmission-qt = "${EPEL_MIRROR}/aarch64/Packages/t/transmission-qt-4.1.3-2.el10_3.aarch64.rpm;name=aarch64_transmission-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_transmission-qt}"
SRC_URI[aarch64_transmission-qt.sha256sum] = "1f45d7abd2f29aa7195a9b181a9e0a0c002e82d93f99066c4cb705902006bd2d"

RDEPENDS:transmission = " \
 transmission-gtk \
 "
RDEPENDS:transmission-cli = " \
 glibc \
 libdeflate \
 libevent \
 libgcc \
 libnatpmp \
 libpsl \
 libstdc++ \
 miniupnpc \
 openssl-libs \
 transmission-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:transmission-common = " \
 glibc \
 libdeflate \
 libevent \
 libgcc \
 libnatpmp \
 libpsl \
 libstdc++ \
 miniupnpc \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:transmission-daemon = " \
 bash \
 glibc \
 libdeflate \
 libevent \
 libgcc \
 libnatpmp \
 libpsl \
 libstdc++ \
 miniupnpc \
 openssl-libs \
 systemd-libs \
 transmission-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:transmission-gtk = " \
 glib2 \
 glibc \
 glibmm2.68 \
 gtk4 \
 gtkmm4.0 \
 libdeflate \
 libevent \
 libgcc \
 libnatpmp \
 libpsl \
 libsigc++30 \
 libstdc++ \
 miniupnpc \
 openssl-libs \
 pangomm2.48 \
 transmission-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:transmission-qt = " \
 glibc \
 libdeflate \
 libevent \
 libgcc \
 libnatpmp \
 libpsl \
 libstdc++ \
 miniupnpc \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 transmission-common \
 virtual/libcurl.so.4___64bit_ \
 "
