# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-test"
PV = "0.4.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-tokio-test+default-devel \
 rust-tokio-test-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-test-0.4.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "681b3398b62ee380843ef59ca079080845f40b62805161bae15e760c1f50bfda"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-test+default-devel-0.4.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-test+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-test+default-devel.sha256sum] = "f22911e634fbcbef64f1ce6c2940120a0ba6da6bee1a55b4bfc04848451ded0c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-test-devel-0.4.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-test-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-test-devel.sha256sum] = "0c805747a26b4020de8c0da4594670ca7b102b3cf1dc8774c42a1cf1afc0a24b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-test+default-devel-0.4.6-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-test+default-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-test+default-devel.sha256sum] = "3107002cd68d850a1ddb8daa4889823b5bf535c785bfdc3e08905449ab2b74ce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-test-devel-0.4.6-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-test-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-test-devel.sha256sum] = "34e3bc21a0031e7d41e7780bf96218759f4fa339da5eaf61fa768f4f2507927a"

RDEPENDS:rust-tokio-test+default-devel = " \
 cargo \
 rust-tokio-test-devel \
 "
RDEPENDS:rust-tokio-test-devel = " \
 cargo \
 rust \
 rust-futures-core+default-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+test-util-devel \
 rust-tokio+time-devel \
 rust-tokio-stream+default-devel \
 "
