# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Install-AuthorTests"
PV = "0.002"
PR = "38.el10"
PACKAGES = " \
 perl-Module-Install-AuthorTests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Module-Install-AuthorTests-0.002-38.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6b221bc4facd0917601035a7cf28a5d353f804a0cdd15b6881ad7da46e3ed45"

URI_x86_64_v2_perl-Module-Install-AuthorTests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Module-Install-AuthorTests-0.002-38.el10.noarch.rpm;name=x86_64_v2_perl-Module-Install-AuthorTests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Install-AuthorTests}"
SRC_URI[x86_64_v2_perl-Module-Install-AuthorTests.sha256sum] = "d64c628e2044b6eaa98fcefc2b4ef2bbbe2c3d47081a49b04035c049de17672d"

URI_aarch64_perl-Module-Install-AuthorTests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Module-Install-AuthorTests-0.002-38.el10.noarch.rpm;name=aarch64_perl-Module-Install-AuthorTests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Install-AuthorTests}"
SRC_URI[aarch64_perl-Module-Install-AuthorTests.sha256sum] = "d64c628e2044b6eaa98fcefc2b4ef2bbbe2c3d47081a49b04035c049de17672d"

RDEPENDS:perl-Module-Install-AuthorTests = " \
 perl-Carp \
 perl-Module-Install \
 perl-libs \
 perl-vars \
 "
