# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pmac"
PV = "0.7.1"
PR = "6.el10_1"
PACKAGES = " \
 rust-pmac+default-devel \
 rust-pmac+std-devel \
 rust-pmac+zeroize-devel \
 rust-pmac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pmac-0.7.1-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef1fef9c8051a62918c1965bd48be5d2143de219e0a5081977ca6e89b4ded8a4"

URI_x86_64_v2_rust-pmac+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pmac+default-devel-0.7.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pmac+default-devel}"
SRC_URI[x86_64_v2_rust-pmac+default-devel.sha256sum] = "d0d90a740282682f7142d92d07a57165429ddeb280dcc0cbbed2a77f6cc83f8c"

URI_x86_64_v2_rust-pmac+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pmac+std-devel-0.7.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pmac+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pmac+std-devel}"
SRC_URI[x86_64_v2_rust-pmac+std-devel.sha256sum] = "300b563bce4cec5dd43dee8f52083421ae18f02796e80048b98781c08188ea43"

URI_x86_64_v2_rust-pmac+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pmac+zeroize-devel-0.7.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pmac+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pmac+zeroize-devel}"
SRC_URI[x86_64_v2_rust-pmac+zeroize-devel.sha256sum] = "8e6fdd83dbf82fa223fcd1f5ab38218fdddedb5be15a3d3972abd1d7cb4b114d"

URI_x86_64_v2_rust-pmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pmac-devel-0.7.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pmac-devel}"
SRC_URI[x86_64_v2_rust-pmac-devel.sha256sum] = "32c19e020949df941efae4436d2fbf61e3150a310e621044dda0429035ac854e"

URI_aarch64_rust-pmac+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pmac+default-devel-0.7.1-6.el10_1.noarch.rpm;name=aarch64_rust-pmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pmac+default-devel}"
SRC_URI[aarch64_rust-pmac+default-devel.sha256sum] = "99c95ed43bd1dff1beeb12bcccd21eabc97fb400b8d0e880e7edaf940b8e7222"

URI_aarch64_rust-pmac+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pmac+std-devel-0.7.1-6.el10_1.noarch.rpm;name=aarch64_rust-pmac+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pmac+std-devel}"
SRC_URI[aarch64_rust-pmac+std-devel.sha256sum] = "7f3e7fb3202c183b6314b83fa6b59e25c2bc254c8e821a152d56be5bf3773cbb"

URI_aarch64_rust-pmac+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pmac+zeroize-devel-0.7.1-6.el10_1.noarch.rpm;name=aarch64_rust-pmac+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pmac+zeroize-devel}"
SRC_URI[aarch64_rust-pmac+zeroize-devel.sha256sum] = "9af268abb1a932b38075c54470e8716d63fb2df76348ac75fe5bff34130d0a42"

URI_aarch64_rust-pmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pmac-devel-0.7.1-6.el10_1.noarch.rpm;name=aarch64_rust-pmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pmac-devel}"
SRC_URI[aarch64_rust-pmac-devel.sha256sum] = "701040050ea225523ba41646c969c0f4bbad5006770a572c4c88e7668bd3750f"

RDEPENDS:rust-pmac+default-devel = " \
 cargo \
 rust-pmac-devel \
 "
RDEPENDS:rust-pmac+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-pmac-devel \
 "
RDEPENDS:rust-pmac+zeroize-devel = " \
 cargo \
 rust-cipher+zeroize-devel \
 rust-pmac-devel \
 "
RDEPENDS:rust-pmac-devel = " \
 cargo \
 rust \
 rust-cipher+default-devel \
 rust-dbl+default-devel \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
