# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-valyala-fastjson"
PV = "1.6.4"
PR = "4.el10_0"
PACKAGES = " \
 golang-github-valyala-fastjson-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-valyala-fastjson-1.6.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "433e66e021d0feea26754d2a162c5bf8790e3664903d79a29c652724c991ccea"

URI_x86_64_v2_golang-github-valyala-fastjson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-valyala-fastjson-devel-1.6.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-valyala-fastjson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-valyala-fastjson-devel}"
SRC_URI[x86_64_v2_golang-github-valyala-fastjson-devel.sha256sum] = "f9b1bc8096d244585985eb15d222e22d10d07e73fe3c74acbac1f241ef477745"

URI_aarch64_golang-github-valyala-fastjson-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-valyala-fastjson-devel-1.6.4-4.el10_0.noarch.rpm;name=aarch64_golang-github-valyala-fastjson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-valyala-fastjson-devel}"
SRC_URI[aarch64_golang-github-valyala-fastjson-devel.sha256sum] = "841b5b1aaa3095fb2430414dc8cf76bf2c38e7d647857e2352ce2d77137ff5f1"

RDEPENDS:golang-github-valyala-fastjson-devel = " \
 go-filesystem \
 "
