# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-fa"
PV = "0.20130404"
PR = "25.el10"
PACKAGES = " \
 hyphen-fa \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-fa-0.20130404-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8f374f64cc90bedeff8a8549474152f2ee6569ad72f87fceb481168afd60c21"

URI_x86_64_v2_hyphen-fa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-fa-0.20130404-25.el10.noarch.rpm;name=x86_64_v2_hyphen-fa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-fa}"
SRC_URI[x86_64_v2_hyphen-fa.sha256sum] = "8a33e3f5b8d028298ea8df697978413a940f442b64bb78d10e0e404c8409d825"

URI_aarch64_hyphen-fa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-fa-0.20130404-25.el10.noarch.rpm;name=aarch64_hyphen-fa;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-fa}"
SRC_URI[aarch64_hyphen-fa.sha256sum] = "8a33e3f5b8d028298ea8df697978413a940f442b64bb78d10e0e404c8409d825"

RDEPENDS:hyphen-fa = " \
 hyphen \
 "
