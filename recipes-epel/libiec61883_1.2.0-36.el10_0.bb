# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libiec61883"
PV = "1.2.0"
PR = "36.el10_0"
PACKAGES = " \
 libiec61883 \
 libiec61883-devel \
 libiec61883-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libiec61883-1.2.0-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ff96b70a157a32a684ff6c49ebde2f841a82b16ebd1c75d4bee919670f507c6"

URI_x86_64_v2_libiec61883 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libiec61883-1.2.0-36.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libiec61883;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libiec61883}"
SRC_URI[x86_64_v2_libiec61883.sha256sum] = "99d0cb74a3fc00c981c96c3655888216249caf9d0f4685c4a58446f1a6dff036"

URI_x86_64_v2_libiec61883-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libiec61883-devel-1.2.0-36.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libiec61883-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libiec61883-devel}"
SRC_URI[x86_64_v2_libiec61883-devel.sha256sum] = "dd48009b8461a5d65fb672ae748729285e95a42300d801d5377b4a4e514d7430"

URI_x86_64_v2_libiec61883-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libiec61883-utils-1.2.0-36.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libiec61883-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libiec61883-utils}"
SRC_URI[x86_64_v2_libiec61883-utils.sha256sum] = "0b6486aff17e8fc3133dd3d0d38deb52f9dfba1624d2a1d3ad0c7f4f62afe0a6"

URI_aarch64_libiec61883 = "${EPEL_MIRROR}/aarch64/Packages/l/libiec61883-1.2.0-36.el10_0.aarch64.rpm;name=aarch64_libiec61883;unpack=0"
SRC_URI:append = " ${URI_aarch64_libiec61883}"
SRC_URI[aarch64_libiec61883.sha256sum] = "085b8d5b4493f6979268618f7bbbfd14c0a4af397fcbc3d73ee2b2dd161e2794"

URI_aarch64_libiec61883-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libiec61883-devel-1.2.0-36.el10_0.aarch64.rpm;name=aarch64_libiec61883-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libiec61883-devel}"
SRC_URI[aarch64_libiec61883-devel.sha256sum] = "e2161e3a8bf6c921b95bef4f49d08d1932e95ca50f9dd1e7505af01661fdd132"

URI_aarch64_libiec61883-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libiec61883-utils-1.2.0-36.el10_0.aarch64.rpm;name=aarch64_libiec61883-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libiec61883-utils}"
SRC_URI[aarch64_libiec61883-utils.sha256sum] = "8a00d365eec94548c711a3978cfd0e344c2cbc286f00df04ec47e6e3d1f9aa25"

RDEPENDS:libiec61883 = " \
 glibc \
 libraw1394 \
 "
RDEPENDS:libiec61883-devel = " \
 libiec61883 \
 libraw1394-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libiec61883-utils = " \
 glibc \
 libiec61883 \
 libraw1394 \
 "
