# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ytree"
PV = "2.13"
PR = "1.el10_3"
PACKAGES = " \
 ytree \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/y/ytree-2.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "282e249c9780881487af6c836fc9960e0fb4066eb72d0d3e0de2308a4e51a86e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ytree-2.13-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ytree;unpack=0"
SRC_URI[x86_64_v2_ytree.sha256sum] = "e1f08c7d951a0c6856ad619aaf4da61e693a5a58a16bc0cb56843d72999fc4b7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/y/ytree-2.13-1.el10_3.aarch64.rpm;name=aarch64_ytree;unpack=0"
SRC_URI[aarch64_ytree.sha256sum] = "70fc3aa903497d7af3d38a431e0b8ad40e1f57974baa118a1536e0eb183dc67b"

RDEPENDS:ytree = " \
 glibc \
 ncurses-libs \
 readline \
 "
