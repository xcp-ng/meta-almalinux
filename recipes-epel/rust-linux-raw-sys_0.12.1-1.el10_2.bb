# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-linux-raw-sys"
PV = "0.12.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-linux-raw-sys+auxvec-devel \
 rust-linux-raw-sys+bootparam-devel \
 rust-linux-raw-sys+btrfs-devel \
 rust-linux-raw-sys+default-devel \
 rust-linux-raw-sys+elf-devel \
 rust-linux-raw-sys+elf_uapi-devel \
 rust-linux-raw-sys+errno-devel \
 rust-linux-raw-sys+general-devel \
 rust-linux-raw-sys+if_arp-devel \
 rust-linux-raw-sys+if_ether-devel \
 rust-linux-raw-sys+if_packet-devel \
 rust-linux-raw-sys+if_tun-devel \
 rust-linux-raw-sys+image-devel \
 rust-linux-raw-sys+io_uring-devel \
 rust-linux-raw-sys+ioctl-devel \
 rust-linux-raw-sys+landlock-devel \
 rust-linux-raw-sys+loop_device-devel \
 rust-linux-raw-sys+mempolicy-devel \
 rust-linux-raw-sys+net-devel \
 rust-linux-raw-sys+netlink-devel \
 rust-linux-raw-sys+no_std-devel \
 rust-linux-raw-sys+prctl-devel \
 rust-linux-raw-sys+ptrace-devel \
 rust-linux-raw-sys+std-devel \
 rust-linux-raw-sys+system-devel \
 rust-linux-raw-sys+vm_sockets-devel \
 rust-linux-raw-sys+xdp-devel \
 rust-linux-raw-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-linux-raw-sys-0.12.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "832469e790e331016f19564d6ca9efca2a85921beff8d68b6077fab935a8a339"

URI_x86_64_v2_rust-linux-raw-sys+auxvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+auxvec-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+auxvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+auxvec-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+auxvec-devel.sha256sum] = "a33902bbcad87d9b715af6ae3a2217fd5c11105985f35f4e097695b73a00a299"

URI_x86_64_v2_rust-linux-raw-sys+bootparam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+bootparam-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+bootparam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+bootparam-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+bootparam-devel.sha256sum] = "41b618e7dfa44ec1b9eead5dec71240b2b59e4d1a1a455c0e7650ec6e67643d5"

URI_x86_64_v2_rust-linux-raw-sys+btrfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+btrfs-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+btrfs-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+btrfs-devel.sha256sum] = "4d8a5381dd748aadcb2671127cb6f94f506752b83ab5c0c40101c96f04cec317"

URI_x86_64_v2_rust-linux-raw-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+default-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+default-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+default-devel.sha256sum] = "a7899954a39c31d1b0294cf3e9ddc22796a6c8576033e50f485d40569b01d46d"

URI_x86_64_v2_rust-linux-raw-sys+elf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+elf-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+elf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+elf-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+elf-devel.sha256sum] = "b99ebcfc231924c618596dcd3db8a92f6ebaac89a931b75ca9807d10f0dc336b"

URI_x86_64_v2_rust-linux-raw-sys+elf_uapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+elf_uapi-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+elf_uapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+elf_uapi-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+elf_uapi-devel.sha256sum] = "432c12f7550fc5c7bb158f5ebefa4fb1d51f1174a54bc2c4d08a8e796677747c"

URI_x86_64_v2_rust-linux-raw-sys+errno-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+errno-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+errno-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+errno-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+errno-devel.sha256sum] = "676fd32fbdf53b686046436ff8d496dbd443a37fe6b517a5106ffc22b8f7efe6"

URI_x86_64_v2_rust-linux-raw-sys+general-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+general-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+general-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+general-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+general-devel.sha256sum] = "4ed83efacbbfa2693e5fe58aff8c4a34c9bfc26c0e0fe5e562cef1b2f4c4d391"

URI_x86_64_v2_rust-linux-raw-sys+if_arp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+if_arp-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+if_arp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+if_arp-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+if_arp-devel.sha256sum] = "848178e7373292c135b61278ce0dd0e8fbb6d761a1d235a51ffa8d893e31ebac"

URI_x86_64_v2_rust-linux-raw-sys+if_ether-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+if_ether-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+if_ether-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+if_ether-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+if_ether-devel.sha256sum] = "a27a0b2863e08192cc7d2bd064ef3459798a1c459aeec7b09e37ecf6fbb1a495"

URI_x86_64_v2_rust-linux-raw-sys+if_packet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+if_packet-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+if_packet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+if_packet-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+if_packet-devel.sha256sum] = "9d9947f80f0911d7d06be55d54e7046908f194f8528f104dd0d59bd427d8196e"

URI_x86_64_v2_rust-linux-raw-sys+if_tun-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+if_tun-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+if_tun-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+if_tun-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+if_tun-devel.sha256sum] = "92ef61089272238e6cd5303de02106c1a6defe44447fd2db00c647f8147fec26"

URI_x86_64_v2_rust-linux-raw-sys+image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+image-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+image-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+image-devel.sha256sum] = "0126b2efdfb39f422afc35c153fbac90edbe93f700be616a7cba270a9194a6c9"

URI_x86_64_v2_rust-linux-raw-sys+io_uring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+io_uring-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+io_uring-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+io_uring-devel.sha256sum] = "c1e9da36434adb16831bb0c00e1820ed564196fa3baabd19e2481682d5d54563"

URI_x86_64_v2_rust-linux-raw-sys+ioctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+ioctl-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+ioctl-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+ioctl-devel.sha256sum] = "ed9f759b849e529e34072cbfe8031acb267d0f21fd8d42645b92e21dc3822048"

URI_x86_64_v2_rust-linux-raw-sys+landlock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+landlock-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+landlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+landlock-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+landlock-devel.sha256sum] = "0b0878ae27ed0591e573cdb6d777f71654e15b6723fbc6c411f43ffa6bc13967"

URI_x86_64_v2_rust-linux-raw-sys+loop_device-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+loop_device-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+loop_device-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+loop_device-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+loop_device-devel.sha256sum] = "0f5d39a74ecf007ea1c037d90eb2c7e3bcc060459d900bc1db6a89854bb85f7e"

URI_x86_64_v2_rust-linux-raw-sys+mempolicy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+mempolicy-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+mempolicy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+mempolicy-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+mempolicy-devel.sha256sum] = "96b0f8f786b2878783cf2775141e46947f6b1e26e9b4ce4ef66b7c88df829337"

URI_x86_64_v2_rust-linux-raw-sys+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+net-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+net-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+net-devel.sha256sum] = "0cbc742c1a7812d6268981832a071d363eeffda84bc5c3b29fc3b7f6d3587a50"

URI_x86_64_v2_rust-linux-raw-sys+netlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+netlink-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+netlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+netlink-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+netlink-devel.sha256sum] = "a1f8de449bf44b255b8fe46a488472e721c037ae957f06ff1d3800f983f5c8be"

URI_x86_64_v2_rust-linux-raw-sys+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+no_std-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+no_std-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+no_std-devel.sha256sum] = "d52742698781bd32e8f3b45c896674e8953e541571bcfce6ae3f2fd3319f834b"

URI_x86_64_v2_rust-linux-raw-sys+prctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+prctl-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+prctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+prctl-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+prctl-devel.sha256sum] = "2c3eb49308d8522070327c3ff482230a803b762ac1147fd33e9a444b7ccbc885"

URI_x86_64_v2_rust-linux-raw-sys+ptrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+ptrace-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+ptrace-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+ptrace-devel.sha256sum] = "3e6e9890f389a922d58482f5fbede0423b60704de086fd2a8862f69c82dd6a96"

URI_x86_64_v2_rust-linux-raw-sys+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+std-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+std-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+std-devel.sha256sum] = "75d5fad103944156f0f94335aeec310ff47e13e4500912963f2869df9d4ba76c"

URI_x86_64_v2_rust-linux-raw-sys+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+system-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+system-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+system-devel.sha256sum] = "de6c6ea66f580e4915524e1c4e000139ef36aee59c5d5b62fe68893a1202758f"

URI_x86_64_v2_rust-linux-raw-sys+vm_sockets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+vm_sockets-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+vm_sockets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+vm_sockets-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+vm_sockets-devel.sha256sum] = "7cac31a6ee766ba7c14456c19abcaaa7fd5a2458b223590de7d28dcbcf091fd8"

URI_x86_64_v2_rust-linux-raw-sys+xdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys+xdp-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys+xdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys+xdp-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys+xdp-devel.sha256sum] = "ada4ef1fae13ec94bd772fa6e5529b7c058bf285e351b22c58db3424a8a1057b"

URI_x86_64_v2_rust-linux-raw-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linux-raw-sys-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linux-raw-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linux-raw-sys-devel}"
SRC_URI[x86_64_v2_rust-linux-raw-sys-devel.sha256sum] = "2968aebc64e033e951ea987b567f93cfd0b0e88efa0d6ec528b2a3c75c826134"

URI_aarch64_rust-linux-raw-sys+auxvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+auxvec-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+auxvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+auxvec-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+auxvec-devel.sha256sum] = "d1ae1f906eb4625eb291e613c581018c9ffdba1c9b68f3a34f3e239288b06488"

URI_aarch64_rust-linux-raw-sys+bootparam-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+bootparam-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+bootparam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+bootparam-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+bootparam-devel.sha256sum] = "d9576f61a0ecf9e43d5f1739c056f088d1e9998bdbbc5a778e7c754a26418851"

URI_aarch64_rust-linux-raw-sys+btrfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+btrfs-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+btrfs-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+btrfs-devel.sha256sum] = "e189f310c78b1fee4a6fcdc99314af72f57c76fc42087273cba0699895e1dfa8"

URI_aarch64_rust-linux-raw-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+default-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+default-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+default-devel.sha256sum] = "4d525074d31164df5b624b2fb7b07fd062af5ed981e3c8d603cd3784e0f40014"

URI_aarch64_rust-linux-raw-sys+elf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+elf-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+elf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+elf-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+elf-devel.sha256sum] = "1392c66c6fafe337de3132fbeafc66ad80dfc08c64b1ca1c6972d1b2655b6430"

URI_aarch64_rust-linux-raw-sys+elf_uapi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+elf_uapi-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+elf_uapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+elf_uapi-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+elf_uapi-devel.sha256sum] = "53d294c6630f542ee82a0290ce2eefe21967f0bc5bc25cc954615d9010f99893"

URI_aarch64_rust-linux-raw-sys+errno-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+errno-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+errno-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+errno-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+errno-devel.sha256sum] = "1b4102ec65be87b964e320ea9278f04b1d7a5a72772bf503bb0748f79b667f38"

URI_aarch64_rust-linux-raw-sys+general-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+general-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+general-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+general-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+general-devel.sha256sum] = "09603914a28ec0edd741beb58c3a4a05323c46b7359f0cb2b230a621c8f59275"

URI_aarch64_rust-linux-raw-sys+if_arp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+if_arp-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+if_arp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+if_arp-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+if_arp-devel.sha256sum] = "454952e77b39c211690c110747f09a237481b829c8f1c3f4c5b89754fd056755"

URI_aarch64_rust-linux-raw-sys+if_ether-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+if_ether-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+if_ether-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+if_ether-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+if_ether-devel.sha256sum] = "e55e701c4556b6f784b53b95036a074bba12bf1752873c35465885efeafefa7d"

URI_aarch64_rust-linux-raw-sys+if_packet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+if_packet-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+if_packet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+if_packet-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+if_packet-devel.sha256sum] = "1385f17a4e8539b6481b8f14caedad8084d2118115f8ecfc1b4cd65f93e0a4af"

URI_aarch64_rust-linux-raw-sys+if_tun-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+if_tun-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+if_tun-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+if_tun-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+if_tun-devel.sha256sum] = "ae39caa57cdabb4020755024b77eb5a35e033f796fcb26288cc0a35bd3a3c101"

URI_aarch64_rust-linux-raw-sys+image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+image-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+image-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+image-devel.sha256sum] = "69cc46a871abf69a9af8b861d1cdfb87ac30fa97c092b037f1af7a8eca15210b"

URI_aarch64_rust-linux-raw-sys+io_uring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+io_uring-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+io_uring-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+io_uring-devel.sha256sum] = "9f2e9795301d9ab0513a0c6e1830e3ca6c0e2ca9389dc77b615d37c634b42b9e"

URI_aarch64_rust-linux-raw-sys+ioctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+ioctl-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+ioctl-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+ioctl-devel.sha256sum] = "ab33eba928f201a2cc103e6ec11c294f1ec6b18ec98e939356b12caab57fbaef"

URI_aarch64_rust-linux-raw-sys+landlock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+landlock-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+landlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+landlock-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+landlock-devel.sha256sum] = "47ccd9099abb22f7352276c4de4dbc392320d4d7ecd617860b73afc29785c4d4"

URI_aarch64_rust-linux-raw-sys+loop_device-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+loop_device-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+loop_device-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+loop_device-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+loop_device-devel.sha256sum] = "84c686ea9d0f01662023ac0799d53a93baa925b5e5d1e03fd7661bef5f60f903"

URI_aarch64_rust-linux-raw-sys+mempolicy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+mempolicy-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+mempolicy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+mempolicy-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+mempolicy-devel.sha256sum] = "3ba94083a7885e4ff803033d870ff44e589124a5960bd8928c780c54764dbacc"

URI_aarch64_rust-linux-raw-sys+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+net-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+net-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+net-devel.sha256sum] = "fd56a86e828c05db87201f9df0f0930335d326834f2fbbc3eeead25876a1909b"

URI_aarch64_rust-linux-raw-sys+netlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+netlink-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+netlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+netlink-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+netlink-devel.sha256sum] = "77b109fc531dcc03150041a2173b2112e6964c67f6b6d4a211bb69276210eda9"

URI_aarch64_rust-linux-raw-sys+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+no_std-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+no_std-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+no_std-devel.sha256sum] = "b8a498634d92590494c6344d6a658205746994bb136359af844f7eb9cd5e3f56"

URI_aarch64_rust-linux-raw-sys+prctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+prctl-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+prctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+prctl-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+prctl-devel.sha256sum] = "97b2b653d843e5a2aec6b06ee07491ed13a969cce8654f866ac959e66698b67c"

URI_aarch64_rust-linux-raw-sys+ptrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+ptrace-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+ptrace-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+ptrace-devel.sha256sum] = "3695bc68354e117393ceaba2ec5ec6099593403a2b944bb42e301fb829747872"

URI_aarch64_rust-linux-raw-sys+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+std-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+std-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+std-devel.sha256sum] = "26cc892d49ffd8f8d624fe6144a5ec64ae4186e297b8b72137240955450a1821"

URI_aarch64_rust-linux-raw-sys+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+system-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+system-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+system-devel.sha256sum] = "15b77fc8044c5ed2e1eb250b3e630ea92176f03cc48833e7f4ae176a388cee14"

URI_aarch64_rust-linux-raw-sys+vm_sockets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+vm_sockets-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+vm_sockets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+vm_sockets-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+vm_sockets-devel.sha256sum] = "edd262da6bd63ebb19dbe309f68cd2e9ae9d258107168c7e542a7bce981c1e67"

URI_aarch64_rust-linux-raw-sys+xdp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys+xdp-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys+xdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys+xdp-devel}"
SRC_URI[aarch64_rust-linux-raw-sys+xdp-devel.sha256sum] = "2094a970c6fd6298d444c3177520ab2a124134311a0f6e49f8b361b5279798f9"

URI_aarch64_rust-linux-raw-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linux-raw-sys-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-linux-raw-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linux-raw-sys-devel}"
SRC_URI[aarch64_rust-linux-raw-sys-devel.sha256sum] = "c82acd1329f1d32ad70e5c09fa7b9499d88ca3867492e0be9a613497148bfafc"

RDEPENDS:rust-linux-raw-sys+auxvec-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+bootparam-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+btrfs-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+default-devel = " \
 cargo \
 rust-linux-raw-sys+errno-devel \
 rust-linux-raw-sys+general-devel \
 rust-linux-raw-sys+std-devel \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+elf-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+elf_uapi-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+errno-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+general-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+if_arp-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+if_ether-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+if_packet-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+if_tun-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+image-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+io_uring-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+ioctl-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+landlock-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+loop_device-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+mempolicy-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+net-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+netlink-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+no_std-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+prctl-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+ptrace-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+std-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+system-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+vm_sockets-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys+xdp-devel = " \
 cargo \
 rust-linux-raw-sys-devel \
 "
RDEPENDS:rust-linux-raw-sys-devel = " \
 cargo \
 rust \
 "
