# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scotch"
PV = "7.0.8"
PR = "1.el10_0"
PACKAGES = " \
 ptscotch-mpich \
 ptscotch-mpich-devel \
 ptscotch-mpich-devel-parmetis \
 ptscotch-openmpi \
 ptscotch-openmpi-devel \
 ptscotch-openmpi-devel-parmetis \
 scotch \
 scotch-devel \
 scotch-devel-metis \
 scotch-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scotch-7.0.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49b90d57fcc40b51757fb61906d4f9cd96546c640bc5a1eec3420859c15f43a0"

URI_x86_64_v2_ptscotch-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptscotch-mpich-7.0.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptscotch-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptscotch-mpich}"
SRC_URI[x86_64_v2_ptscotch-mpich.sha256sum] = "b4d262cd3bf5940e0e06007c522c9e9d157692f4b91b16009ea953c727d5affa"

URI_x86_64_v2_ptscotch-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptscotch-mpich-devel-7.0.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptscotch-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptscotch-mpich-devel}"
SRC_URI[x86_64_v2_ptscotch-mpich-devel.sha256sum] = "c8c65dcac6d8d6f92378f501b4ceb9c76d1c9468d6886018c6ac3c029fd84a4d"

URI_x86_64_v2_ptscotch-mpich-devel-parmetis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptscotch-mpich-devel-parmetis-7.0.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptscotch-mpich-devel-parmetis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptscotch-mpich-devel-parmetis}"
SRC_URI[x86_64_v2_ptscotch-mpich-devel-parmetis.sha256sum] = "840ec50de954553c08c4ef6899fe5b19b3d08592fbc337c0bef1532f5c894e28"

URI_x86_64_v2_ptscotch-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptscotch-openmpi-7.0.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptscotch-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptscotch-openmpi}"
SRC_URI[x86_64_v2_ptscotch-openmpi.sha256sum] = "ea0b56e52c72c22f9ae0c4b8d3af6699f30d54fd8a7021e46c46588555de1f5a"

URI_x86_64_v2_ptscotch-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptscotch-openmpi-devel-7.0.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptscotch-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptscotch-openmpi-devel}"
SRC_URI[x86_64_v2_ptscotch-openmpi-devel.sha256sum] = "3a90b957d4d23fc79ac61efd768e65c28869163808f211b7305d438067b204d7"

URI_x86_64_v2_ptscotch-openmpi-devel-parmetis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptscotch-openmpi-devel-parmetis-7.0.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptscotch-openmpi-devel-parmetis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptscotch-openmpi-devel-parmetis}"
SRC_URI[x86_64_v2_ptscotch-openmpi-devel-parmetis.sha256sum] = "61156883be98fbdec00eef25b7918a282b8fae2bdaaa5de54bbfadcdc9b0abdb"

URI_x86_64_v2_scotch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scotch-7.0.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scotch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scotch}"
SRC_URI[x86_64_v2_scotch.sha256sum] = "5b613663ab50b52b4f6364e5cb8823d87e9aa42938d04b4eaf825f7b4f600cf1"

URI_x86_64_v2_scotch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scotch-devel-7.0.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scotch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scotch-devel}"
SRC_URI[x86_64_v2_scotch-devel.sha256sum] = "bc0d1261cc145c7d6511ec1f004a4f841af83929d7f89f7f6eabd0ee0fed8679"

URI_x86_64_v2_scotch-devel-metis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scotch-devel-metis-7.0.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scotch-devel-metis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scotch-devel-metis}"
SRC_URI[x86_64_v2_scotch-devel-metis.sha256sum] = "7aa35f539428ba76d32b1935b1c60d447fdf969fadf7610aa4301dd25a488ce5"

URI_x86_64_v2_scotch-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scotch-doc-7.0.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_scotch-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scotch-doc}"
SRC_URI[x86_64_v2_scotch-doc.sha256sum] = "3d0daf68575d456795d0b0896730b0b5e20ead967c353a1bb9154beb57235f88"

URI_aarch64_ptscotch-mpich = "${EPEL_MIRROR}/aarch64/Packages/p/ptscotch-mpich-7.0.8-1.el10_0.aarch64.rpm;name=aarch64_ptscotch-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptscotch-mpich}"
SRC_URI[aarch64_ptscotch-mpich.sha256sum] = "9681fe420b3321376b18fe2c841266d7d5b7575580bace067ae1324f27ad1e9b"

URI_aarch64_ptscotch-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/p/ptscotch-mpich-devel-7.0.8-1.el10_0.aarch64.rpm;name=aarch64_ptscotch-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptscotch-mpich-devel}"
SRC_URI[aarch64_ptscotch-mpich-devel.sha256sum] = "020ac9c7c34f12f1126a1a6f4f72ea7f8af8ae14f32841ab9e9421612bd855c4"

URI_aarch64_ptscotch-mpich-devel-parmetis = "${EPEL_MIRROR}/aarch64/Packages/p/ptscotch-mpich-devel-parmetis-7.0.8-1.el10_0.aarch64.rpm;name=aarch64_ptscotch-mpich-devel-parmetis;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptscotch-mpich-devel-parmetis}"
SRC_URI[aarch64_ptscotch-mpich-devel-parmetis.sha256sum] = "f0927d7f864a6906eeaf2624d41f1b6418eb0392a2b211f32dc8822a73b6bcfb"

URI_aarch64_ptscotch-openmpi = "${EPEL_MIRROR}/aarch64/Packages/p/ptscotch-openmpi-7.0.8-1.el10_0.aarch64.rpm;name=aarch64_ptscotch-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptscotch-openmpi}"
SRC_URI[aarch64_ptscotch-openmpi.sha256sum] = "f36eb76c15a8deafbfba2c0a874b0f31a7682c262af3b75a57820d3192d1ebee"

URI_aarch64_ptscotch-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/p/ptscotch-openmpi-devel-7.0.8-1.el10_0.aarch64.rpm;name=aarch64_ptscotch-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptscotch-openmpi-devel}"
SRC_URI[aarch64_ptscotch-openmpi-devel.sha256sum] = "3126b4416272a262202d0ea90ed9f1641823c5126b0aa6964117eff8eeaf1357"

URI_aarch64_ptscotch-openmpi-devel-parmetis = "${EPEL_MIRROR}/aarch64/Packages/p/ptscotch-openmpi-devel-parmetis-7.0.8-1.el10_0.aarch64.rpm;name=aarch64_ptscotch-openmpi-devel-parmetis;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptscotch-openmpi-devel-parmetis}"
SRC_URI[aarch64_ptscotch-openmpi-devel-parmetis.sha256sum] = "11705db46d90b9ac165dcbcb38e9290f9cc8767ef35c312a55aa40fab774ed5b"

URI_aarch64_scotch = "${EPEL_MIRROR}/aarch64/Packages/s/scotch-7.0.8-1.el10_0.aarch64.rpm;name=aarch64_scotch;unpack=0"
SRC_URI:append = " ${URI_aarch64_scotch}"
SRC_URI[aarch64_scotch.sha256sum] = "ce142dda043f43752c9f6a651933075af7f4daa84f0d19de095ff73ee4f4d5d2"

URI_aarch64_scotch-devel = "${EPEL_MIRROR}/aarch64/Packages/s/scotch-devel-7.0.8-1.el10_0.aarch64.rpm;name=aarch64_scotch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_scotch-devel}"
SRC_URI[aarch64_scotch-devel.sha256sum] = "886b00ef435962e5c667815f85ab8653796c20bc9e091d1ca09bb37dd652d831"

URI_aarch64_scotch-devel-metis = "${EPEL_MIRROR}/aarch64/Packages/s/scotch-devel-metis-7.0.8-1.el10_0.aarch64.rpm;name=aarch64_scotch-devel-metis;unpack=0"
SRC_URI:append = " ${URI_aarch64_scotch-devel-metis}"
SRC_URI[aarch64_scotch-devel-metis.sha256sum] = "f268690d0a215fd842cae56b1610f2481919e68b80273198d505b15db453f571"

URI_aarch64_scotch-doc = "${EPEL_MIRROR}/aarch64/Packages/s/scotch-doc-7.0.8-1.el10_0.noarch.rpm;name=aarch64_scotch-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scotch-doc}"
SRC_URI[aarch64_scotch-doc.sha256sum] = "3b1fadbb0977878bf740ce29557fec55ff3473a9b4daf84379f1e084ad2981fb"

RDEPENDS:ptscotch-mpich = " \
 bzip2-libs \
 glibc \
 mpich \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:ptscotch-mpich-devel = " \
 ptscotch-mpich \
 "
RDEPENDS:ptscotch-mpich-devel-parmetis = " \
 ptscotch-mpich-devel \
 "
RDEPENDS:ptscotch-openmpi = " \
 bzip2-libs \
 glibc \
 openmpi \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:ptscotch-openmpi-devel = " \
 ptscotch-openmpi \
 "
RDEPENDS:ptscotch-openmpi-devel-parmetis = " \
 ptscotch-openmpi-devel \
 "
RDEPENDS:scotch = " \
 bzip2-libs \
 glibc \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:scotch-devel = " \
 cmake-filesystem \
 scotch \
 "
RDEPENDS:scotch-devel-metis = " \
 scotch-devel \
 "
RDEPENDS:scotch-doc = " \
 "
