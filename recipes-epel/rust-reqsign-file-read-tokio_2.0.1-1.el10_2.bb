# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-file-read-tokio"
PV = "2.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqsign-file-read-tokio+default-devel \
 rust-reqsign-file-read-tokio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-file-read-tokio-2.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3053485be91a8cab806ae209bd1ccb82b7d9737fbb59faa6864aa1746e2e112"

URI_x86_64_v2_rust-reqsign-file-read-tokio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-file-read-tokio+default-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-file-read-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-file-read-tokio+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-file-read-tokio+default-devel.sha256sum] = "8d0f7dbd83459231214ebe843fa145493ca39e82be3ed6cae0e486a739748708"

URI_x86_64_v2_rust-reqsign-file-read-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-file-read-tokio-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-file-read-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-file-read-tokio-devel}"
SRC_URI[x86_64_v2_rust-reqsign-file-read-tokio-devel.sha256sum] = "1c266707935ba0fa58316918c0a739901b0c64843e18257c15673a3a7554033d"

URI_aarch64_rust-reqsign-file-read-tokio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-file-read-tokio+default-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-file-read-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-file-read-tokio+default-devel}"
SRC_URI[aarch64_rust-reqsign-file-read-tokio+default-devel.sha256sum] = "527c7976abdeef5da4fd221fe4f29c9965acd813e14671684886d0f51e57fca1"

URI_aarch64_rust-reqsign-file-read-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-file-read-tokio-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-file-read-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-file-read-tokio-devel}"
SRC_URI[aarch64_rust-reqsign-file-read-tokio-devel.sha256sum] = "f62ca3977527859100c8dbc4b1f925a821dd793eea021b63a269d09c65cfeee6"

RDEPENDS:rust-reqsign-file-read-tokio+default-devel = " \
 cargo \
 rust-reqsign-file-read-tokio-devel \
 "
RDEPENDS:rust-reqsign-file-read-tokio-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-reqsign-core+default-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 "
