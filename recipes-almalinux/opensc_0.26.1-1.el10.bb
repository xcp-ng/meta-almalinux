# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opensc"
PV = "0.26.1"
PR = "1.el10"
PACKAGES = " \
 opensc \
 opensc-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/opensc-0.26.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "75899b863fdf71d0d0129a62752d6e237b793f1354a0262ef0a95878eaf43b38"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opensc-0.26.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_opensc;unpack=0"
SRC_URI[x86_64_v2_opensc.sha256sum] = "f2eec6607645ccb7097de7844ad2b30c3212662b861a4dd0c0a40f0fd1895d3c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opensc-libs-0.26.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_opensc-libs;unpack=0"
SRC_URI[x86_64_v2_opensc-libs.sha256sum] = "649faff20882fda247c27a4fe2cb968f3834949f0776e2cd472dee50a8ea9c17"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opensc-0.26.1-1.el10.aarch64.rpm;name=aarch64_opensc;unpack=0"
SRC_URI[aarch64_opensc.sha256sum] = "722d1cf3a6c6ff6370110fd53ab918e9aefada267d1daba17f8fb69373d5d4bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opensc-libs-0.26.1-1.el10.aarch64.rpm;name=aarch64_opensc-libs;unpack=0"
SRC_URI[aarch64_opensc-libs.sha256sum] = "0239f1bf3fa7eb54271b9f9dfe3359ff5ea8b35c3c7ee6a79658f24337553406"

RDEPENDS:opensc = " \
 glibc \
 opensc-libs \
 openssl-libs \
 pcsc-lite \
 readline \
 zlib-ng-compat \
 "
RDEPENDS:opensc-libs = " \
 glibc \
 openssl-libs \
 pcsc-lite-libs \
 zlib-ng-compat \
 "
