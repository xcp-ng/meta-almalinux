# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_normalizer_data"
PV = "2.1.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-icu_normalizer_data+default-devel \
 rust-icu_normalizer_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_normalizer_data-2.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2e171572ef9168e215265f0f1d2c3bc37158c22738d239e2108241ad6e46b94"

URI_x86_64_v2_rust-icu_normalizer_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer_data+default-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer_data+default-devel.sha256sum] = "b30c93dff3ddbf7c8e6cf4ad0c556045eba039d0f3f12df24b335d2dcd9a357e"

URI_x86_64_v2_rust-icu_normalizer_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer_data-devel-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer_data-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer_data-devel.sha256sum] = "98c0f3096c5581332030e8cdfe6f12b76f8706927d5491776e48bea4372e43b1"

URI_aarch64_rust-icu_normalizer_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer_data+default-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_normalizer_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer_data+default-devel}"
SRC_URI[aarch64_rust-icu_normalizer_data+default-devel.sha256sum] = "cd4a4e64ec3be064eb800f24d3d8e0d1be44b22d8c0d62839caca86ef65ba11e"

URI_aarch64_rust-icu_normalizer_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer_data-devel-2.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-icu_normalizer_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer_data-devel}"
SRC_URI[aarch64_rust-icu_normalizer_data-devel.sha256sum] = "f878d818ec0730d11b4a052f99a44174bc70f5d97f05c32bf441f1cf37c04aac"

RDEPENDS:rust-icu_normalizer_data+default-devel = " \
 cargo \
 rust-icu_normalizer_data-devel \
 "
RDEPENDS:rust-icu_normalizer_data-devel = " \
 cargo \
 rust \
 "
