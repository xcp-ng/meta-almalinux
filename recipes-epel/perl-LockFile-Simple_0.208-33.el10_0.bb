# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-LockFile-Simple"
PV = "0.208"
PR = "33.el10_0"
PACKAGES = " \
 perl-LockFile-Simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-LockFile-Simple-0.208-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90467040dbb40726cc98b0980c4161fb2838216cb7c4771b9cde31e94aea4c41"

URI_x86_64_v2_perl-LockFile-Simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-LockFile-Simple-0.208-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-LockFile-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-LockFile-Simple}"
SRC_URI[x86_64_v2_perl-LockFile-Simple.sha256sum] = "165d4d53c70676862cc4a62f8ac593a089e25ff49442baaaa5549949a0c2256c"

URI_aarch64_perl-LockFile-Simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-LockFile-Simple-0.208-33.el10_0.noarch.rpm;name=aarch64_perl-LockFile-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-LockFile-Simple}"
SRC_URI[aarch64_perl-LockFile-Simple.sha256sum] = "442a3f1a55425dbaa99ed87a0e0488c5cc90aab8f2cc38647a5dba912c1b2e76"

RDEPENDS:perl-LockFile-Simple = " \
 perl-Exporter \
 perl-Sys-Hostname \
 perl-libs \
 perl-vars \
 "
