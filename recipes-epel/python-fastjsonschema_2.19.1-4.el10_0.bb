# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fastjsonschema"
PV = "2.19.1"
PR = "4.el10_0"
PACKAGES = " \
 python3-fastjsonschema \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fastjsonschema-2.19.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d520592b9798da24b8b992c716963737fd43e7f10824ebf827afbf2202edc3a"

URI_x86_64_v2_python3-fastjsonschema = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastjsonschema-2.19.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fastjsonschema;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastjsonschema}"
SRC_URI[x86_64_v2_python3-fastjsonschema.sha256sum] = "5e29ea4a969a98211391caa46f0832ef71a7c115cec74b285cdf7d3f5855937e"

URI_aarch64_python3-fastjsonschema = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastjsonschema-2.19.1-4.el10_0.noarch.rpm;name=aarch64_python3-fastjsonschema;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastjsonschema}"
SRC_URI[aarch64_python3-fastjsonschema.sha256sum] = "69452c39efb27b91b967f79333527373287cdda0d2d7dd65fedafb11a0c97d6d"

RDEPENDS:python3-fastjsonschema = " \
 python3 \
 "
