# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-colored"
PV = "3.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-colored+default-devel \
 rust-colored+no-color-devel \
 rust-colored-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-colored-3.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ca5f1a3faf56cd082ef4057eb57b544ae16a9e6ef55c6985177aab72c9bd113"

URI_x86_64_v2_rust-colored+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colored+default-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colored+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colored+default-devel}"
SRC_URI[x86_64_v2_rust-colored+default-devel.sha256sum] = "2015202b43d04e88ef7fffe7fe3bf2fe061bd2a1c8ffd49490512ce2de288a28"
RPROVIDES:rust-colored+default-devel:x86_64_v2 = "virtual/crate_colored/default__ge_2.0.0_with_crate_colored/default__lt_4.0.0~"

URI_x86_64_v2_rust-colored+no-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colored+no-color-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colored+no-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colored+no-color-devel}"
SRC_URI[x86_64_v2_rust-colored+no-color-devel.sha256sum] = "06da79b3b85ea9da74a9bd656b6aaf93a537a61a042561534b3c8584d651236d"

URI_x86_64_v2_rust-colored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colored-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colored-devel}"
SRC_URI[x86_64_v2_rust-colored-devel.sha256sum] = "54ff3de2199c9ad76532c348356d813e2d0074b4344913e6ee9d69e220381e32"

URI_aarch64_rust-colored+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colored+default-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-colored+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colored+default-devel}"
SRC_URI[aarch64_rust-colored+default-devel.sha256sum] = "d239c19bfbcc8685d2451d79aa921262cb28b561a6a958fa9ce350944fd08cbb"
RPROVIDES:rust-colored+default-devel:aarch64 = "virtual/crate_colored/default__ge_2.0.0_with_crate_colored/default__lt_4.0.0~"

URI_aarch64_rust-colored+no-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colored+no-color-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-colored+no-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colored+no-color-devel}"
SRC_URI[aarch64_rust-colored+no-color-devel.sha256sum] = "91bf922ec3578a043739efa62ae517ebcd9937d115ed068f866959fdb375ea0f"

URI_aarch64_rust-colored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colored-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-colored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colored-devel}"
SRC_URI[aarch64_rust-colored-devel.sha256sum] = "75a7fe8261e937067037dcf9389af0c74b19031aba62e4bf8ef68fb1c6786b2c"

RDEPENDS:rust-colored+default-devel = " \
 cargo \
 rust-colored-devel \
 "
RDEPENDS:rust-colored+no-color-devel = " \
 cargo \
 rust-colored-devel \
 "
RDEPENDS:rust-colored-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_colored/default__ge_2.0.0_with_crate_colored/default__lt_4.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_colored/default__ge_2.0.0_with_crate_colored/default__lt_4.0.0~"
