# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmail-account-wizard"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kmail-account-wizard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmail-account-wizard-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44b272be2d89c7a1c6cdafe9684639f36f46639af8b47fdfd0947ac849426c7a"

URI_x86_64_v2_kmail-account-wizard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-account-wizard-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail-account-wizard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmail-account-wizard}"
SRC_URI[x86_64_v2_kmail-account-wizard.sha256sum] = "4f2124498d28d41902eb1420b95bb423086774cf4d3d360ee017e5a3efee4029"

URI_aarch64_kmail-account-wizard = "${EPEL_MIRROR}/aarch64/Packages/k/kmail-account-wizard-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmail-account-wizard;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmail-account-wizard}"
SRC_URI[aarch64_kmail-account-wizard.sha256sum] = "a1677944aa58627d9229f4a5034c7d878d5e2022445bc5e22ba5e25779c63813"

RDEPENDS:kmail-account-wizard = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
