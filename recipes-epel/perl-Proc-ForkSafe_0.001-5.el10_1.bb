# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Proc-ForkSafe"
PV = "0.001"
PR = "5.el10_1"
PACKAGES = " \
 perl-Proc-ForkSafe \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Proc-ForkSafe-0.001-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97b6c478976e7a29f4686ea52d3ac134d0d375fbc0e452b768c8cd09b3d3bfb6"

URI_x86_64_v2_perl-Proc-ForkSafe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Proc-ForkSafe-0.001-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Proc-ForkSafe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Proc-ForkSafe}"
SRC_URI[x86_64_v2_perl-Proc-ForkSafe.sha256sum] = "f8c0e5216ca087eb87791bdac9b0dfd19c147cf58e773b13f35b7b5bebee4deb"

URI_aarch64_perl-Proc-ForkSafe = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Proc-ForkSafe-0.001-5.el10_1.noarch.rpm;name=aarch64_perl-Proc-ForkSafe;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Proc-ForkSafe}"
SRC_URI[aarch64_perl-Proc-ForkSafe.sha256sum] = "bfcbcf9edc6d81283c4c4a1461dd2278dc7f591368821c6188cbd750c1f69e6b"

RDEPENDS:perl-Proc-ForkSafe = " \
 perl-libs \
 "
