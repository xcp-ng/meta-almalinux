# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mutter"
PV = "47.5"
PR = "8.el10_0"
PACKAGES = " \
 mutter \
 mutter-common \
 mutter-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mutter-47.5-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bdb7f18b44a58493f76578a52239df3d3ed3ec2994a1fd4905dc1ed51eda0d3"

URI_x86_64_v2_mutter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mutter-47.5-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_mutter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mutter}"
SRC_URI[x86_64_v2_mutter.sha256sum] = "69e719c95888fcecd75de448f1a2d4913f33d9791014e5ba36fcb93cedc991fa"
RPROVIDES:mutter:x86_64_v2 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_x86_64_v2_mutter-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mutter-common-47.5-8.el10_0.noarch.rpm;name=x86_64_v2_mutter-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mutter-common}"
SRC_URI[x86_64_v2_mutter-common.sha256sum] = "88df4e69939724d65fcd64caf9451c2e83ee9af23a504587657768cf1de832e1"

URI_x86_64_v2_mutter-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mutter-devel-47.5-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_mutter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mutter-devel}"
SRC_URI[x86_64_v2_mutter-devel.sha256sum] = "5b9a2b51e2d268e2a3353340c1bfda8fe3cd21c8ead260835d5c6c9af8648189"

URI_aarch64_mutter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mutter-47.5-8.el10_0.aarch64.rpm;name=aarch64_mutter;unpack=0"
SRC_URI:append = " ${URI_aarch64_mutter}"
SRC_URI[aarch64_mutter.sha256sum] = "a5a20c9a756e8d01cd7e1f122bbb381e415bf77ed31067d04284aa6d9a01dd17"
RPROVIDES:mutter:aarch64 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_aarch64_mutter-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mutter-common-47.5-8.el10_0.noarch.rpm;name=aarch64_mutter-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_mutter-common}"
SRC_URI[aarch64_mutter-common.sha256sum] = "88df4e69939724d65fcd64caf9451c2e83ee9af23a504587657768cf1de832e1"

URI_aarch64_mutter-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mutter-devel-47.5-8.el10_0.aarch64.rpm;name=aarch64_mutter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mutter-devel}"
SRC_URI[aarch64_mutter-devel.sha256sum] = "be43e9721b1dfe42f64fce305f0dd027154a098ff18f1120f54c194bec881baa"

RDEPENDS:mutter = " \
 atk \
 cairo \
 colord-libs \
 dbus \
 fribidi \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-control-center-filesystem \
 gnome-desktop4 \
 gnome-settings-daemon \
 graphene \
 gsettings-desktop-schemas \
 gtk4 \
 harfbuzz \
 lcms2 \
 libICE \
 libSM \
 libX11 \
 libX11-xcb \
 libXau \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libXtst \
 libcanberra \
 libdisplay-info \
 libdrm \
 libeis \
 libgcc \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libgudev \
 libinput \
 libwacom \
 libwayland-server \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 libxkbfile \
 mesa-libgbm \
 mutter-common \
 pango \
 pipewire \
 pipewire-libs \
 pixman \
 startup-notification \
 systemd-libs \
 "
RDEPENDS:mutter-common = " \
 "
RDEPENDS:mutter-devel = " \
 atk-devel \
 cairo \
 cairo-devel \
 glib2 \
 glib2-devel \
 glibc \
 graphene-devel \
 gsettings-desktop-schemas-devel \
 harfbuzz-devel \
 libX11-devel \
 libXext \
 libXfixes-devel \
 libXi-devel \
 libgcc \
 libglvnd-devel \
 libglvnd-gles \
 libwayland-client \
 libxcb \
 mesa-libEGL-devel \
 mutter \
 mutter-devel \
 pango-devel \
 pixman-devel \
 pkgconf-pkg-config \
 wayland-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

PROVIDES:append:aarch64 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"
