# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fwupd-efi"
PV = "1.8"
PR = "1.el10_2.alma.1"
PACKAGES = " \
 fwupd-efi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/fwupd-efi-1.8-1.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "238eef005313ed1171e227feccb842c2684ba07273957bcbcea846d02a72242e"

URI_x86_64_v2_fwupd-efi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/fwupd-efi-1.8-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_fwupd-efi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fwupd-efi}"
SRC_URI[x86_64_v2_fwupd-efi.sha256sum] = "1f0f6d40d959d92b6420b13140a43d155883160834b6e8ef8f417164ced4ac1d"

URI_aarch64_fwupd-efi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/fwupd-efi-1.8-1.el10_2.alma.1.aarch64.rpm;name=aarch64_fwupd-efi;unpack=0"
SRC_URI:append = " ${URI_aarch64_fwupd-efi}"
SRC_URI[aarch64_fwupd-efi.sha256sum] = "40eaf3779a10c0b1964f36f3c6ee692c39177bab273d4e584435a7d13ced0b13"

RDEPENDS:fwupd-efi = " \
 pkgconf-pkg-config \
 "
