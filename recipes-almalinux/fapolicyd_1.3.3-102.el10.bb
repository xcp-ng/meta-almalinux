# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fapolicyd"
PV = "1.3.3"
PR = "102.el10"
PACKAGES = " \
 fapolicyd \
 fapolicyd-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fapolicyd-1.3.3-102.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b94953f194ac6ca1b04f74375bbb93f06df4bcd131268ea6c59fb650c4546554"

URI_x86_64_v2_fapolicyd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fapolicyd-1.3.3-102.el10.x86_64_v2.rpm;name=x86_64_v2_fapolicyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicyd}"
SRC_URI[x86_64_v2_fapolicyd.sha256sum] = "e328d21101d043429481d1b507e61e5a996f4e1944ce74ff2ec559597fe4a93c"

URI_x86_64_v2_fapolicyd-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fapolicyd-selinux-1.3.3-102.el10.noarch.rpm;name=x86_64_v2_fapolicyd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicyd-selinux}"
SRC_URI[x86_64_v2_fapolicyd-selinux.sha256sum] = "e5802d81db150e9e6763c2fd39481020a63b21e72a047d1ae05d8b2a198948c5"

URI_aarch64_fapolicyd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fapolicyd-1.3.3-102.el10.aarch64.rpm;name=aarch64_fapolicyd;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicyd}"
SRC_URI[aarch64_fapolicyd.sha256sum] = "6af150ff19228a0418ecf30468d8adb38e5bae9631443cc15c521beb46a63d2b"

URI_aarch64_fapolicyd-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fapolicyd-selinux-1.3.3-102.el10.noarch.rpm;name=aarch64_fapolicyd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicyd-selinux}"
SRC_URI[aarch64_fapolicyd-selinux.sha256sum] = "e5802d81db150e9e6763c2fd39481020a63b21e72a047d1ae05d8b2a198948c5"

RDEPENDS:fapolicyd = " \
 bash \
 file-libs \
 glibc \
 libcap-ng \
 libseccomp \
 lmdb-libs \
 openssl-libs \
 rpm-libs \
 rpm-plugin-fapolicyd \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:fapolicyd-selinux = " \
 bash \
 fapolicyd \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
