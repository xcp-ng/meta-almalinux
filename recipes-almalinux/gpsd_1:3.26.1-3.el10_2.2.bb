# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpsd"
PE = "1"
PV = "3.26.1"
PR = "3.el10_2.2"
PACKAGES = " \
 gpsd \
 gpsd-clients \
 python3-gpsd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gpsd-3.26.1-3.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7e2be9f520401fead16c85e2ed40ad5ef0f154cb20b8badf16a037bfe39e2026"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gpsd-3.26.1-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_gpsd;unpack=0"
SRC_URI[x86_64_v2_gpsd.sha256sum] = "99b43150e063d6e4f97c9f1a1876b0c25a3a44941451f65082dd47d923c5be91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gpsd-clients-3.26.1-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_gpsd-clients;unpack=0"
SRC_URI[x86_64_v2_gpsd-clients.sha256sum] = "42f3835ad5a133b15b4d887aa41d08008c90b34c67a22d04b9ca0287d4ecf45a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-gpsd-3.26.1-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_python3-gpsd;unpack=0"
SRC_URI[x86_64_v2_python3-gpsd.sha256sum] = "570878c9df0b466d44576cbf37c811e491625632a30ab8f076babee27b98d91f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gpsd-3.26.1-3.el10_2.2.aarch64.rpm;name=aarch64_gpsd;unpack=0"
SRC_URI[aarch64_gpsd.sha256sum] = "937483ecca31381e198c2d57bee3f6becde729ba3e5b58345f3588e03c47d157"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gpsd-clients-3.26.1-3.el10_2.2.aarch64.rpm;name=aarch64_gpsd-clients;unpack=0"
SRC_URI[aarch64_gpsd-clients.sha256sum] = "0eb982b8925ccf1276c193678d47b10f14cf55124cebc2669903542ceaa848ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-gpsd-3.26.1-3.el10_2.2.aarch64.rpm;name=aarch64_python3-gpsd;unpack=0"
SRC_URI[aarch64_python3-gpsd.sha256sum] = "754d9d3f3bb210fd584d5f8abb8be11a318ec4fdee6fb2b71061845a6ace4126"

RDEPENDS:gpsd = " \
 bash \
 bluez-libs \
 dbus-libs \
 glibc \
 libusb1 \
 ncurses-libs \
 systemd \
 systemd-udev \
 "
RDEPENDS:gpsd-clients = " \
 bash \
 bluez-libs \
 dbus-libs \
 glibc \
 libusb1 \
 ncurses-libs \
 python3 \
 python3-gpsd \
 "
RDEPENDS:python3-gpsd = " \
 glibc \
 python3 \
 python3-pyserial \
 "
