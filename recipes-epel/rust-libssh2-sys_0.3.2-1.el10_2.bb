# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libssh2-sys"
PV = "0.3.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-libssh2-sys+default-devel \
 rust-libssh2-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libssh2-sys-0.3.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22dd20c4739f3f4e64222215f63aae58cc9d514667e131eda11613432c7bae92"

URI_x86_64_v2_rust-libssh2-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libssh2-sys+default-devel-0.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libssh2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libssh2-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libssh2-sys+default-devel.sha256sum] = "fbc3037d846eb20ae3a23565eca60b6730b9f6a8c5d4ff61be1b3904978be0ed"

URI_x86_64_v2_rust-libssh2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libssh2-sys-devel-0.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libssh2-sys-devel}"
SRC_URI[x86_64_v2_rust-libssh2-sys-devel.sha256sum] = "a69589956218fcb2313c3563346fda01bd80b83455863cd05fb899e4563f57fe"

URI_aarch64_rust-libssh2-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libssh2-sys+default-devel-0.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-libssh2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libssh2-sys+default-devel}"
SRC_URI[aarch64_rust-libssh2-sys+default-devel.sha256sum] = "0102d264c9d7255b136b428e5db4266e64ca046db6d7c5d52cc46ff7007798a0"

URI_aarch64_rust-libssh2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libssh2-sys-devel-0.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libssh2-sys-devel}"
SRC_URI[aarch64_rust-libssh2-sys-devel.sha256sum] = "3575c2dde7e599e8af1414b4edb1096d73633de427bada7dc0c7e366a54ca330"

RDEPENDS:rust-libssh2-sys+default-devel = " \
 cargo \
 rust-libssh2-sys-devel \
 "
RDEPENDS:rust-libssh2-sys-devel = " \
 cargo \
 libssh2-devel \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-openssl-sys+default-devel \
 rust-pkg-config+default-devel \
 "
