# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-aws-v4"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-reqsign-aws-v4+default-devel \
 rust-reqsign-aws-v4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-aws-v4-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07151d2c63229a3903da539f49b2b27d44466ca118a4d4be5f1273636a0dc360"

URI_x86_64_v2_rust-reqsign-aws-v4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aws-v4+default-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aws-v4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-aws-v4+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-aws-v4+default-devel.sha256sum] = "2a8bc65ebd052e853a718fd62aaf8527144b2760faa6b31038452c9ad493c8b0"

URI_x86_64_v2_rust-reqsign-aws-v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aws-v4-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aws-v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-aws-v4-devel}"
SRC_URI[x86_64_v2_rust-reqsign-aws-v4-devel.sha256sum] = "7f45921f9b7f5d908495f89956b3485b4dac31fd9ff8ee809eac63c8d3a60402"

URI_aarch64_rust-reqsign-aws-v4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aws-v4+default-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-aws-v4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-aws-v4+default-devel}"
SRC_URI[aarch64_rust-reqsign-aws-v4+default-devel.sha256sum] = "d93c0c7d47081cd4986d708689fd0c6aef5766e64f26fdcd88b0a7f73e017ae6"

URI_aarch64_rust-reqsign-aws-v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aws-v4-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-aws-v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-aws-v4-devel}"
SRC_URI[aarch64_rust-reqsign-aws-v4-devel.sha256sum] = "f795af62ad8ae6d621c2e820850dd4906eb6689f5ad38b16d002014ea649a55f"

RDEPENDS:rust-reqsign-aws-v4+default-devel = " \
 cargo \
 rust-reqsign-aws-v4-devel \
 "
RDEPENDS:rust-reqsign-aws-v4-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-bytes+default-devel \
 rust-form_urlencoded+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-quick-xml+default-devel \
 rust-quick-xml+serialize-devel \
 rust-reqsign-core+default-devel \
 rust-rust-ini+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_urlencoded+default-devel \
 rust-sha1+default-devel \
 "
