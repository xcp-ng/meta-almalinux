# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-session"
PV = "46.0"
PR = "10.el10"
PACKAGES = " \
 gnome-session \
 gnome-session-wayland-session \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-session-46.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78ec3b17379fda713429c4dfebd7e449116c59c25f2a672853102b163ac3e465"

URI_x86_64_v2_gnome-session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-session-46.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-session}"
SRC_URI[x86_64_v2_gnome-session.sha256sum] = "54ed231b316744bec6bd15ab0c589edb01c763dfd1b00a274731742e664fc7f1"

URI_x86_64_v2_gnome-session-wayland-session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-session-wayland-session-46.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-session-wayland-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-session-wayland-session}"
SRC_URI[x86_64_v2_gnome-session-wayland-session.sha256sum] = "29380228c6dd42f2e89ed4664c9c6dd0171b736e32b72f3ecd9b7fc46bd826cc"

URI_aarch64_gnome-session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-session-46.0-10.el10.aarch64.rpm;name=aarch64_gnome-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-session}"
SRC_URI[aarch64_gnome-session.sha256sum] = "6b366a1b3b6515a530f068dea68366ce33df2f9de155789831383f9343108499"

URI_aarch64_gnome-session-wayland-session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-session-wayland-session-46.0-10.el10.aarch64.rpm;name=aarch64_gnome-session-wayland-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-session-wayland-session}"
SRC_URI[aarch64_gnome-session-wayland-session.sha256sum] = "59e076ad244af5500008617a16a37c6e5dc20e5a01f310173db5ac9b48c89c9b"

RDEPENDS:gnome-session = " \
 almalinux-logos \
 bash \
 dbus \
 dconf \
 glib2 \
 glibc \
 gnome-control-center-filesystem \
 gnome-desktop3 \
 gsettings-desktop-schemas \
 gtk3 \
 json-glib \
 libICE \
 libSM \
 libX11 \
 libXcomposite \
 libepoxy \
 libgcc \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 systemd-libs \
 "
RDEPENDS:gnome-session-wayland-session = " \
 gnome-session \
 gnome-shell \
 xorg-x11-server-Xwayland \
 "
