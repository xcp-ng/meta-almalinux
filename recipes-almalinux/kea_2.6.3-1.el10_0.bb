# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kea"
PV = "2.6.3"
PR = "1.el10_0"
PACKAGES = " \
 kea \
 kea-doc \
 kea-hooks \
 kea-keama \
 kea-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kea-2.6.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97d13231468132bc81b4197f0601953e4a1a86a58208ffd18c54adda124d9547"

URI_x86_64_v2_kea = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kea-2.6.3-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kea;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea}"
SRC_URI[x86_64_v2_kea.sha256sum] = "ebc0cab64755d5cc3ecff197789165e4825b50242609e4be87f6a4e655c46b39"

URI_x86_64_v2_kea-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kea-doc-2.6.3-1.el10_0.noarch.rpm;name=x86_64_v2_kea-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-doc}"
SRC_URI[x86_64_v2_kea-doc.sha256sum] = "ab452a69b5f245b954d573ecd533f02e48f97330ace10abf6066632e389e1bb3"

URI_x86_64_v2_kea-hooks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kea-hooks-2.6.3-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kea-hooks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-hooks}"
SRC_URI[x86_64_v2_kea-hooks.sha256sum] = "88e75cedec3e34b3aaf7b6d24f16fc7fbde1f010429f0cbade628ac10bd1e817"

URI_x86_64_v2_kea-keama = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kea-keama-2.6.3-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kea-keama;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-keama}"
SRC_URI[x86_64_v2_kea-keama.sha256sum] = "e5356d0455482c61a3f83b529a9df63b46b86eebf1db32a8e34f37d9eaef347c"

URI_x86_64_v2_kea-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kea-libs-2.6.3-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kea-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-libs}"
SRC_URI[x86_64_v2_kea-libs.sha256sum] = "ea5486fff0f9949ebcb54f480b9c0d84cc2c6474e78aabe86748f600f87ebd60"

URI_aarch64_kea = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kea-2.6.3-1.el10_0.aarch64.rpm;name=aarch64_kea;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea}"
SRC_URI[aarch64_kea.sha256sum] = "987339e702e313e4e3cf63c31387e1d20c84549f6747f234d379d23dfade30e0"

URI_aarch64_kea-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kea-doc-2.6.3-1.el10_0.noarch.rpm;name=aarch64_kea-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-doc}"
SRC_URI[aarch64_kea-doc.sha256sum] = "ab452a69b5f245b954d573ecd533f02e48f97330ace10abf6066632e389e1bb3"

URI_aarch64_kea-hooks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kea-hooks-2.6.3-1.el10_0.aarch64.rpm;name=aarch64_kea-hooks;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-hooks}"
SRC_URI[aarch64_kea-hooks.sha256sum] = "9916e5072c2d3f29580789a8402e5c743a95a248a5bde0f7fb338e2657dc8540"

URI_aarch64_kea-keama = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kea-keama-2.6.3-1.el10_0.aarch64.rpm;name=aarch64_kea-keama;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-keama}"
SRC_URI[aarch64_kea-keama.sha256sum] = "39f344e3b8f0e63b2d04a432ef28f7ddd70fb708ee66730c7e5560c035da5b9a"

URI_aarch64_kea-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kea-libs-2.6.3-1.el10_0.aarch64.rpm;name=aarch64_kea-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-libs}"
SRC_URI[aarch64_kea-libs.sha256sum] = "e353acb41dd5273989533573a0add6b3f35aea8af025a58a16b044b7200f7c18"

RDEPENDS:kea = " \
 bash \
 glibc \
 kea-libs \
 libgcc \
 libstdc++ \
 openssl-libs \
 python3 \
 shadow-utils \
 systemd \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:kea-doc = " \
 "
RDEPENDS:kea-hooks = " \
 boost-system \
 glibc \
 kea-libs \
 libgcc \
 libpq \
 log4cplus \
 mariadb-connector-c \
 openssl-libs \
 "
RDEPENDS:kea-keama = " \
 glibc \
 "
RDEPENDS:kea-libs = " \
 boost-system \
 glibc \
 libgcc \
 libpq \
 libstdc++ \
 log4cplus \
 mariadb-connector-c \
 openssl-libs \
 "
