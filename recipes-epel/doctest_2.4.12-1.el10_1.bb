# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "doctest"
PV = "2.4.12"
PR = "1.el10_1"
PACKAGES = " \
 doctest-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/doctest-2.4.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0a5771c3991723e4a429396b6f599e07c5b3b68d3260dbeb197b748cb3a25e5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/doctest-devel-2.4.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_doctest-devel;unpack=0"
SRC_URI[x86_64_v2_doctest-devel.sha256sum] = "e738ba555bb236b4f304a4accf20a1b4f69c1f15c867983e56239d37724aed23"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/doctest-devel-2.4.12-1.el10_1.aarch64.rpm;name=aarch64_doctest-devel;unpack=0"
SRC_URI[aarch64_doctest-devel.sha256sum] = "83f6841533895fd8a9cf111fa2df74fc9db482bb4fe5ee0714a23c05d5993445"

RDEPENDS:doctest-devel = " \
 cmake-filesystem \
 libstdc++-devel \
 "
