# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aribb25"
PV = "0.2.7"
PR = "4.el10_0"
PACKAGES = " \
 aribb25 \
 aribb25-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aribb25-0.2.7-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60f0f3efc4f20ce3681debec1b34ad281bbc496a7032d0532948b97ed8a69908"

URI_x86_64_v2_aribb25 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aribb25-0.2.7-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aribb25;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aribb25}"
SRC_URI[x86_64_v2_aribb25.sha256sum] = "b43be171270458cbb7cc1acb6ca93e52f74a974eb3e127ad98890fe59f203126"

URI_x86_64_v2_aribb25-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aribb25-devel-0.2.7-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aribb25-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aribb25-devel}"
SRC_URI[x86_64_v2_aribb25-devel.sha256sum] = "e5bf53f0000be5dfd3985b7b7722677f5bba610993c5ca9af0d92268dcd88f97"

URI_aarch64_aribb25 = "${EPEL_MIRROR}/aarch64/Packages/a/aribb25-0.2.7-4.el10_0.aarch64.rpm;name=aarch64_aribb25;unpack=0"
SRC_URI:append = " ${URI_aarch64_aribb25}"
SRC_URI[aarch64_aribb25.sha256sum] = "46c7f7c60a475d36aab9e68eb4d7c286d37d7e908656b2b1dddbf3d1e561e9d6"

URI_aarch64_aribb25-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aribb25-devel-0.2.7-4.el10_0.aarch64.rpm;name=aarch64_aribb25-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aribb25-devel}"
SRC_URI[aarch64_aribb25-devel.sha256sum] = "aaecc33316d758485dfc8cd9c6943440066122b893c13b1c5793ad1dbdc569cf"

RDEPENDS:aribb25 = " \
 glibc \
 "
RDEPENDS:aribb25-devel = " \
 aribb25 \
 pcsc-lite-devel \
 pkgconf-pkg-config \
 "
