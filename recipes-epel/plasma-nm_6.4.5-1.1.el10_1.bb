# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-nm"
PV = "6.4.5"
PR = "1.1.el10_1"
PACKAGES = " \
 plasma-nm \
 plasma-nm-l2tp \
 plasma-nm-openconnect \
 plasma-nm-openswan \
 plasma-nm-openvpn \
 plasma-nm-pptp \
 plasma-nm-strongswan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-nm-6.4.5-1.1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "decf94bc332df7a4eed27e38d98b1f262a060a409daf78a3fc3b690c393aeaaf"

URI_x86_64_v2_plasma-nm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-6.4.5-1.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm}"
SRC_URI[x86_64_v2_plasma-nm.sha256sum] = "9e1db8ccfe1d49f14f858961667ba85801fcd69ac45be1db98f4f242b3e1f91c"

URI_x86_64_v2_plasma-nm-l2tp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-l2tp-6.4.5-1.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-l2tp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-l2tp}"
SRC_URI[x86_64_v2_plasma-nm-l2tp.sha256sum] = "8333e3cd017b30a931d2a1c5665d5a773700480ae43a39af9d8c3b34cfba259f"

URI_x86_64_v2_plasma-nm-openconnect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openconnect-6.4.5-1.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openconnect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-openconnect}"
SRC_URI[x86_64_v2_plasma-nm-openconnect.sha256sum] = "98313a0c176d2bd4e9eee75787ad17fa9ee71f10fb64b978249aa017f2fa08df"

URI_x86_64_v2_plasma-nm-openswan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openswan-6.4.5-1.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-openswan}"
SRC_URI[x86_64_v2_plasma-nm-openswan.sha256sum] = "d0364dcf411dfefe6d0d5b17c7af932612e2313f14e0f2b33d81a5602cbde5e9"

URI_x86_64_v2_plasma-nm-openvpn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openvpn-6.4.5-1.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openvpn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-openvpn}"
SRC_URI[x86_64_v2_plasma-nm-openvpn.sha256sum] = "00215e7a6955974771940070300f3b85b5e7d170c02f49ac129ac81d2cbd31e8"

URI_x86_64_v2_plasma-nm-pptp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-pptp-6.4.5-1.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-pptp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-pptp}"
SRC_URI[x86_64_v2_plasma-nm-pptp.sha256sum] = "a4bd52f20c6556e717d88ebd1ad5e5f70800e4df1c4000eb5250c8e4f7779851"

URI_x86_64_v2_plasma-nm-strongswan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-strongswan-6.4.5-1.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-strongswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-strongswan}"
SRC_URI[x86_64_v2_plasma-nm-strongswan.sha256sum] = "858c0447d08c900550f89faf0db779a51e6fb41c60eebe572a8835574474504b"

URI_aarch64_plasma-nm = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-6.4.5-1.1.el10_1.aarch64.rpm;name=aarch64_plasma-nm;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm}"
SRC_URI[aarch64_plasma-nm.sha256sum] = "6e63d0af044b7cf485a79ba28e72625d825dd11b55fab24c18f6f4ab94829c3c"

URI_aarch64_plasma-nm-l2tp = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-l2tp-6.4.5-1.1.el10_1.aarch64.rpm;name=aarch64_plasma-nm-l2tp;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-l2tp}"
SRC_URI[aarch64_plasma-nm-l2tp.sha256sum] = "c7bc9e809876fafe9cbaf5ab2f7487ed286448f1fea6eade649af1b072eca6c9"

URI_aarch64_plasma-nm-openconnect = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openconnect-6.4.5-1.1.el10_1.aarch64.rpm;name=aarch64_plasma-nm-openconnect;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-openconnect}"
SRC_URI[aarch64_plasma-nm-openconnect.sha256sum] = "4f769c2bac8a9c009d8979298446f85055283df8ed3911c398c263b68d44d665"

URI_aarch64_plasma-nm-openswan = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openswan-6.4.5-1.1.el10_1.aarch64.rpm;name=aarch64_plasma-nm-openswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-openswan}"
SRC_URI[aarch64_plasma-nm-openswan.sha256sum] = "0a8419f42cbd445fab618846cb538dbfade2f882a7e5ba6ff95ceb53e6a34793"

URI_aarch64_plasma-nm-openvpn = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openvpn-6.4.5-1.1.el10_1.aarch64.rpm;name=aarch64_plasma-nm-openvpn;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-openvpn}"
SRC_URI[aarch64_plasma-nm-openvpn.sha256sum] = "3a4a0ecf5adbb8c0e34f4d4b5fd099f01cee415a7eade97df360423e54a257cd"

URI_aarch64_plasma-nm-pptp = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-pptp-6.4.5-1.1.el10_1.aarch64.rpm;name=aarch64_plasma-nm-pptp;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-pptp}"
SRC_URI[aarch64_plasma-nm-pptp.sha256sum] = "15a1fce4cec613ab08e614c25c93a2618212d77704ceca449a00af7e27e6760b"

URI_aarch64_plasma-nm-strongswan = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-strongswan-6.4.5-1.1.el10_1.aarch64.rpm;name=aarch64_plasma-nm-strongswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-strongswan}"
SRC_URI[aarch64_plasma-nm-strongswan.sha256sum] = "566d7750a7b26fcab91492c278aef0766567e4cbe7fadc94b4b82cd637f19110"

RDEPENDS:plasma-nm = " \
 NetworkManager \
 NetworkManager-libnm \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-networkmanager-qt \
 kf6-prison \
 kf6-solid \
 libstdc++ \
 qca-qt6 \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-nm-l2tp = " \
 NetworkManager-l2tp \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-openconnect = " \
 NetworkManager-openconnect \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 openconnect \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:plasma-nm-openswan = " \
 NetworkManager-libreswan \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-openvpn = " \
 NetworkManager-libnm \
 NetworkManager-openvpn \
 glib2 \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-pptp = " \
 NetworkManager-pptp \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-strongswan = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 strongswan \
 "
