# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "publicsuffix-list"
PV = "20240107"
PR = "5.el10"
PACKAGES = " \
 publicsuffix-list \
 publicsuffix-list-dafsa \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/publicsuffix-list-20240107-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98c0e6464e0f18b5dfd478b855d3ff458fdb96a6280a0358ca9dd7b89ecf5fa6"

URI_x86_64_v2_publicsuffix-list = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/publicsuffix-list-20240107-5.el10.noarch.rpm;name=x86_64_v2_publicsuffix-list;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_publicsuffix-list}"
SRC_URI[x86_64_v2_publicsuffix-list.sha256sum] = "e2f83b49d223193ac36730c93b087cd8a38e8b5a548047ff160000b0b6673079"

URI_x86_64_v2_publicsuffix-list-dafsa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/publicsuffix-list-dafsa-20240107-5.el10.noarch.rpm;name=x86_64_v2_publicsuffix-list-dafsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_publicsuffix-list-dafsa}"
SRC_URI[x86_64_v2_publicsuffix-list-dafsa.sha256sum] = "95d8620d329756f24e4b12d4e63165fa50159be98dd1c2d84dcbb3284fb82e82"

URI_aarch64_publicsuffix-list = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/publicsuffix-list-20240107-5.el10.noarch.rpm;name=aarch64_publicsuffix-list;unpack=0"
SRC_URI:append = " ${URI_aarch64_publicsuffix-list}"
SRC_URI[aarch64_publicsuffix-list.sha256sum] = "e2f83b49d223193ac36730c93b087cd8a38e8b5a548047ff160000b0b6673079"

URI_aarch64_publicsuffix-list-dafsa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/publicsuffix-list-dafsa-20240107-5.el10.noarch.rpm;name=aarch64_publicsuffix-list-dafsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_publicsuffix-list-dafsa}"
SRC_URI[aarch64_publicsuffix-list-dafsa.sha256sum] = "95d8620d329756f24e4b12d4e63165fa50159be98dd1c2d84dcbb3284fb82e82"

RDEPENDS:publicsuffix-list = " \
 "
RDEPENDS:publicsuffix-list-dafsa = " \
 "
