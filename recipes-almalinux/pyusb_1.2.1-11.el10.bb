# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyusb"
PV = "1.2.1"
PR = "11.el10"
PACKAGES = " \
 python3-pyusb \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pyusb-1.2.1-11.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "be635740d69762216e3be55690a10da35fffc47b07f48e272b5358915be12c17"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyusb-1.2.1-11.el10.noarch.rpm;name=x86_64_v2_python3-pyusb;unpack=0"
SRC_URI[x86_64_v2_python3-pyusb.sha256sum] = "374bf9c3fa87947df85dd0a8a701e26a7609aed6a558fd07c036cbd2495e6f9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyusb-1.2.1-11.el10.noarch.rpm;name=aarch64_python3-pyusb;unpack=0"
SRC_URI[aarch64_python3-pyusb.sha256sum] = "374bf9c3fa87947df85dd0a8a701e26a7609aed6a558fd07c036cbd2495e6f9b"

RDEPENDS:python3-pyusb = " \
 libusb1 \
 python3 \
 "
