# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde-json-core"
PV = "0.6.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-serde-json-core+custom-error-messages-devel \
 rust-serde-json-core+default-devel \
 rust-serde-json-core+heapless-devel \
 rust-serde-json-core+std-devel \
 rust-serde-json-core-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-serde-json-core-0.6.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a2607a40a892385e92f60fbdeccd56a6b274e330a6afe818ba49042177e6a6ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-json-core+custom-error-messages-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-json-core+custom-error-messages-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde-json-core+custom-error-messages-devel.sha256sum] = "7ba46ada2efdac7927f72531d5d9b64e0c70fdf01700bac451221cf144987574"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-json-core+default-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-json-core+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde-json-core+default-devel.sha256sum] = "08f19dff167128f09d697ce4220cac217d1f6336f41479257caf63f20a639a59"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-json-core+heapless-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-json-core+heapless-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde-json-core+heapless-devel.sha256sum] = "6da092772e040b804832c5b05049409c0f596a8119506424c59408e12890b75b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-json-core+std-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-json-core+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde-json-core+std-devel.sha256sum] = "3de3e510d3b006fe5dfd247e5a7ab0e1cf1c209c4cb1a0752f209072161cc27e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-json-core-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-json-core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde-json-core-devel.sha256sum] = "fdb3db6fe52dd2afee469318e30e0845b94fc347335625e4865738354180a64a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-json-core+custom-error-messages-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-serde-json-core+custom-error-messages-devel;unpack=0"
SRC_URI[aarch64_rust-serde-json-core+custom-error-messages-devel.sha256sum] = "dab96ec02b1e92e238be8dd4d456ba1d10acafb1c1db1070fad5ce8c939bfa18"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-json-core+default-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-serde-json-core+default-devel;unpack=0"
SRC_URI[aarch64_rust-serde-json-core+default-devel.sha256sum] = "7a674e76923b517bab186ab5e4dc623301656e2b3beefa9a126529a337c04816"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-json-core+heapless-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-serde-json-core+heapless-devel;unpack=0"
SRC_URI[aarch64_rust-serde-json-core+heapless-devel.sha256sum] = "4243c09ffb963e251f92b47e6d072c93dae7b3058cf21bf2554bea0e14051d92"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-json-core+std-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-serde-json-core+std-devel;unpack=0"
SRC_URI[aarch64_rust-serde-json-core+std-devel.sha256sum] = "0a8dcb5ac764125500d806ffacaea1082c0489d0ea20613c4a7d89ae5398cf81"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-json-core-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-serde-json-core-devel;unpack=0"
SRC_URI[aarch64_rust-serde-json-core-devel.sha256sum] = "b0cd4e674f88d0bb650e5210e9e2de1024960199f41850b2eee7c550b1ef4b77"

RDEPENDS:rust-serde-json-core+custom-error-messages-devel = " \
 cargo \
 rust-serde-json-core+heapless-devel \
 rust-serde-json-core-devel \
 "
RDEPENDS:rust-serde-json-core+default-devel = " \
 cargo \
 rust-serde-json-core+heapless-devel \
 rust-serde-json-core-devel \
 "
RDEPENDS:rust-serde-json-core+heapless-devel = " \
 cargo \
 rust-heapless0.8+default-devel \
 rust-heapless0.8+serde-devel \
 rust-serde-json-core-devel \
 "
RDEPENDS:rust-serde-json-core+std-devel = " \
 cargo \
 rust-serde+std-devel \
 rust-serde-json-core-devel \
 "
RDEPENDS:rust-serde-json-core-devel = " \
 cargo \
 rust \
 rust-ryu+default-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
