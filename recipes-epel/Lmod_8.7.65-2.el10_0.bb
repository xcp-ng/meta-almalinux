# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "Lmod"
PV = "8.7.65"
PR = "2.el10_0"
PACKAGES = " \
 Lmod \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/Lmod-8.7.65-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf04a97081adc2d1f6e5e4f79c6fc09d5dfa5b1bc691bf797c026f085d001631"

URI_x86_64_v2_Lmod = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/Lmod-8.7.65-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_Lmod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_Lmod}"
SRC_URI[x86_64_v2_Lmod.sha256sum] = "d26c01c64a19defc2ec776d24774c40d3858b80e498e027e3cf2a7b105ec9537"
RPROVIDES:Lmod:x86_64_v2 = "virtual/environment_modules_"

URI_aarch64_Lmod = "${EPEL_MIRROR}/aarch64/Packages/l/Lmod-8.7.65-2.el10_0.aarch64.rpm;name=aarch64_Lmod;unpack=0"
SRC_URI:append = " ${URI_aarch64_Lmod}"
SRC_URI[aarch64_Lmod.sha256sum] = "9b8f169b1f7b4c8ecfdc3ea29c6074e0a4962a2fd6c52f5df5e2676d73eafc9e"
RPROVIDES:Lmod:aarch64 = "virtual/environment_modules_"

RDEPENDS:Lmod = " \
 alternatives \
 bash \
 glibc \
 lua-filesystem \
 lua-json \
 lua-posix \
 lua-term \
 procps-ng \
 tcl \
 virtual/coreutils \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/environment_modules_"

PROVIDES:append:aarch64 = " rpm/virtual/environment_modules_"
