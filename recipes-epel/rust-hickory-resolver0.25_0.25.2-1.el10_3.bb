# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-resolver0.25"
PV = "0.25.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-hickory-resolver0.25+backtrace-devel \
 rust-hickory-resolver0.25+default-devel \
 rust-hickory-resolver0.25+rustls-platform-verifier-devel \
 rust-hickory-resolver0.25+serde-devel \
 rust-hickory-resolver0.25+system-config-devel \
 rust-hickory-resolver0.25+tokio-devel \
 rust-hickory-resolver0.25+webpki-roots-devel \
 rust-hickory-resolver0.25-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-resolver0.25-0.25.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "821f14fd156e4e004ec209fbd36f79290379f24f45c24e8ef777130da079863f"

URI_x86_64_v2_rust-hickory-resolver0.25+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.25+backtrace-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.25+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.25+backtrace-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.25+backtrace-devel.sha256sum] = "2d09cc855a90064b573941b4f0d780a7e16cb443d0990a6034597d3f25c0f7fb"

URI_x86_64_v2_rust-hickory-resolver0.25+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.25+default-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.25+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.25+default-devel.sha256sum] = "a34b380bbc73315c27e29bb09b18a2ef5f921fd4d841fa2769ae7014f52ebf04"

URI_x86_64_v2_rust-hickory-resolver0.25+rustls-platform-verifier-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.25+rustls-platform-verifier-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.25+rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.25+rustls-platform-verifier-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.25+rustls-platform-verifier-devel.sha256sum] = "b427c5f04e404cfcfce9ba5d307a3dce56f3e84f4bd424cd82849876d9013db0"

URI_x86_64_v2_rust-hickory-resolver0.25+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.25+serde-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.25+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.25+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.25+serde-devel.sha256sum] = "3c8d39d45a72e06a57808c03dcc5b3ba8a58f1c07ec79b85fe4f5a9187b8ffde"

URI_x86_64_v2_rust-hickory-resolver0.25+system-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.25+system-config-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.25+system-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.25+system-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.25+system-config-devel.sha256sum] = "999df995f35165d78563da33323cce5df1e29c41d4ae08165c37eb5851c22890"

URI_x86_64_v2_rust-hickory-resolver0.25+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.25+tokio-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.25+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.25+tokio-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.25+tokio-devel.sha256sum] = "72ed8f7191ab95bbdc8ce235525b0ce6bb3bea480dd9ee7b8eb7de897f8b36d4"

URI_x86_64_v2_rust-hickory-resolver0.25+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.25+webpki-roots-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.25+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.25+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.25+webpki-roots-devel.sha256sum] = "91232a230446ca589f1a09ba49f7267b4862e665386cb9495159d488608d2e10"

URI_x86_64_v2_rust-hickory-resolver0.25-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver0.25-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver0.25-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver0.25-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver0.25-devel.sha256sum] = "0748e6463386948964e72aeef14bdc3f6810eb132f40d966fc489453460dae9b"

URI_aarch64_rust-hickory-resolver0.25+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.25+backtrace-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver0.25+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.25+backtrace-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.25+backtrace-devel.sha256sum] = "d70b4ed4abe2b0ea58ad470ed29b4b4cd48aa8cbbbe03b18667ff9967056b7de"

URI_aarch64_rust-hickory-resolver0.25+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.25+default-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.25+default-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.25+default-devel.sha256sum] = "59068182e26f8ab86aeb6476cc8f1a304d714f79b6d5fc707c8ec3c5b78cdae5"

URI_aarch64_rust-hickory-resolver0.25+rustls-platform-verifier-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.25+rustls-platform-verifier-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver0.25+rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.25+rustls-platform-verifier-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.25+rustls-platform-verifier-devel.sha256sum] = "90272fe7a05ce72c86f54f08f75cea15cd5c3997bb4be457e12d9979e2425503"

URI_aarch64_rust-hickory-resolver0.25+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.25+serde-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver0.25+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.25+serde-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.25+serde-devel.sha256sum] = "5df17a1f2c4eacef3edf9d3e42148e7effb6b406c0b31a2c8187efc9ab61a7ee"

URI_aarch64_rust-hickory-resolver0.25+system-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.25+system-config-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver0.25+system-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.25+system-config-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.25+system-config-devel.sha256sum] = "884978085e04bc3b362ecf0b2924be8721efbee69222f45e279ad39bd8b929e5"

URI_aarch64_rust-hickory-resolver0.25+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.25+tokio-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver0.25+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.25+tokio-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.25+tokio-devel.sha256sum] = "f9ead515e2b3d04a4619992b2ce7e45fb356cbad6ed844dff915de1c5cee2a0c"

URI_aarch64_rust-hickory-resolver0.25+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.25+webpki-roots-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver0.25+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.25+webpki-roots-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.25+webpki-roots-devel.sha256sum] = "acb9351c93c47fd95fdee1662757e00e2e4a798689365944464c43a00cdcc35d"

URI_aarch64_rust-hickory-resolver0.25-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver0.25-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver0.25-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver0.25-devel}"
SRC_URI[aarch64_rust-hickory-resolver0.25-devel.sha256sum] = "3387e782c2481f0837e2117bf7dcb5a7105c3026e1d6195ffaedcacd8b9d8cff"

RDEPENDS:rust-hickory-resolver0.25+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-hickory-proto0.25+backtrace-devel \
 rust-hickory-resolver0.25-devel \
 "
RDEPENDS:rust-hickory-resolver0.25+default-devel = " \
 cargo \
 rust-hickory-resolver0.25+system-config-devel \
 rust-hickory-resolver0.25+tokio-devel \
 rust-hickory-resolver0.25-devel \
 "
RDEPENDS:rust-hickory-resolver0.25+rustls-platform-verifier-devel = " \
 cargo \
 rust-hickory-proto0.25+rustls-platform-verifier-devel \
 rust-hickory-resolver0.25-devel \
 "
RDEPENDS:rust-hickory-resolver0.25+serde-devel = " \
 cargo \
 rust-hickory-proto0.25+serde-devel \
 rust-hickory-resolver0.25-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 "
RDEPENDS:rust-hickory-resolver0.25+system-config-devel = " \
 cargo \
 rust-hickory-resolver0.25-devel \
 rust-resolv-conf+default-devel \
 rust-resolv-conf+system-devel \
 "
RDEPENDS:rust-hickory-resolver0.25+tokio-devel = " \
 cargo \
 rust-hickory-proto0.25+tokio-devel \
 rust-hickory-resolver0.25-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 "
RDEPENDS:rust-hickory-resolver0.25+webpki-roots-devel = " \
 cargo \
 rust-hickory-proto0.25+webpki-roots-devel \
 rust-hickory-resolver0.25-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-hickory-resolver0.25-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-hickory-proto0.25+std-devel \
 rust-hickory-proto0.25-devel \
 rust-moka+default-devel \
 rust-moka+sync-devel \
 rust-once_cell+critical-section-devel \
 rust-once_cell-devel \
 rust-parking_lot+default-devel \
 rust-rand0.9+alloc-devel \
 rust-rand0.9-devel \
 rust-smallvec+default-devel \
 rust-thiserror-devel \
 rust-tracing-devel \
 "
