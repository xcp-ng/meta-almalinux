# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgpg"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kgpg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgpg-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5a14ca5014b9bae9ddca07aac08bda15cbb0aa00e67f8c2cc6df579ae49a43f"

URI_x86_64_v2_kgpg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgpg-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgpg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgpg}"
SRC_URI[x86_64_v2_kgpg.sha256sum] = "b37e0de70748d9c4882bad9ea4a84b2ae5b5e63e1d30f9702e2455ff13d617a5"

URI_aarch64_kgpg = "${EPEL_MIRROR}/aarch64/Packages/k/kgpg-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kgpg;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgpg}"
SRC_URI[aarch64_kgpg.sha256sum] = "0d344f79545eedf237f1b2d753eebef1d5fc203d571eb5c97ecce66cb24063ca"

RDEPENDS:kgpg = " \
 akonadi-contacts \
 akonadi-server \
 glibc \
 gnupg2 \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
