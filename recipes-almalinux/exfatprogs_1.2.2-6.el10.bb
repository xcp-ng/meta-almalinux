# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "exfatprogs"
PV = "1.2.2"
PR = "6.el10"
PACKAGES = " \
 exfatprogs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/exfatprogs-1.2.2-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39cf36fa1954a2018fc751a91b0c46a49599ff4efb4186160f451a0826a3e578"

URI_x86_64_v2_exfatprogs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/exfatprogs-1.2.2-6.el10.x86_64_v2.rpm;name=x86_64_v2_exfatprogs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_exfatprogs}"
SRC_URI[x86_64_v2_exfatprogs.sha256sum] = "33778fee8bc70a338b3af8fb537bf90c35e222f91be4a192a5006550a9572a24"

URI_aarch64_exfatprogs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/exfatprogs-1.2.2-6.el10.aarch64.rpm;name=aarch64_exfatprogs;unpack=0"
SRC_URI:append = " ${URI_aarch64_exfatprogs}"
SRC_URI[aarch64_exfatprogs.sha256sum] = "6c0fa7cc1fbab202a0a252d17dc99777a37c2286a6a0401284553d5b8c9f1837"

RDEPENDS:exfatprogs = " \
 glibc \
 "
