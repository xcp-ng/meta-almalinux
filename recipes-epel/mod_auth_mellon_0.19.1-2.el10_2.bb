# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_auth_mellon"
PV = "0.19.1"
PR = "2.el10_2"
PACKAGES = " \
 mod_auth_mellon \
 mod_auth_mellon-diagnostics \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mod_auth_mellon-0.19.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1e10e43a7232b9ef59aeb59b11f5e3d2aa8999f55a50d8176048f7e85b4110d"

URI_x86_64_v2_mod_auth_mellon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mod_auth_mellon-0.19.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mod_auth_mellon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_auth_mellon}"
SRC_URI[x86_64_v2_mod_auth_mellon.sha256sum] = "bab93574edee5973783826915f53d08835134bcd965ab9b503e7561f5ef43210"

URI_x86_64_v2_mod_auth_mellon-diagnostics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mod_auth_mellon-diagnostics-0.19.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mod_auth_mellon-diagnostics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_auth_mellon-diagnostics}"
SRC_URI[x86_64_v2_mod_auth_mellon-diagnostics.sha256sum] = "265f5dc42a439455e81a9a087aa7ce1e56ecc65354b32394455c0a53b06f1b0e"

URI_aarch64_mod_auth_mellon = "${EPEL_MIRROR}/aarch64/Packages/m/mod_auth_mellon-0.19.1-2.el10_2.aarch64.rpm;name=aarch64_mod_auth_mellon;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_auth_mellon}"
SRC_URI[aarch64_mod_auth_mellon.sha256sum] = "0e46ed174bbb5255c9ea42ea1935420a0f21763490c3ce8d4f7df24d0c12ee68"

URI_aarch64_mod_auth_mellon-diagnostics = "${EPEL_MIRROR}/aarch64/Packages/m/mod_auth_mellon-diagnostics-0.19.1-2.el10_2.aarch64.rpm;name=aarch64_mod_auth_mellon-diagnostics;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_auth_mellon-diagnostics}"
SRC_URI[aarch64_mod_auth_mellon-diagnostics.sha256sum] = "ede30449eacef163ce86eb8ef4a5e1dacf11d50f13b442ab2848bb55766fcee8"

RDEPENDS:mod_auth_mellon = " \
 bash \
 glib2 \
 glibc \
 httpd-core \
 lasso \
 libtool-ltdl \
 libxml2 \
 libxslt \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 xmlsec1 \
 xmlsec1-openssl \
 "
RDEPENDS:mod_auth_mellon-diagnostics = " \
 glib2 \
 glibc \
 lasso \
 libtool-ltdl \
 libxml2 \
 libxslt \
 mod_auth_mellon \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 xmlsec1 \
 xmlsec1-openssl \
 "
