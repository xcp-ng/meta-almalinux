# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ffmpegthumbs"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ffmpegthumbs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/ffmpegthumbs-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df6e8e19e56c67d01e70490d39a2994a24571b65042119978bdbc10a85d08abf"

URI_x86_64_v2_ffmpegthumbs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ffmpegthumbs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ffmpegthumbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ffmpegthumbs}"
SRC_URI[x86_64_v2_ffmpegthumbs.sha256sum] = "2214420f8f770599b239e729b8224788609cc895e3ca1f9c713995f6a9faaccc"

URI_aarch64_ffmpegthumbs = "${EPEL_MIRROR}/aarch64/Packages/f/ffmpegthumbs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ffmpegthumbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ffmpegthumbs}"
SRC_URI[aarch64_ffmpegthumbs.sha256sum] = "f425ba4a6a3675b709693684cf98f094ae0355e28528f6e7346467780347c4e8"

RDEPENDS:ffmpegthumbs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libstdc++ \
 libswscale-free \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
