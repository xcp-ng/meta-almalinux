# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "heimdal"
PV = "7.8.0"
PR = "26.el10_2"
PACKAGES = " \
 heimdal-devel \
 heimdal-libs \
 heimdal-path \
 heimdal-server \
 heimdal-static \
 heimdal-workstation \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/heimdal-7.8.0-26.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3dbff80c0e9f39e27fa7e3dd28919b54107f8b38486b58eb662a524ccae0335"

URI_x86_64_v2_heimdal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heimdal-devel-7.8.0-26.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heimdal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_heimdal-devel}"
SRC_URI[x86_64_v2_heimdal-devel.sha256sum] = "bd287b82a17a68159dcd210ccaef621c5ca871d5ccac921de803d525be814227"

URI_x86_64_v2_heimdal-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heimdal-libs-7.8.0-26.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heimdal-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_heimdal-libs}"
SRC_URI[x86_64_v2_heimdal-libs.sha256sum] = "ec438da0a763c0ad674fc5c04829296317641d97568389c3485baa5b943a4ba5"

URI_x86_64_v2_heimdal-path = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heimdal-path-7.8.0-26.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heimdal-path;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_heimdal-path}"
SRC_URI[x86_64_v2_heimdal-path.sha256sum] = "378b59534caa83117a3f46615e26b38415e080754174ecfa1d8cd8131e704060"

URI_x86_64_v2_heimdal-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heimdal-server-7.8.0-26.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heimdal-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_heimdal-server}"
SRC_URI[x86_64_v2_heimdal-server.sha256sum] = "dc18d531cc73a508d4664e5d6c25d4cb9d3601b216c05c57136bfb729739bfbe"

URI_x86_64_v2_heimdal-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heimdal-static-7.8.0-26.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heimdal-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_heimdal-static}"
SRC_URI[x86_64_v2_heimdal-static.sha256sum] = "dc9edabff1711aa6804a55b156c164b8ee210820985b430e2353e6cc5f62a151"

URI_x86_64_v2_heimdal-workstation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/heimdal-workstation-7.8.0-26.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_heimdal-workstation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_heimdal-workstation}"
SRC_URI[x86_64_v2_heimdal-workstation.sha256sum] = "60940c59f66c02b758da3401ec99f24fd8079a55d66d25fa1be40fe564c510c4"

URI_aarch64_heimdal-devel = "${EPEL_MIRROR}/aarch64/Packages/h/heimdal-devel-7.8.0-26.el10_2.aarch64.rpm;name=aarch64_heimdal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_heimdal-devel}"
SRC_URI[aarch64_heimdal-devel.sha256sum] = "0a83b40341b421d4aeeff0ab8aa458a1bf0d4ffa32e15790d48bc8c1e4906e1c"

URI_aarch64_heimdal-libs = "${EPEL_MIRROR}/aarch64/Packages/h/heimdal-libs-7.8.0-26.el10_2.aarch64.rpm;name=aarch64_heimdal-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_heimdal-libs}"
SRC_URI[aarch64_heimdal-libs.sha256sum] = "4518b97cddd6826b0f63a6250aecf83264d919ee0719ed0e58cfb9f94447af0e"

URI_aarch64_heimdal-path = "${EPEL_MIRROR}/aarch64/Packages/h/heimdal-path-7.8.0-26.el10_2.aarch64.rpm;name=aarch64_heimdal-path;unpack=0"
SRC_URI:append = " ${URI_aarch64_heimdal-path}"
SRC_URI[aarch64_heimdal-path.sha256sum] = "fc1a147c707918eb8d927f0e54dc2783e1ed8ccf84d5c3808406e4159bb2437c"

URI_aarch64_heimdal-server = "${EPEL_MIRROR}/aarch64/Packages/h/heimdal-server-7.8.0-26.el10_2.aarch64.rpm;name=aarch64_heimdal-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_heimdal-server}"
SRC_URI[aarch64_heimdal-server.sha256sum] = "31e37d393316e15ab01be962d4f9cd021ea0224130999bea0cd182eb547d8516"

URI_aarch64_heimdal-static = "${EPEL_MIRROR}/aarch64/Packages/h/heimdal-static-7.8.0-26.el10_2.aarch64.rpm;name=aarch64_heimdal-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_heimdal-static}"
SRC_URI[aarch64_heimdal-static.sha256sum] = "771f8f6b02c2d73a9f94af4ac9fd76561e2e014df3410d52666319bf2b657b07"

URI_aarch64_heimdal-workstation = "${EPEL_MIRROR}/aarch64/Packages/h/heimdal-workstation-7.8.0-26.el10_2.aarch64.rpm;name=aarch64_heimdal-workstation;unpack=0"
SRC_URI:append = " ${URI_aarch64_heimdal-workstation}"
SRC_URI[aarch64_heimdal-workstation.sha256sum] = "91ad19b23fc54a999e5cb851ed97f01eeed1d40680a95f2bcbf47aa4a7b259b5"

RDEPENDS:heimdal-devel = " \
 bash \
 glibc \
 heimdal-libs \
 libcom_err \
 "
RDEPENDS:heimdal-libs = " \
 glibc \
 info \
 libcom_err \
 libdb \
 libedit \
 libxcrypt \
 ncurses-libs \
 openldap \
 sqlite-libs \
 "
RDEPENDS:heimdal-path = " \
 heimdal-libs \
 setup \
 "
RDEPENDS:heimdal-server = " \
 bash \
 glibc \
 heimdal-libs \
 libcap-ng \
 logrotate \
 systemd \
 "
RDEPENDS:heimdal-static = " \
 heimdal-devel \
 "
RDEPENDS:heimdal-workstation = " \
 glibc \
 heimdal-libs \
 libedit \
 libxcrypt \
 "
