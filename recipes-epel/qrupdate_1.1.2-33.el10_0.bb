# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qrupdate"
PV = "1.1.2"
PR = "33.el10_0"
PACKAGES = " \
 qrupdate \
 qrupdate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qrupdate-1.1.2-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c74f279a59a50868b657890ab0621f8edba42f8a67fbc1886fcc5188f055527"

URI_x86_64_v2_qrupdate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qrupdate-1.1.2-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qrupdate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qrupdate}"
SRC_URI[x86_64_v2_qrupdate.sha256sum] = "c9153cdb4eea68912177e8223ef091db6438dfc1a52e3fb63825e4ed5264f8f9"

URI_x86_64_v2_qrupdate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qrupdate-devel-1.1.2-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qrupdate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qrupdate-devel}"
SRC_URI[x86_64_v2_qrupdate-devel.sha256sum] = "39f84c260a001536ba2ae88f937ed86c4f1f96a7f626e4844d24522d7bd5d219"

URI_aarch64_qrupdate = "${EPEL_MIRROR}/aarch64/Packages/q/qrupdate-1.1.2-33.el10_0.aarch64.rpm;name=aarch64_qrupdate;unpack=0"
SRC_URI:append = " ${URI_aarch64_qrupdate}"
SRC_URI[aarch64_qrupdate.sha256sum] = "bf07c7d95ad6cbd31d854820654e1d9d6b439147d1c84830b133a00f3c375a8c"

URI_aarch64_qrupdate-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qrupdate-devel-1.1.2-33.el10_0.aarch64.rpm;name=aarch64_qrupdate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qrupdate-devel}"
SRC_URI[aarch64_qrupdate-devel.sha256sum] = "0a29091531646d38e60f482b8c95583d5adb0b46a72cc25f8371fafd04fa1650"

RDEPENDS:qrupdate = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 "
RDEPENDS:qrupdate-devel = " \
 flexiblas-devel \
 qrupdate \
 "
