# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xorg-x11-xtrans-devel"
PV = "1.6.0"
PR = "1.el10"
PACKAGES = " \
 xorg-x11-xtrans-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/xorg-x11-xtrans-devel-1.6.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5403ce2f6b284db39355728db5a249c277bc70f4eb9127d3d8f052de2ab112d2"

URI_x86_64_v2_xorg-x11-xtrans-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xorg-x11-xtrans-devel-1.6.0-1.el10.noarch.rpm;name=x86_64_v2_xorg-x11-xtrans-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-xtrans-devel}"
SRC_URI[x86_64_v2_xorg-x11-xtrans-devel.sha256sum] = "c30bcf184991f3f30a3880db801251fe8def3ed9b5e470baca3b0a95e49fb4fe"

URI_aarch64_xorg-x11-xtrans-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xorg-x11-xtrans-devel-1.6.0-1.el10.noarch.rpm;name=aarch64_xorg-x11-xtrans-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-xtrans-devel}"
SRC_URI[aarch64_xorg-x11-xtrans-devel.sha256sum] = "c30bcf184991f3f30a3880db801251fe8def3ed9b5e470baca3b0a95e49fb4fe"

RDEPENDS:xorg-x11-xtrans-devel = " \
 pkgconf-pkg-config \
 "
