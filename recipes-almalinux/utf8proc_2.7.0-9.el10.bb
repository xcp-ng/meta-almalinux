# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "utf8proc"
PV = "2.7.0"
PR = "9.el10"
PACKAGES = " \
 utf8proc \
 utf8proc-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/utf8proc-2.7.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "053423837222f11374cfa77b7b4152002dd7b6bca6ae23ab9458f0cea94ea5d3"

URI_x86_64_v2_utf8proc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/utf8proc-2.7.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_utf8proc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_utf8proc}"
SRC_URI[x86_64_v2_utf8proc.sha256sum] = "c2e2c52de8277a5ba7860c81bb927e2593ecc8f02600afdbf801cb78c4373896"

URI_x86_64_v2_utf8proc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/utf8proc-devel-2.7.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_utf8proc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_utf8proc-devel}"
SRC_URI[x86_64_v2_utf8proc-devel.sha256sum] = "9610a74388ee76e531b1fe5489d9cbb1430002ad2dd4611edf78e4eea6a37ca6"

URI_aarch64_utf8proc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/utf8proc-2.7.0-9.el10.aarch64.rpm;name=aarch64_utf8proc;unpack=0"
SRC_URI:append = " ${URI_aarch64_utf8proc}"
SRC_URI[aarch64_utf8proc.sha256sum] = "322025452cf8431e8f514e4a65b336e32f0bc980d0875d4293905e7e22a5bc54"

URI_aarch64_utf8proc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/utf8proc-devel-2.7.0-9.el10.aarch64.rpm;name=aarch64_utf8proc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_utf8proc-devel}"
SRC_URI[aarch64_utf8proc-devel.sha256sum] = "f3cb34507a479c76be1575d887cbbdb04bcb16acd26ee2447e051b579d25da02"

RDEPENDS:utf8proc = " \
 glibc \
 "
RDEPENDS:utf8proc-devel = " \
 pkgconf-pkg-config \
 utf8proc \
 "
