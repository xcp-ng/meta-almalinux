# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-cockroachdb-redact"
PV = "1.0.9"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-cockroachdb-redact-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-cockroachdb-redact-1.0.9-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62bcf8c12aaf07c135eb38c6498b529db1835c0c5178b731f346adca3929f233"

URI_x86_64_v2_golang-github-cockroachdb-redact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-cockroachdb-redact-devel-1.0.9-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-cockroachdb-redact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-cockroachdb-redact-devel}"
SRC_URI[x86_64_v2_golang-github-cockroachdb-redact-devel.sha256sum] = "529e52b3caf20a673f06d4855b3c1a08651a1172c45cccd5d91dadda734c1672"

URI_aarch64_golang-github-cockroachdb-redact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-cockroachdb-redact-devel-1.0.9-14.el10_0.noarch.rpm;name=aarch64_golang-github-cockroachdb-redact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-cockroachdb-redact-devel}"
SRC_URI[aarch64_golang-github-cockroachdb-redact-devel.sha256sum] = "19ecbd516c00a947469b5a781b6701e3ce043f1ebeaae9330b01fd984bfc6348"

RDEPENDS:golang-github-cockroachdb-redact-devel = " \
 go-filesystem \
 "
