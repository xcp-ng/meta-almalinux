# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-wsgidav"
PV = "4.3.5"
PR = "1.el10_2"
PACKAGES = " \
 python3-wsgidav \
 python3-wsgidav+pam \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-wsgidav-4.3.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fda52e69dff2ef387b0af097f5579a386d6d01de9666e8d3738145f6d8f7a2e"

URI_x86_64_v2_python3-wsgidav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-wsgidav-4.3.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-wsgidav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wsgidav}"
SRC_URI[x86_64_v2_python3-wsgidav.sha256sum] = "c670b61df594361d017f33ac1305729610219cb1479bf5e5ab28067cb38b8468"

URI_x86_64_v2_python3-wsgidav+pam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-wsgidav+pam-4.3.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-wsgidav+pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wsgidav+pam}"
SRC_URI[x86_64_v2_python3-wsgidav+pam.sha256sum] = "112ba5b09b0e78e82508641b5e375243351032c72affca7778bb4d1a0414399e"

URI_aarch64_python3-wsgidav = "${EPEL_MIRROR}/aarch64/Packages/p/python3-wsgidav-4.3.5-1.el10_2.noarch.rpm;name=aarch64_python3-wsgidav;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wsgidav}"
SRC_URI[aarch64_python3-wsgidav.sha256sum] = "6789b9934ab56e7d6c0ccb6e59a251beafe53bb3ffe570eeba2fa732f9c56c5f"

URI_aarch64_python3-wsgidav+pam = "${EPEL_MIRROR}/aarch64/Packages/p/python3-wsgidav+pam-4.3.5-1.el10_2.noarch.rpm;name=aarch64_python3-wsgidav+pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wsgidav+pam}"
SRC_URI[aarch64_python3-wsgidav+pam.sha256sum] = "8a6d0c5d3cceb42cbfe3537f09848a96e82dd6522401dd1de736fbb74d758705"

RDEPENDS:python3-wsgidav = " \
 python3 \
 python3-bcrypt \
 python3-defusedxml \
 python3-jinja2 \
 python3-json5 \
 python3-passlib \
 python3-pyyaml \
 "
RDEPENDS:python3-wsgidav+pam = " \
 python3 \
 python3-pam \
 python3-wsgidav \
 "
