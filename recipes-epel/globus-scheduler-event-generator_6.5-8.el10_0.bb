# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-scheduler-event-generator"
PV = "6.5"
PR = "8.el10_0"
PACKAGES = " \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-devel \
 globus-scheduler-event-generator-doc \
 globus-scheduler-event-generator-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-scheduler-event-generator-6.5-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48a0383119cf408df0619bd6c80f6c1c57227071e22231411cd34be604c505aa"

URI_x86_64_v2_globus-scheduler-event-generator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-scheduler-event-generator-6.5-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-scheduler-event-generator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-scheduler-event-generator}"
SRC_URI[x86_64_v2_globus-scheduler-event-generator.sha256sum] = "e1b952f7729d012c8714525aa7597b803a2094aff9a5b8574122e83dcad8e341"

URI_x86_64_v2_globus-scheduler-event-generator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-scheduler-event-generator-devel-6.5-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-scheduler-event-generator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-scheduler-event-generator-devel}"
SRC_URI[x86_64_v2_globus-scheduler-event-generator-devel.sha256sum] = "d1c091eabd633dcd92acfede628c60140bc330b433a3b2d682fe5866d7c89ea2"

URI_x86_64_v2_globus-scheduler-event-generator-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-scheduler-event-generator-doc-6.5-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-scheduler-event-generator-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-scheduler-event-generator-doc}"
SRC_URI[x86_64_v2_globus-scheduler-event-generator-doc.sha256sum] = "bef07dfdae8f89bad446ac56f2d2b01bfbff581a0acd9bc1a74998c4b9cefd88"

URI_x86_64_v2_globus-scheduler-event-generator-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-scheduler-event-generator-progs-6.5-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-scheduler-event-generator-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-scheduler-event-generator-progs}"
SRC_URI[x86_64_v2_globus-scheduler-event-generator-progs.sha256sum] = "a0761152dd3cb409e9f59ef0d02241893f34a8cdee60e26b3ce77c5b665a2b7c"

URI_aarch64_globus-scheduler-event-generator = "${EPEL_MIRROR}/aarch64/Packages/g/globus-scheduler-event-generator-6.5-8.el10_0.aarch64.rpm;name=aarch64_globus-scheduler-event-generator;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-scheduler-event-generator}"
SRC_URI[aarch64_globus-scheduler-event-generator.sha256sum] = "4377a40d297bbbd664634bff01204e71ac4730fdcb221e081e69b5ba217d017c"

URI_aarch64_globus-scheduler-event-generator-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-scheduler-event-generator-devel-6.5-8.el10_0.aarch64.rpm;name=aarch64_globus-scheduler-event-generator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-scheduler-event-generator-devel}"
SRC_URI[aarch64_globus-scheduler-event-generator-devel.sha256sum] = "598011c147f36d84a65250cd13fc6b623689fcd67a830dd82e6a7cb50b6f3b3d"

URI_aarch64_globus-scheduler-event-generator-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-scheduler-event-generator-doc-6.5-8.el10_0.noarch.rpm;name=aarch64_globus-scheduler-event-generator-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-scheduler-event-generator-doc}"
SRC_URI[aarch64_globus-scheduler-event-generator-doc.sha256sum] = "749ab483a470ed132d00a20610c5c4eeb5fae059b5a2c46948b69611ea74be15"

URI_aarch64_globus-scheduler-event-generator-progs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-scheduler-event-generator-progs-6.5-8.el10_0.aarch64.rpm;name=aarch64_globus-scheduler-event-generator-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-scheduler-event-generator-progs}"
SRC_URI[aarch64_globus-scheduler-event-generator-progs.sha256sum] = "bf96dd7db0895ace8a1f8cb72c7b76bc5d407063643c52ee0f7df430558a587b"

RDEPENDS:globus-scheduler-event-generator = " \
 glibc \
 globus-common \
 globus-xio-gsi-driver \
 "
RDEPENDS:globus-scheduler-event-generator-devel = " \
 globus-common-devel \
 globus-gram-protocol-devel \
 globus-scheduler-event-generator \
 globus-xio-devel \
 globus-xio-gsi-driver-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-scheduler-event-generator-doc = " \
 "
RDEPENDS:globus-scheduler-event-generator-progs = " \
 bash \
 glibc \
 globus-common \
 globus-scheduler-event-generator \
 globus-xio \
 systemd \
 "
