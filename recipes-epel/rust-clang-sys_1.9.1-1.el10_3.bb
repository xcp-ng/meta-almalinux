# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clang-sys"
PV = "1.9.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-clang-sys+clang_10_0-devel \
 rust-clang-sys+clang_11_0-devel \
 rust-clang-sys+clang_12_0-devel \
 rust-clang-sys+clang_13_0-devel \
 rust-clang-sys+clang_14_0-devel \
 rust-clang-sys+clang_15_0-devel \
 rust-clang-sys+clang_16_0-devel \
 rust-clang-sys+clang_17_0-devel \
 rust-clang-sys+clang_18_0-devel \
 rust-clang-sys+clang_19_0-devel \
 rust-clang-sys+clang_20_0-devel \
 rust-clang-sys+clang_3_5-devel \
 rust-clang-sys+clang_3_6-devel \
 rust-clang-sys+clang_3_7-devel \
 rust-clang-sys+clang_3_8-devel \
 rust-clang-sys+clang_3_9-devel \
 rust-clang-sys+clang_4_0-devel \
 rust-clang-sys+clang_5_0-devel \
 rust-clang-sys+clang_6_0-devel \
 rust-clang-sys+clang_7_0-devel \
 rust-clang-sys+clang_8_0-devel \
 rust-clang-sys+clang_9_0-devel \
 rust-clang-sys+default-devel \
 rust-clang-sys+libcpp-devel \
 rust-clang-sys+libloading-devel \
 rust-clang-sys+runtime-devel \
 rust-clang-sys+static-devel \
 rust-clang-sys-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-clang-sys-1.9.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ae253be8c75831985f7aaa6052b774a93a016f98da6040bce4fe3621e8174e0f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_10_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_10_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_10_0-devel.sha256sum] = "cb406953dfcc0327aa24ba98a257f41bf32c11121dc70f4a4c7a5fb913219b41"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_11_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_11_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_11_0-devel.sha256sum] = "3e7d849e19768695fe2d3aa9506f06d7eaabee7ae1068bc452c8e4bfc5ad2b92"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_12_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_12_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_12_0-devel.sha256sum] = "a23f27302484967f62d58a13404c172548b8756825d9638f2203dec008819478"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_13_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_13_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_13_0-devel.sha256sum] = "45843c019bf9dcf4b431b834df5227ac2db7cad7a1d3f3a1d44f49146b98013c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_14_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_14_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_14_0-devel.sha256sum] = "26b4ab319ef89dd790ac35f375aec1c3bab17969903ea376ad3ea878a7cadc83"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_15_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_15_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_15_0-devel.sha256sum] = "c450f1a4ce7776e0a6c09a33fd6e3253523bb5c1f5db945935f9d3364eacc719"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_16_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_16_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_16_0-devel.sha256sum] = "4c81f009f46dafb5fcd1a443e1c71e6a72a643cb70087286b2088b7c88f2fbfc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_17_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_17_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_17_0-devel.sha256sum] = "fa82beb3451afc86741605405b7bdbd07bdd9510fe2399940fefca99b9468b55"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_18_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_18_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_18_0-devel.sha256sum] = "8b7e5252786240e4032e7843465cd2b03dd897f9fb129b8ca3ea9ec48c0e4713"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_19_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_19_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_19_0-devel.sha256sum] = "b8406f02fe1316e3601a7d88b0e74b009e8dce80530d334c0c0a20d4a2955712"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_20_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_20_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_20_0-devel.sha256sum] = "801d41471274eb33dd279c679cba3abec47b7afc8d5252a19cb6955ac4897e75"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_5-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_5-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_5-devel.sha256sum] = "ff143a0c0cb54db5aa7b0b2607bff4d8ddbe7fce32c99f4f35ec45f6b966c7e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_6-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_6-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_6-devel.sha256sum] = "8e3546494c886a34609c9f2a9d08157d47dd15c626683085fcbc9d49952a5db9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_7-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_7-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_7-devel.sha256sum] = "d078e6f670e8333e595e44a9b79e3c69d4f460240f8899d01784cd9eeef5252d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_8-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_8-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_8-devel.sha256sum] = "61a6ce2c3a9cdaabe1e140f32b47cfed3273be5e2675023d1bec08d6b69fb9f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_9-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_9-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_9-devel.sha256sum] = "51b9026fba474a0e90ec37799b59468ab8b5003abc246347f4482e5596fe6012"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_4_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_4_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_4_0-devel.sha256sum] = "0a2f1eebf82f0049404b1298fc042fe6b9b093d91013fe3ed52cb092df0354b8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_5_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_5_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_5_0-devel.sha256sum] = "ce18b850a9a78ecf2324518bd0f5b1a66c10052c74a8802d59378f3129631b41"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_6_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_6_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_6_0-devel.sha256sum] = "2fbf12baa21e457b9395e690fd34c58b643f4aa1b1c5784bff89b46638ce886c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_7_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_7_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_7_0-devel.sha256sum] = "a414d90d3d345d99c879ec07266bb7b7781d99a1cd0bef1bdc3294c487994b92"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_8_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_8_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_8_0-devel.sha256sum] = "f3360d4567b4b07529094859749f432c8b7558741a50dae3078ddf24faa7150a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_9_0-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_9_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_9_0-devel.sha256sum] = "671eb6596da21273840c70c5ac05cbebf1ea757a1a1802df86d40bc885119074"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+default-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+default-devel.sha256sum] = "9112a5773ef4448225474ed0108a1f5e0fcf9c937482d5431380e715bf8bdc1b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+libcpp-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+libcpp-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+libcpp-devel.sha256sum] = "8528cd0b8dde3395bb32747fcd9e97404987150892ed02aa63699f4c203c2919"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+libloading-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+libloading-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+libloading-devel.sha256sum] = "c5c0863599c92d1c8c2113ac98e87e525ad2fdf0743a8af72d48933eaa9c6546"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+runtime-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+runtime-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+runtime-devel.sha256sum] = "811938a609d2e40d10c574150dcae9edd0e43c63e07e157f96d0f8151d7ed1a9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+static-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+static-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+static-devel.sha256sum] = "7e95946e2e9e2bead61c8785b463f4ad44bbefd9ece741c31aebcc53ec755b76"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys-devel-1.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys-devel.sha256sum] = "054d97cd2f7b4367a3c321ed6b1dc87e6a9c5d3849fae213fba238d6853ee1fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_10_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_10_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_10_0-devel.sha256sum] = "5f93817ab371ba66968ef7d30b2c31d0d21fe827a04921d6b05f94c13eb38fa7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_11_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_11_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_11_0-devel.sha256sum] = "820112eca49d1a79eb086c64c32bfdea63972ad25bc7199f8f9489cd20dc4808"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_12_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_12_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_12_0-devel.sha256sum] = "565bb98c109fd6de973f3428b9f8df778d07a0ac7f9edfc750da98015571ed57"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_13_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_13_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_13_0-devel.sha256sum] = "243a5d3c60d7171f0da347346bfc78e9c474532395a44ff3d9767240f31e12c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_14_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_14_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_14_0-devel.sha256sum] = "1ac22b2f162263d1bc4f5ad48a669952ccf898592f52813a81a5b5e4b3deb354"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_15_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_15_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_15_0-devel.sha256sum] = "96271543a0cbf26104cc474556fbead290ebb7a770f33886f55af5ad9d6a03c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_16_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_16_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_16_0-devel.sha256sum] = "fcb81f0744ca33004a7b1f34aedddf2f4ff58456b87ec0b94679436e500e1cc6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_17_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_17_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_17_0-devel.sha256sum] = "ff3df56b85b08e04f823cc30e5766cb88c1146f723663ce5b3d53367a439ee5e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_18_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_18_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_18_0-devel.sha256sum] = "1e9661a46756ff8d868c85d7ff76c48db13bc9da7a3ee294648d8b2c56315019"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_19_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_19_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_19_0-devel.sha256sum] = "4604b1b744438ce4339eb24344337b25d2f189e7317c94b05c045a0e3fe9ffa3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_20_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_20_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_20_0-devel.sha256sum] = "423b0597433f3361728169ceef74b1ced81befe8b8c81f4fc63b725fd9e2951e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_5-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_5-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_3_5-devel.sha256sum] = "4f7077ecc9292e333f805372396f3e165be6f65a2db76b51f9cd9838f4c93990"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_6-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_6-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_3_6-devel.sha256sum] = "97bca7d4f825a7807b56ab3238513cba7ce2ab7742b883f7d37049ae7485e405"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_7-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_7-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_3_7-devel.sha256sum] = "80d90edf9b09835dd0d797e86be71a0ac5790b8444233bf4a727254f3fa04c84"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_8-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_8-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_3_8-devel.sha256sum] = "ca5c50a7cdceff5e2e48720b8d914e59576420efd8e246e0db649774aebb991a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_9-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_9-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_3_9-devel.sha256sum] = "7ed7c462cbbc2262d3a227f1051d05a6ae9a804b395806a47ae4c183d7bf5e4e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_4_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_4_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_4_0-devel.sha256sum] = "a131407fe7a8ea1faac477944219d53503c2d8a1a713fa067636657c437957ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_5_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_5_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_5_0-devel.sha256sum] = "c71b890a4302aeedb5b0e57524716b09da43261ca5088d0a9826f1ae4800095a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_6_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_6_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_6_0-devel.sha256sum] = "a992a921e71fda860a46d2b6e14cb982ab9e2ac480c242b00ab33d37117bb23b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_7_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_7_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_7_0-devel.sha256sum] = "6dc70c2fd70cb9dd5dc4237ae97143c10deb05221f09b1afaf1881b4f5c890b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_8_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_8_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_8_0-devel.sha256sum] = "f55913ec387fd9b86003f8bc49c79dbc30b1543341fead06cac7a83d0645c168"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_9_0-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+clang_9_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_9_0-devel.sha256sum] = "5949913404bfdedd9952fa38b5881451e84c5e80cc412a7ccdd1f1b6c9db6b60"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+default-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+default-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+default-devel.sha256sum] = "ad272c65995d3ab9974b3bf68b7104e40bd401fea128f2cfe3811427a897c749"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+libcpp-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+libcpp-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+libcpp-devel.sha256sum] = "1c29d9c21837e7287cbf3ee7a020c738cb5e386e6ee576bf67a8d6c5f7233a72"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+libloading-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+libloading-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+libloading-devel.sha256sum] = "d0ae30152efe47ba4c4478ef5f1fd8b6e30b0b6d4bf16eda32203d2c44d04ec2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+runtime-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+runtime-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+runtime-devel.sha256sum] = "4fbdab3fd6db74e6b2d8dc71ff04ec1e770cd05aaca3ae384abbf2a47018943b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+static-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys+static-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+static-devel.sha256sum] = "5ae0b5358409279183761ded585edea92178345b669e562230f846173e78df1e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys-devel-1.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-clang-sys-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys-devel.sha256sum] = "c949af6a1760621712abb80ef2e053c54b9f867a3cb52971f50e60cd01201845"

RDEPENDS:rust-clang-sys+clang_10_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_9_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_11_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_10_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_12_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_11_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_13_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_12_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_14_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_13_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_15_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_14_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_16_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_15_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_17_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_16_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_18_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_17_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_19_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_18_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_20_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_19_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_5-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_6-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_5-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_7-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_6-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_8-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_7-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_9-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_8-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_4_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_9-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_5_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_4_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_6_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_5_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_7_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_6_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_8_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_7_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_9_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_8_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+default-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+libcpp-devel = " \
 cargo \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+libloading-devel = " \
 cargo \
 rust-clang-sys-devel \
 rust-libloading0.8+default-devel \
 "
RDEPENDS:rust-clang-sys+runtime-devel = " \
 cargo \
 clang-libs \
 rust-clang-sys+libloading-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+static-devel = " \
 cargo \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys-devel = " \
 cargo \
 rust-glob+default-devel \
 rust-libc-devel \
 "
