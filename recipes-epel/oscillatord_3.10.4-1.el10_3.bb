# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oscillatord"
PV = "3.10.4"
PR = "1.el10_3"
PACKAGES = " \
 oscillatord \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/oscillatord-3.10.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1130eaae0f8d5f83ee7e6fbf37baf9d61b30f4134f29dfd49f2c6657d98cf668"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - oscillatord: libff.so.0.0.0()(64bit)
# - oscillatord: libubloxcfg.so.0.0.0()(64bit)
# - oscillatord: ubloxcfg >= 1.16-1.20260223git499048b

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oscillatord-3.10.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oscillatord;unpack=0"
SRC_URI[x86_64_v2_oscillatord.sha256sum] = "57864773b9ae16ad8bb9f346f0f3e6138cb694cf1a7590b46784526373adf0a2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/oscillatord-3.10.4-1.el10_3.aarch64.rpm;name=aarch64_oscillatord;unpack=0"
SRC_URI[aarch64_oscillatord.sha256sum] = "1837ca107dc81fb7fdee8ef35caea3c6a1bd43b6f5bc44e67e42d3d70f665f92"

RDEPENDS:oscillatord:x86_64_v2 = " \
 bash \
 glibc \
 json-c \
 libgcc \
 liboscillator-disciplining \
"
RDEPENDS:oscillatord:aarch64 = " \
 bash \
 glibc \
 json-c \
 libgcc \
 liboscillator-disciplining \
 ubloxcfg \
"
