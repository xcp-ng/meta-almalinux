# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-metrics"
PV = "0.24.2"
PR = "3.el10_3"
PACKAGES = " \
 rust-metrics+default-devel \
 rust-metrics-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-metrics-0.24.2-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54affa6b83aef01eca9fdd9708046bf5341e78d6fcf7e4c2dc6a5d0be2ee9616"

URI_x86_64_v2_rust-metrics+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics+default-devel-0.24.2-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics+default-devel}"
SRC_URI[x86_64_v2_rust-metrics+default-devel.sha256sum] = "4ee6e1afadda9c04db78289387304c3f34afaa8764f988a015a7e14c60c0272f"

URI_x86_64_v2_rust-metrics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-devel-0.24.2-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-devel}"
SRC_URI[x86_64_v2_rust-metrics-devel.sha256sum] = "77787930e1c229f2a38d4f74901d10c31dee86df9303df32c8fcc0e8603bc867"

URI_aarch64_rust-metrics+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics+default-devel-0.24.2-3.el10_3.noarch.rpm;name=aarch64_rust-metrics+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics+default-devel}"
SRC_URI[aarch64_rust-metrics+default-devel.sha256sum] = "fb2ecfb5d17c9e6dd8b1e481123badb6a3594d0aca10abfd9437308f6d0b5e88"

URI_aarch64_rust-metrics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-devel-0.24.2-3.el10_3.noarch.rpm;name=aarch64_rust-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-devel}"
SRC_URI[aarch64_rust-metrics-devel.sha256sum] = "e6a99774e316a4e55875611000e6fbf5dc63ba5ab4f64b41e455f61a7eb30e78"

RDEPENDS:rust-metrics+default-devel = " \
 cargo \
 rust-metrics-devel \
 "
RDEPENDS:rust-metrics-devel = " \
 cargo \
 rust \
 rust-ahash-devel \
 rust-portable-atomic+fallback-devel \
 rust-portable-atomic-devel \
 "
