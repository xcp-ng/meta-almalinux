# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksirk"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ksirk \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ksirk-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ac02a805f7f1e1a607e9986b21d10e863e9acc29cfcf723bbd52cd156d3889fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksirk-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksirk;unpack=0"
SRC_URI[x86_64_v2_ksirk.sha256sum] = "eb051840977fb4b3a201dde90c6576e9d5a61fbf81a2ea737f0a75210a7bd536"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ksirk-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ksirk;unpack=0"
SRC_URI[aarch64_ksirk.sha256sum] = "057df43b69c55901a806db25e6e16017eb43aaff73bccfd4303474125ceca205"

RDEPENDS:ksirk = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qca-qt6-ossl \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
