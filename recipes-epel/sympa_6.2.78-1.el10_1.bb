# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sympa"
PV = "6.2.78"
PR = "1.el10_1"
PACKAGES = " \
 sympa \
 sympa-devel-doc \
 sympa-httpd \
 sympa-lighttpd \
 sympa-nginx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sympa-6.2.78-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "258ec9ed6ebf78b8a6067cc6cc7e7487d1d8cd3d0cd72daeb52eba173efad960"

URI_x86_64_v2_sympa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-6.2.78-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sympa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa}"
SRC_URI[x86_64_v2_sympa.sha256sum] = "1c536b82de1d3706d35881475bac271c1c2ee55082e54e9065833fc2abfa6c71"

URI_x86_64_v2_sympa-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-devel-doc-6.2.78-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-devel-doc}"
SRC_URI[x86_64_v2_sympa-devel-doc.sha256sum] = "8c319325a3bf0791f24d13258d2b6b6ab53df851de0e585a1dd6c8f61e0f83f0"

URI_x86_64_v2_sympa-httpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-httpd-6.2.78-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-httpd}"
SRC_URI[x86_64_v2_sympa-httpd.sha256sum] = "98ae3e03d296155377b94768cdc7c627127478c67219edf2f83dd5773cd385df"

URI_x86_64_v2_sympa-lighttpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-lighttpd-6.2.78-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-lighttpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-lighttpd}"
SRC_URI[x86_64_v2_sympa-lighttpd.sha256sum] = "6902264cee3bc230b6cde01e27d1faba9020ff6dd1406b3b31e12506feac94c6"

URI_x86_64_v2_sympa-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-nginx-6.2.78-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-nginx}"
SRC_URI[x86_64_v2_sympa-nginx.sha256sum] = "036e9aa9d26ef59efc079d8fb4bdbd3b810716a2773629f24e412ab64e37d17b"

URI_aarch64_sympa = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-6.2.78-1.el10_1.aarch64.rpm;name=aarch64_sympa;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa}"
SRC_URI[aarch64_sympa.sha256sum] = "75832548505665b0b1a313db7121c82b87bda0fa0de0a2e2adfcfbff564f71fd"

URI_aarch64_sympa-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-devel-doc-6.2.78-1.el10_1.noarch.rpm;name=aarch64_sympa-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-devel-doc}"
SRC_URI[aarch64_sympa-devel-doc.sha256sum] = "c09e71225db74fa846e197b45451d6183a77382407b979e699bac74bfed10ce6"

URI_aarch64_sympa-httpd = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-httpd-6.2.78-1.el10_1.noarch.rpm;name=aarch64_sympa-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-httpd}"
SRC_URI[aarch64_sympa-httpd.sha256sum] = "864041d95cc2cba53f6aafcc2b127d2243860ec14874cb94ad2527236929cf1f"

URI_aarch64_sympa-lighttpd = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-lighttpd-6.2.78-1.el10_1.noarch.rpm;name=aarch64_sympa-lighttpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-lighttpd}"
SRC_URI[aarch64_sympa-lighttpd.sha256sum] = "e257baf1f06fab7fd5b4876ca781a9ddf0d335fb801b783530770aad280c140d"

URI_aarch64_sympa-nginx = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-nginx-6.2.78-1.el10_1.noarch.rpm;name=aarch64_sympa-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-nginx}"
SRC_URI[aarch64_sympa-nginx.sha256sum] = "d74252b8f57e5c878dff1d4c3c307c59fc1c5c5d44756013602a19e7a50e9ac3"

RDEPENDS:sympa = " \
 bash \
 glibc \
 js-jquery \
 js-jquery-ui \
 logrotate \
 mhonarc \
 perl-Archive-Zip-SimpleZip \
 perl-AuthCAS \
 perl-CGI \
 perl-CGI-Fast \
 perl-Carp \
 perl-Class-Singleton \
 perl-Clone \
 perl-Crypt-CipherSaber \
 perl-Crypt-Eksblowfish \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-SMIME \
 perl-DBD-CSV \
 perl-DBD-MySQL \
 perl-DBI \
 perl-Data-Dumper \
 perl-Data-Password \
 perl-DateTime \
 perl-DateTime-Format-Mail \
 perl-DateTime-TimeZone \
 perl-Digest-MD5 \
 perl-Encode \
 perl-Encode-EUCJPASCII \
 perl-Encode-HanExtra \
 perl-Encode-Locale \
 perl-English \
 perl-FCGI \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Copy-Recursive \
 perl-File-Find \
 perl-File-NFSLock \
 perl-File-Path \
 perl-Getopt-Long \
 perl-HTML-Formatter \
 perl-HTML-Parser \
 perl-HTML-StripScripts-Parser \
 perl-HTML-Tree \
 perl-HTTP-Cookies \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Socket-IP \
 perl-IO-Socket-SSL \
 perl-IO-stringy \
 perl-LDAP \
 perl-LWP-Protocol-https \
 perl-MIME-Base64 \
 perl-MIME-Charset \
 perl-MIME-EncWords \
 perl-MIME-Lite-HTML \
 perl-MIME-tools \
 perl-Mail-DKIM \
 perl-MailTools \
 perl-Net-CIDR \
 perl-Net-DNS \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-SOAP-Lite \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Template-Toolkit \
 perl-Term-ProgressBar \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-URI \
 perl-URI-Find \
 perl-Unicode-LineBreak \
 perl-Unicode-Normalize \
 perl-Unicode-UTF8 \
 perl-XML-LibXML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libintl-perl \
 perl-libnet \
 perl-libs \
 perl-libwww-perl \
 perl-parent \
 shadow-utils \
 sympa \
 systemd \
 virtual/smtpdaemon \
 "
RDEPENDS:sympa-devel-doc = " \
 sympa \
 "
RDEPENDS:sympa-httpd = " \
 bash \
 httpd \
 multiwatch \
 sympa \
 "
RDEPENDS:sympa-lighttpd = " \
 lighttpd \
 lighttpd-fastcgi \
 sympa \
 "
RDEPENDS:sympa-nginx = " \
 bash \
 multiwatch \
 nginx \
 sympa \
 "
