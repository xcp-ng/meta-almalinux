# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "enchant2"
PV = "2.6.7"
PR = "3.el10"
PACKAGES = " \
 enchant2 \
 enchant2-devel \
 enchant2-voikko \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/enchant2-2.6.7-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bdd03d7238da06c1959c0ba968c2708095490eb5be10714cea32557ee50d7b9"

URI_x86_64_v2_enchant2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/enchant2-2.6.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_enchant2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_enchant2}"
SRC_URI[x86_64_v2_enchant2.sha256sum] = "837256609e4c02fce5b50572d94806f2227458da767b425f17e9e39a0c13976c"

URI_x86_64_v2_enchant2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/enchant2-devel-2.6.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_enchant2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_enchant2-devel}"
SRC_URI[x86_64_v2_enchant2-devel.sha256sum] = "427ee60e89587daf29fb330635944fea6940cfad0abc7a5b9a5ff4c7d1137ed7"

URI_x86_64_v2_enchant2-voikko = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/enchant2-voikko-2.6.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_enchant2-voikko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_enchant2-voikko}"
SRC_URI[x86_64_v2_enchant2-voikko.sha256sum] = "a2fcfb64adb8e6d15d113427cdf471cb6d82332b92776914baf5357cdaf50441"

URI_aarch64_enchant2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/enchant2-2.6.7-3.el10.aarch64.rpm;name=aarch64_enchant2;unpack=0"
SRC_URI:append = " ${URI_aarch64_enchant2}"
SRC_URI[aarch64_enchant2.sha256sum] = "7f684dd1924790ea50fc1a1eff53138c70a644e283cbc0b4b7c0b53e8fc8bcfd"

URI_aarch64_enchant2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/enchant2-devel-2.6.7-3.el10.aarch64.rpm;name=aarch64_enchant2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_enchant2-devel}"
SRC_URI[aarch64_enchant2-devel.sha256sum] = "ae7769c55c4be28d949de473b2bf917db1540e692c53385281f9a0f0af8a247d"

URI_aarch64_enchant2-voikko = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/enchant2-voikko-2.6.7-3.el10.aarch64.rpm;name=aarch64_enchant2-voikko;unpack=0"
SRC_URI:append = " ${URI_aarch64_enchant2-voikko}"
SRC_URI[aarch64_enchant2-voikko.sha256sum] = "fd821fad28ade8a55d0f21759e55f99c4f4ea5ca84ffbe94e29f678f0d355813"

RDEPENDS:enchant2 = " \
 glib2 \
 glibc \
 hunspell \
 libgcc \
 libstdc++ \
 "
RDEPENDS:enchant2-devel = " \
 enchant2 \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:enchant2-voikko = " \
 enchant2 \
 glib2 \
 glibc \
 libvoikko \
 "
