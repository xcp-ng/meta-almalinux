# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxxbridge-flags"
PV = "1.0.142"
PR = "1.el10_0"
PACKAGES = " \
 rust-cxxbridge-flags+c++14-devel \
 rust-cxxbridge-flags+c++17-devel \
 rust-cxxbridge-flags+c++20-devel \
 rust-cxxbridge-flags+default-devel \
 rust-cxxbridge-flags-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxxbridge-flags-1.0.142-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f80519bae6f9af945f161c05d8dd282c9c7e9e11c7144d0e1bbeadafbc5bad9"

URI_x86_64_v2_rust-cxxbridge-flags+c++14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++14-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+c++14-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++14-devel.sha256sum] = "ac520dafd952850f8ddb7d24d01576a3789e26c0c9d853e3956284b9c8a29e91"

URI_x86_64_v2_rust-cxxbridge-flags+c++17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++17-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+c++17-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++17-devel.sha256sum] = "aa811103087111f240662aa4ecb13c429c4214eccaecb2575ef0f85af47253f0"

URI_x86_64_v2_rust-cxxbridge-flags+c++20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++20-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+c++20-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++20-devel.sha256sum] = "1facbb8dfbc39f8e2012fedf13700bce0a4be5f8615aceab36eeee33cde46662"

URI_x86_64_v2_rust-cxxbridge-flags+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+default-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+default-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+default-devel.sha256sum] = "becd2d811380a4a8c698ca4df05b1b2d4507e4031e557cc683b937058da749da"

URI_x86_64_v2_rust-cxxbridge-flags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags-devel.sha256sum] = "b2a63cf6e4ab537fcfecd08c3e28b1307a79dfdfa373ca59a30128db7aeb6e86"

URI_aarch64_rust-cxxbridge-flags+c++14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++14-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+c++14-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+c++14-devel.sha256sum] = "c5ee38d271b177169b1100a8ff0b660c556a622947fe878cef873cc73f556435"

URI_aarch64_rust-cxxbridge-flags+c++17-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++17-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+c++17-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+c++17-devel.sha256sum] = "ff3bf9ec63f3cb88fbc633c274b2eab383d5ee3543e5df732538c26707d8d860"

URI_aarch64_rust-cxxbridge-flags+c++20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++20-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+c++20-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+c++20-devel.sha256sum] = "aae6217fce50628952401f8f6ac1b5bf102a22c6c627c3934860ce45620f9cb4"

URI_aarch64_rust-cxxbridge-flags+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+default-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxxbridge-flags+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+default-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+default-devel.sha256sum] = "75bcb01398bff9f50eb50c50c21665ffaa104397842c08bc63d49328472a7b4c"

URI_aarch64_rust-cxxbridge-flags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxxbridge-flags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags-devel.sha256sum] = "8182068c155dc3c07beb88b2e0bd783881e31b391980ed3c15e823f3a12e9ec5"

RDEPENDS:rust-cxxbridge-flags+c++14-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+c++17-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+c++20-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+default-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags-devel = " \
 cargo \
 rust \
 "
