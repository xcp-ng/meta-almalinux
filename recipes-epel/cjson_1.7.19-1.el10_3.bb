# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cjson"
PV = "1.7.19"
PR = "1.el10_3"
PACKAGES = " \
 cjson \
 cjson-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cjson-1.7.19-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd948a0e83d27dae547a17caf8cb4e830d7018f1942ea28fc1f1613c9e173961"

URI_x86_64_v2_cjson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cjson-1.7.19-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cjson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cjson}"
SRC_URI[x86_64_v2_cjson.sha256sum] = "c7f9f7a9b63a26cd69fde5b90520d496407d5b9894ebc9709b842080a535e89d"

URI_x86_64_v2_cjson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cjson-devel-1.7.19-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cjson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cjson-devel}"
SRC_URI[x86_64_v2_cjson-devel.sha256sum] = "48d5716a5199b1ef61df11b49c9755bac0e9abb2b0d3566997b2eb29a5f36e2c"

URI_aarch64_cjson = "${EPEL_MIRROR}/aarch64/Packages/c/cjson-1.7.19-1.el10_3.aarch64.rpm;name=aarch64_cjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_cjson}"
SRC_URI[aarch64_cjson.sha256sum] = "8f9775ed810998d4273370ae7526bce2f757cefd721daa9d7d8cf19cae7f3fd5"

URI_aarch64_cjson-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cjson-devel-1.7.19-1.el10_3.aarch64.rpm;name=aarch64_cjson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cjson-devel}"
SRC_URI[aarch64_cjson-devel.sha256sum] = "8d2bfbe6afae1e4361fa4cd1edab77cc693d72692ab86b71c453a5bb8b63bbde"

RDEPENDS:cjson = " \
 glibc \
 "
RDEPENDS:cjson-devel = " \
 cjson \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
