# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-free"
PV = "5.2"
PR = "1.el10_0"
PACKAGES = " \
 ghc-free \
 ghc-free-devel \
 ghc-free-doc \
 ghc-free-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-free-5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "910abdee2587ffd15fd2780d9425b623232576a52d210bc12c8fdaec7c98f1d5"

URI_x86_64_v2_ghc-free = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-free-5.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-free}"
SRC_URI[x86_64_v2_ghc-free.sha256sum] = "a301863f097d92990928e925a3a5afa596aa31c8b9dbb314308179c84453ccc6"

URI_x86_64_v2_ghc-free-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-free-devel-5.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-free-devel}"
SRC_URI[x86_64_v2_ghc-free-devel.sha256sum] = "7504fb32a3c66f36a3bcee7edad2870b475f1bdbac8dc792a87d194d09b52a09"

URI_x86_64_v2_ghc-free-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-free-doc-5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-free-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-free-doc}"
SRC_URI[x86_64_v2_ghc-free-doc.sha256sum] = "de91f56f58b6ee307047aa5d4f17d0b8ea09adfb8d604311daeaf512633bc116"

URI_x86_64_v2_ghc-free-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-free-prof-5.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-free-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-free-prof}"
SRC_URI[x86_64_v2_ghc-free-prof.sha256sum] = "b99ed93737c180aac1856aa86a6ec954a11aca5f37b590f076ce9488fa75270c"

URI_aarch64_ghc-free = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-free-5.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-free}"
SRC_URI[aarch64_ghc-free.sha256sum] = "61ecbbbd0fbe607b4512ce7d989987b5026bc1e0d84e1020ecd1bf96f7feb79c"

URI_aarch64_ghc-free-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-free-devel-5.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-free-devel}"
SRC_URI[aarch64_ghc-free-devel.sha256sum] = "898f115e5509588cd8f6c7ee995c6a7ae2a0eff54ac6629c7b0358a3d9b43803"

URI_aarch64_ghc-free-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-free-doc-5.2-1.el10_0.noarch.rpm;name=aarch64_ghc-free-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-free-doc}"
SRC_URI[aarch64_ghc-free-doc.sha256sum] = "f37e37e6fd2b6ec0f3dd98772eeb2c6142213fb5599a08562f2f5c56bb252507"

URI_aarch64_ghc-free-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-free-prof-5.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-free-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-free-prof}"
SRC_URI[aarch64_ghc-free-prof.sha256sum] = "a7f9da0a596473b12ee0e70d35244f0b1e4ef651b945e57cd95ab0a118fbc480"

RDEPENDS:ghc-free = " \
 ghc-StateVar \
 ghc-array \
 ghc-assoc \
 ghc-base \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-deepseq \
 ghc-distributive \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-profunctors \
 ghc-semigroupoids \
 ghc-stm \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-th-abstraction \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-unordered-containers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-free-devel = " \
 ghc-base-devel \
 ghc-comonad-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-distributive-devel \
 ghc-exceptions-devel \
 ghc-free \
 ghc-indexed-traversable-devel \
 ghc-mtl-devel \
 ghc-profunctors-devel \
 ghc-semigroupoids-devel \
 ghc-template-haskell-devel \
 ghc-th-abstraction-devel \
 ghc-transformers-base-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-free-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-free-prof = " \
 ghc-base-prof \
 ghc-comonad-prof \
 ghc-containers-prof \
 ghc-distributive-prof \
 ghc-exceptions-prof \
 ghc-free-devel \
 ghc-indexed-traversable-prof \
 ghc-mtl-prof \
 ghc-profunctors-prof \
 ghc-semigroupoids-prof \
 ghc-template-haskell-prof \
 ghc-th-abstraction-prof \
 ghc-transformers-base-prof \
 ghc-transformers-prof \
 "
