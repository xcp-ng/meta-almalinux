# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-redhat-leapp"
PV = "1.7.4"
PR = "1.el10_2"
PACKAGES = " \
 ansible-collection-redhat-leapp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-collection-redhat-leapp-1.7.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be6064346d770567c6d792cef0183e35d638d57a3fccf41910cdec2d7ac7e0e4"

URI_x86_64_v2_ansible-collection-redhat-leapp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-collection-redhat-leapp-1.7.4-1.el10_2.noarch.rpm;name=x86_64_v2_ansible-collection-redhat-leapp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-redhat-leapp}"
SRC_URI[x86_64_v2_ansible-collection-redhat-leapp.sha256sum] = "120f2ff5e5e90b00addccc26f1a65ff66bb667ac0b052611a96b235ff56ca521"

URI_aarch64_ansible-collection-redhat-leapp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-collection-redhat-leapp-1.7.4-1.el10_2.noarch.rpm;name=aarch64_ansible-collection-redhat-leapp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-redhat-leapp}"
SRC_URI[aarch64_ansible-collection-redhat-leapp.sha256sum] = "120f2ff5e5e90b00addccc26f1a65ff66bb667ac0b052611a96b235ff56ca521"

RDEPENDS:ansible-collection-redhat-leapp = " \
 ansible-core \
 bash \
 rhel-system-roles \
 "
