# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-21-openjdk"
PE = "1"
PV = "21.0.12.1.1"
PR = "1.2.el10.alma.1"
PACKAGES = " \
 java-21-openjdk \
 java-21-openjdk-demo \
 java-21-openjdk-demo-fastdebug \
 java-21-openjdk-demo-slowdebug \
 java-21-openjdk-devel \
 java-21-openjdk-devel-fastdebug \
 java-21-openjdk-devel-slowdebug \
 java-21-openjdk-fastdebug \
 java-21-openjdk-headless \
 java-21-openjdk-headless-fastdebug \
 java-21-openjdk-headless-slowdebug \
 java-21-openjdk-javadoc \
 java-21-openjdk-javadoc-zip \
 java-21-openjdk-jmods \
 java-21-openjdk-jmods-fastdebug \
 java-21-openjdk-jmods-slowdebug \
 java-21-openjdk-slowdebug \
 java-21-openjdk-src \
 java-21-openjdk-src-fastdebug \
 java-21-openjdk-src-slowdebug \
 java-21-openjdk-static-libs \
 java-21-openjdk-static-libs-fastdebug \
 java-21-openjdk-static-libs-slowdebug \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/java-21-openjdk-21.0.12.1.1-1.2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7a0078425a3ee8720c1c06ec408116edff7f3bf5d8beecdda524004bc292e9e"

URI_x86_64_v2_java-21-openjdk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk}"
SRC_URI[x86_64_v2_java-21-openjdk.sha256sum] = "df5fbc78119913d01fa66f5c4ba3239817cb37685caabcc688eefd1f71686015"

URI_x86_64_v2_java-21-openjdk-demo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-demo-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-demo}"
SRC_URI[x86_64_v2_java-21-openjdk-demo.sha256sum] = "ccbe1340d10e47737844663344047952eb52269704d3e67df12994cdcbe96e48"

URI_x86_64_v2_java-21-openjdk-demo-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-demo-fastdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-demo-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-demo-fastdebug.sha256sum] = "1dc5d61401857319aa6c4f84381620efec33915093dfa7ec67f1a7ed059f41b6"

URI_x86_64_v2_java-21-openjdk-demo-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-demo-slowdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-demo-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-demo-slowdebug.sha256sum] = "413ba129ef844e205e9a43937c1577b2db0fd8691291cc50a599247ebdf10dc5"

URI_x86_64_v2_java-21-openjdk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-devel-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-devel}"
SRC_URI[x86_64_v2_java-21-openjdk-devel.sha256sum] = "0f87f660e194507b8d52428f90ed835efeb52464613513e7e689167cb5e260ee"

URI_x86_64_v2_java-21-openjdk-devel-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-devel-fastdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-devel-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-devel-fastdebug.sha256sum] = "a4b5cc6d452850bc73c886b95050ce078316641938ad18b0c64f1b9d16753787"

URI_x86_64_v2_java-21-openjdk-devel-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-devel-slowdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-devel-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-devel-slowdebug.sha256sum] = "c47c8a3d66ea25dee59de2c85289a8e871fdf5e436b6de03830c0d0305ee7663"

URI_x86_64_v2_java-21-openjdk-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-fastdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-fastdebug.sha256sum] = "1b5e0affeebda476f2422c70c40ae20e891e4772d97c67225f0af24e30c09dae"

URI_x86_64_v2_java-21-openjdk-headless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-headless-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-headless}"
SRC_URI[x86_64_v2_java-21-openjdk-headless.sha256sum] = "fb486ae0612e465a078589cf668b0d6e5137ed295170dc0c2b83696de14ad91e"
RPROVIDES:java-21-openjdk-headless:x86_64_v2 = "virtual/java-headless_or_java-21-headless_or_java-25-headless virtual/java-headless_or_java-25-headless"

URI_x86_64_v2_java-21-openjdk-headless-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-headless-fastdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-headless-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-headless-fastdebug.sha256sum] = "14e8a18e17b4c0e00d357f97af43c386d5f4b9870c7a5fdd69a3ac1263bfed0a"

URI_x86_64_v2_java-21-openjdk-headless-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-headless-slowdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-headless-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-headless-slowdebug.sha256sum] = "478946083dee1adbf7a09244686834ac72924365ce72e3e99808b62e2e4613af"

URI_x86_64_v2_java-21-openjdk-javadoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-javadoc-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-javadoc}"
SRC_URI[x86_64_v2_java-21-openjdk-javadoc.sha256sum] = "b6ed99bb0b6a69fe10d9caae021b09b2c10f4f3d4e0055ebf661280cad97f706"

URI_x86_64_v2_java-21-openjdk-javadoc-zip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-javadoc-zip-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-javadoc-zip}"
SRC_URI[x86_64_v2_java-21-openjdk-javadoc-zip.sha256sum] = "fb80c89ecdebc205a531b889c57d923ebfe27218e9467132aef9824c5b41924b"

URI_x86_64_v2_java-21-openjdk-jmods = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-jmods-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-jmods}"
SRC_URI[x86_64_v2_java-21-openjdk-jmods.sha256sum] = "a9cfc355ace2a8f1d576b4eaf5ba7469ba322b23eb946723c18f2f3bed8cacb2"

URI_x86_64_v2_java-21-openjdk-jmods-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-jmods-fastdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-jmods-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-jmods-fastdebug.sha256sum] = "cfdb13ae05fcb5b4988358e83350a036e6495e321222156e87691d8cea2fee0d"

URI_x86_64_v2_java-21-openjdk-jmods-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-jmods-slowdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-jmods-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-jmods-slowdebug.sha256sum] = "071e44b3f93e40ffec319e4e90139dc3884f9d83cc8df0ba412dd95d77eb91f8"

URI_x86_64_v2_java-21-openjdk-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-slowdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-slowdebug.sha256sum] = "e538b4cef485f9fd349e4f8d7ed0dee999909599e1b8f5fa065c669029f52c3c"

URI_x86_64_v2_java-21-openjdk-src = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-src-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-src}"
SRC_URI[x86_64_v2_java-21-openjdk-src.sha256sum] = "2e1f03f5af3ad29a954bc6de84c3fe9a5c151c8fad398573123875ce7180e523"

URI_x86_64_v2_java-21-openjdk-src-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-src-fastdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-src-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-src-fastdebug.sha256sum] = "5689e3194b50d0960ea153fe0be430503a0601719ab2fd0924c1776d9a982703"

URI_x86_64_v2_java-21-openjdk-src-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-src-slowdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-src-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-src-slowdebug.sha256sum] = "1784f84ac7264987a6ad134f1624b7b7cad2321da102f291a833374be788a8b8"

URI_x86_64_v2_java-21-openjdk-static-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-static-libs-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-static-libs}"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs.sha256sum] = "89c962f8a0870da03d659d3130031947fdbf89ce8ff5e21d7bab6477e68da3ea"

URI_x86_64_v2_java-21-openjdk-static-libs-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-static-libs-fastdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-static-libs-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs-fastdebug.sha256sum] = "fbd3707d66c342b8a9b4a20111e15af01fa090d3995b29ed7b2f37f37d911bc0"

URI_x86_64_v2_java-21-openjdk-static-libs-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-static-libs-slowdebug-21.0.12.1.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-static-libs-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs-slowdebug.sha256sum] = "b2a419048ce625dc51139f5dc57714410e903f113f7bc7495b9dd328b22bb92b"

URI_aarch64_java-21-openjdk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk}"
SRC_URI[aarch64_java-21-openjdk.sha256sum] = "7e7899ae75ac21990f7f496dfe98645bab2b952733d62fdb69ad41e46d56142e"

URI_aarch64_java-21-openjdk-demo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-demo-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-demo}"
SRC_URI[aarch64_java-21-openjdk-demo.sha256sum] = "f72ab3d8155fb58f783c69e2e6db159cfd598420c4baba3829c92c80b8d41d8d"

URI_aarch64_java-21-openjdk-demo-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-demo-fastdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-demo-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-demo-fastdebug.sha256sum] = "665bdaf8bf573f0443e7370c2cd94c428f9ad12d4c774c2558395041c1a17c7d"

URI_aarch64_java-21-openjdk-demo-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-demo-slowdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-demo-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-demo-slowdebug.sha256sum] = "a60745c2e79de5112dfb01ce6e9848fe37402f8aeae331845f7568cf119b1bac"

URI_aarch64_java-21-openjdk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-devel-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-devel}"
SRC_URI[aarch64_java-21-openjdk-devel.sha256sum] = "12245417bd0d01d6209b20611377237bcb838f28bcdec6e6bbe8ee92a7937a5f"

URI_aarch64_java-21-openjdk-devel-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-devel-fastdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-devel-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-devel-fastdebug.sha256sum] = "1f0755759b0fcfeef0354395232182478b92c173744c26b3263d0749b9e01008"

URI_aarch64_java-21-openjdk-devel-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-devel-slowdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-devel-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-devel-slowdebug.sha256sum] = "207457b7f7c5e31efb9bfd2082f15418a72826ea751baf02e1af6256b00736a8"

URI_aarch64_java-21-openjdk-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-fastdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-fastdebug.sha256sum] = "26d6f9cf76b2f8a9319c3db8f0a7a69d296f80c29d9c0840efdd8e2a09b99766"

URI_aarch64_java-21-openjdk-headless = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-headless-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-headless}"
SRC_URI[aarch64_java-21-openjdk-headless.sha256sum] = "d18ba692e091a6d6d83bfac166d45d2cb16cf946b19f8ee9348dfa2177e27743"
RPROVIDES:java-21-openjdk-headless:aarch64 = "virtual/java-headless_or_java-21-headless_or_java-25-headless virtual/java-headless_or_java-25-headless"

URI_aarch64_java-21-openjdk-headless-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-headless-fastdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-headless-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-headless-fastdebug.sha256sum] = "25b4e70da14bd3989d4ff07165c02ae5e361ba5257a159f2f6ad5a5aad755c0f"

URI_aarch64_java-21-openjdk-headless-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-headless-slowdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-headless-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-headless-slowdebug.sha256sum] = "c9d265395b9915fc155d1735ccbc42614e4875f17c984ef5136e57d94ff44093"

URI_aarch64_java-21-openjdk-javadoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-javadoc-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-javadoc}"
SRC_URI[aarch64_java-21-openjdk-javadoc.sha256sum] = "041458bc0c0fdee0843015c972614a3223267e1395a95ca39b6a0ca37bd6af7b"

URI_aarch64_java-21-openjdk-javadoc-zip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-javadoc-zip-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-javadoc-zip}"
SRC_URI[aarch64_java-21-openjdk-javadoc-zip.sha256sum] = "329b6243074a57bb87ea4d414a3c8a3e3d1bf685c486475fa3cd304af80d5179"

URI_aarch64_java-21-openjdk-jmods = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-jmods-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-jmods}"
SRC_URI[aarch64_java-21-openjdk-jmods.sha256sum] = "6be5cd666ddf4ae185f847ed452112aa6bb07ae95f069a02a8795ed575a7419a"

URI_aarch64_java-21-openjdk-jmods-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-jmods-fastdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-jmods-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-jmods-fastdebug.sha256sum] = "73cbb3ce79a78f5b33ff4893102b497d3046addac6d771a68efbecd4c9dfe98c"

URI_aarch64_java-21-openjdk-jmods-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-jmods-slowdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-jmods-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-jmods-slowdebug.sha256sum] = "70ab29cfbecc4554a1e666ee2c6389183773193ef143917888a710c9e11cf91f"

URI_aarch64_java-21-openjdk-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-slowdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-slowdebug.sha256sum] = "edd65ffd890c79d91dd56c5fbac1a8d7c8417f6fdc1de91de27f1ff1e8428679"

URI_aarch64_java-21-openjdk-src = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-src-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-src}"
SRC_URI[aarch64_java-21-openjdk-src.sha256sum] = "faaac8b2f5b7846e920a8fa46be2221373d6e4f1ff94935d033a22cac234f0c6"

URI_aarch64_java-21-openjdk-src-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-src-fastdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-src-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-src-fastdebug.sha256sum] = "a04aa7d355e27dd6ee59230f38a643c9440fbb9037c2db26055e6d2741bdb801"

URI_aarch64_java-21-openjdk-src-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-src-slowdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-src-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-src-slowdebug.sha256sum] = "19e24847575251905eafb1d0c602a4c2b8f5c492dd3f05a16979c69501ce0f2c"

URI_aarch64_java-21-openjdk-static-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-static-libs-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-static-libs}"
SRC_URI[aarch64_java-21-openjdk-static-libs.sha256sum] = "ed1a66339a023cd6b91160cf6a9915b4c7ad0be01829a5ea96a9da2ede406994"

URI_aarch64_java-21-openjdk-static-libs-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-static-libs-fastdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-static-libs-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-static-libs-fastdebug.sha256sum] = "971106df2ca1e7deb7f8f72fa350b774c8a10cf639f5cc9c240e6d342327e6f9"

URI_aarch64_java-21-openjdk-static-libs-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-static-libs-slowdebug-21.0.12.1.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-static-libs-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-static-libs-slowdebug.sha256sum] = "251e73774b1f6d3ac753deec62f547355ee79c7f4a6af2408183b55ef36ec05e"

RDEPENDS:java-21-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-21-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-demo = " \
 java-21-openjdk \
 "
RDEPENDS:java-21-openjdk-demo-fastdebug = " \
 java-21-openjdk-fastdebug \
 "
RDEPENDS:java-21-openjdk-demo-slowdebug = " \
 java-21-openjdk-slowdebug \
 "
RDEPENDS:java-21-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-21-openjdk \
 "
RDEPENDS:java-21-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 java-21-openjdk-fastdebug \
 "
RDEPENDS:java-21-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 java-21-openjdk-slowdebug \
 "
RDEPENDS:java-21-openjdk-fastdebug = " \
 bash \
 fontconfig \
 java-21-openjdk-headless-fastdebug \
 libXcomposite \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-headless-fastdebug = " \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-headless-slowdebug = " \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-javadoc = " \
 alternatives \
 bash \
 java-21-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-21-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 java-21-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-21-openjdk-jmods = " \
 java-21-openjdk-devel \
 "
RDEPENDS:java-21-openjdk-jmods-fastdebug = " \
 java-21-openjdk-devel-fastdebug \
 "
RDEPENDS:java-21-openjdk-jmods-slowdebug = " \
 java-21-openjdk-devel-slowdebug \
 "
RDEPENDS:java-21-openjdk-slowdebug = " \
 bash \
 fontconfig \
 java-21-openjdk-headless-slowdebug \
 libXcomposite \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-src = " \
 java-21-openjdk-headless \
 "
RDEPENDS:java-21-openjdk-src-fastdebug = " \
 java-21-openjdk-headless-fastdebug \
 "
RDEPENDS:java-21-openjdk-src-slowdebug = " \
 java-21-openjdk-headless-slowdebug \
 "
RDEPENDS:java-21-openjdk-static-libs = " \
 java-21-openjdk-devel \
 "
RDEPENDS:java-21-openjdk-static-libs-fastdebug = " \
 java-21-openjdk-devel-fastdebug \
 "
RDEPENDS:java-21-openjdk-static-libs-slowdebug = " \
 java-21-openjdk-devel-slowdebug \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless rpm/virtual/java-headless_or_java-25-headless"

PROVIDES:append:aarch64 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless rpm/virtual/java-headless_or_java-25-headless"
