# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-manuel"
PV = "1.12.4"
PR = "9.el10_0"
PACKAGES = " \
 python3-manuel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-manuel-1.12.4-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9747867a88a877ef8be9a73643865bed32265ad2a6b8ec7eca11330e1a447f8a"

URI_x86_64_v2_python3-manuel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-manuel-1.12.4-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-manuel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-manuel}"
SRC_URI[x86_64_v2_python3-manuel.sha256sum] = "4b8c94c384bb0026ccb06b5a60fd9a7b9f52ec54010096fe52b1397d1ca4b872"

URI_aarch64_python3-manuel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-manuel-1.12.4-9.el10_0.noarch.rpm;name=aarch64_python3-manuel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-manuel}"
SRC_URI[aarch64_python3-manuel.sha256sum] = "a3ba9310b5ccc20041ed7ac8b6b044cf1d41d64e4dd5b9f43e68b0f9afea4852"

RDEPENDS:python3-manuel = " \
 python3 \
 python3-setuptools \
 python3-six \
 "
