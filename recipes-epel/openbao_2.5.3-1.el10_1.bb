# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openbao"
PV = "2.5.3"
PR = "1.el10_1"
PACKAGES = " \
 openbao \
 openbao-vault-compat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openbao-2.5.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "297292da13863b73df6ad95c33acee0091b53ebceed2fb8d700700fde7fefb30"

URI_x86_64_v2_openbao = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbao-2.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbao;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openbao}"
SRC_URI[x86_64_v2_openbao.sha256sum] = "9501c9bf90d8939d33a724921d45cd897c11c36db732d01ad45ec3225ceb7e05"

URI_x86_64_v2_openbao-vault-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbao-vault-compat-2.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbao-vault-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openbao-vault-compat}"
SRC_URI[x86_64_v2_openbao-vault-compat.sha256sum] = "1fed862d5c24972fedfdec227ee5eaab34f8fbf7f2d51f47c5e9e54d611622ec"

URI_aarch64_openbao = "${EPEL_MIRROR}/aarch64/Packages/o/openbao-2.5.3-1.el10_1.aarch64.rpm;name=aarch64_openbao;unpack=0"
SRC_URI:append = " ${URI_aarch64_openbao}"
SRC_URI[aarch64_openbao.sha256sum] = "f9a14be4b35b2fdb7c26ecf119a15541b2eae4c88d989634f07aa6ca67ae51f4"

URI_aarch64_openbao-vault-compat = "${EPEL_MIRROR}/aarch64/Packages/o/openbao-vault-compat-2.5.3-1.el10_1.aarch64.rpm;name=aarch64_openbao-vault-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openbao-vault-compat}"
SRC_URI[aarch64_openbao-vault-compat.sha256sum] = "427368a9687592e3ff28501bcf60b27189da72e739a2ef3c10b0c06c00dcc075"

RDEPENDS:openbao = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:openbao-vault-compat = " \
 openbao \
 "
