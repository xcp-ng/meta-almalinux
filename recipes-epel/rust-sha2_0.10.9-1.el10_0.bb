# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha2"
PV = "0.10.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-sha2+asm-aarch64-devel \
 rust-sha2+asm-devel \
 rust-sha2+compress-devel \
 rust-sha2+default-devel \
 rust-sha2+force-soft-compact-devel \
 rust-sha2+force-soft-devel \
 rust-sha2+loongarch64_asm-devel \
 rust-sha2+oid-devel \
 rust-sha2+sha2-asm-devel \
 rust-sha2+std-devel \
 rust-sha2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha2-0.10.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef34832bc28825f5bfc90464cac1d6314d9866c147288af140ad60facf3625a7"

URI_x86_64_v2_rust-sha2+asm-aarch64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+asm-aarch64-devel-0.10.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+asm-aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+asm-aarch64-devel}"
SRC_URI[x86_64_v2_rust-sha2+asm-aarch64-devel.sha256sum] = "e06ca29f36594ebfdb05aa5d5338bfb73e1f7f62bd005da2c3747f702567ae4d"

URI_x86_64_v2_rust-sha2+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+asm-devel-0.10.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+asm-devel}"
SRC_URI[x86_64_v2_rust-sha2+asm-devel.sha256sum] = "1658e9e41553a9b10d97702065ae822ec728998f4f062bc059f7e9faceb2abf3"

URI_x86_64_v2_rust-sha2+compress-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+compress-devel-0.10.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+compress-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+compress-devel}"
SRC_URI[x86_64_v2_rust-sha2+compress-devel.sha256sum] = "4ba0f1976b33863a8ba4b3aa02a035397fae13d12d47acc805bb1264bf0fd410"

URI_x86_64_v2_rust-sha2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+default-devel-0.10.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+default-devel}"
SRC_URI[x86_64_v2_rust-sha2+default-devel.sha256sum] = "7b1d0000d68d1ec0cd3c7b6c92bcb57e3ac9303040444828f4a14f52006552a7"

URI_x86_64_v2_rust-sha2+force-soft-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+force-soft-compact-devel-0.10.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+force-soft-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+force-soft-compact-devel}"
SRC_URI[x86_64_v2_rust-sha2+force-soft-compact-devel.sha256sum] = "42f5af7a123eb85a40463bbcf505907832d5e40d0606fa01e5ef349af290c059"

URI_x86_64_v2_rust-sha2+force-soft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+force-soft-devel-0.10.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+force-soft-devel}"
SRC_URI[x86_64_v2_rust-sha2+force-soft-devel.sha256sum] = "c67a1e4526b1688ee7f502d45b7482eff3f9745f41419d17d1547dbd34285061"

URI_x86_64_v2_rust-sha2+loongarch64_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+loongarch64_asm-devel-0.10.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+loongarch64_asm-devel}"
SRC_URI[x86_64_v2_rust-sha2+loongarch64_asm-devel.sha256sum] = "119d833395e9ddefa3784b2898f6b12e2bd5b22210707b0ea6daca801b0bebdc"

URI_x86_64_v2_rust-sha2+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+oid-devel-0.10.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+oid-devel}"
SRC_URI[x86_64_v2_rust-sha2+oid-devel.sha256sum] = "ee2594b19d78836d7df6fbe590471be34fca8f5a0cd4cde225f15550a7d9b9e2"

URI_x86_64_v2_rust-sha2+sha2-asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+sha2-asm-devel-0.10.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+sha2-asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+sha2-asm-devel}"
SRC_URI[x86_64_v2_rust-sha2+sha2-asm-devel.sha256sum] = "c8e5e1aa095447558eb4e2376435e80967b333dc0aa3af86fef1361c40e35f48"

URI_x86_64_v2_rust-sha2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+std-devel-0.10.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+std-devel}"
SRC_URI[x86_64_v2_rust-sha2+std-devel.sha256sum] = "dca5c3c3c6fd77c6eaa0ea91a94b985033eda349891d73ece4c8e873d0b5b3e2"

URI_x86_64_v2_rust-sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2-devel-0.10.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2-devel}"
SRC_URI[x86_64_v2_rust-sha2-devel.sha256sum] = "6f582898a95a3edac1716a3cd397ce81d793f822e8737cbe8183fa49f1988373"

URI_aarch64_rust-sha2+asm-aarch64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+asm-aarch64-devel-0.10.9-1.el10_0.noarch.rpm;name=aarch64_rust-sha2+asm-aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+asm-aarch64-devel}"
SRC_URI[aarch64_rust-sha2+asm-aarch64-devel.sha256sum] = "d438b03bb283fa4a0a63fb9848c235abd784560d80233854c9844e22f9a3e933"

URI_aarch64_rust-sha2+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+asm-devel-0.10.9-1.el10_0.noarch.rpm;name=aarch64_rust-sha2+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+asm-devel}"
SRC_URI[aarch64_rust-sha2+asm-devel.sha256sum] = "ba8e8e809fc202cca0c0a0cc2404bd8bcda4fe624493065e17181fe19742dda5"

URI_aarch64_rust-sha2+compress-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+compress-devel-0.10.9-1.el10_0.noarch.rpm;name=aarch64_rust-sha2+compress-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+compress-devel}"
SRC_URI[aarch64_rust-sha2+compress-devel.sha256sum] = "9ba82bd28f117d8a72acb2e1d4b75af0a4515fa3b7bdc5807fd702f8b055e8d2"

URI_aarch64_rust-sha2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+default-devel-0.10.9-1.el10_0.noarch.rpm;name=aarch64_rust-sha2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+default-devel}"
SRC_URI[aarch64_rust-sha2+default-devel.sha256sum] = "036fcc0f805d250afa84e6e37acbd1a5091ca4432aec9b82481e7f1e7721018a"

URI_aarch64_rust-sha2+force-soft-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+force-soft-compact-devel-0.10.9-1.el10_0.noarch.rpm;name=aarch64_rust-sha2+force-soft-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+force-soft-compact-devel}"
SRC_URI[aarch64_rust-sha2+force-soft-compact-devel.sha256sum] = "85c4fa06e26f81c78a933b2a565a3e45cea0f3006eb0cb510916b726fb2330c9"

URI_aarch64_rust-sha2+force-soft-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+force-soft-devel-0.10.9-1.el10_0.noarch.rpm;name=aarch64_rust-sha2+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+force-soft-devel}"
SRC_URI[aarch64_rust-sha2+force-soft-devel.sha256sum] = "2ad604e0cfe445045c739a1125ad7bf5ed91a77f0ed694d98c35d16a3593582a"

URI_aarch64_rust-sha2+loongarch64_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+loongarch64_asm-devel-0.10.9-1.el10_0.noarch.rpm;name=aarch64_rust-sha2+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+loongarch64_asm-devel}"
SRC_URI[aarch64_rust-sha2+loongarch64_asm-devel.sha256sum] = "bbd42ab3efd7bfa90eb9d0c45cf14f07eca692b556b0dfe22f87494b22bb39cc"

URI_aarch64_rust-sha2+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+oid-devel-0.10.9-1.el10_0.noarch.rpm;name=aarch64_rust-sha2+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+oid-devel}"
SRC_URI[aarch64_rust-sha2+oid-devel.sha256sum] = "bde75731127c383fa692774bfaeec6135ce718cdbd3911e5056a38f5f89b42d6"

URI_aarch64_rust-sha2+sha2-asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+sha2-asm-devel-0.10.9-1.el10_0.noarch.rpm;name=aarch64_rust-sha2+sha2-asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+sha2-asm-devel}"
SRC_URI[aarch64_rust-sha2+sha2-asm-devel.sha256sum] = "5593b374164939bb752f49fbb0136c798c56649e06027aef61b521e3c5c53f35"

URI_aarch64_rust-sha2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+std-devel-0.10.9-1.el10_0.noarch.rpm;name=aarch64_rust-sha2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+std-devel}"
SRC_URI[aarch64_rust-sha2+std-devel.sha256sum] = "8d606ad4182d0132f8721d0d9f8c5035bdbbc541f633812677f487bd177d1bd3"

URI_aarch64_rust-sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2-devel-0.10.9-1.el10_0.noarch.rpm;name=aarch64_rust-sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2-devel}"
SRC_URI[aarch64_rust-sha2-devel.sha256sum] = "c639673a50ccd110b1eb952aeb2a2d489b1e05e6e08006a18c9fa7c9a7221c8e"

RDEPENDS:rust-sha2+asm-aarch64-devel = " \
 cargo \
 rust-sha2+asm-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+asm-devel = " \
 cargo \
 rust-sha2+sha2-asm-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+compress-devel = " \
 cargo \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+default-devel = " \
 cargo \
 rust-sha2+std-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+force-soft-compact-devel = " \
 cargo \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+force-soft-devel = " \
 cargo \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+loongarch64_asm-devel = " \
 cargo \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+oid-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+sha2-asm-devel = " \
 cargo \
 rust-sha2-asm+default-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-cpufeatures+default-devel \
 rust-digest+default-devel \
 "
