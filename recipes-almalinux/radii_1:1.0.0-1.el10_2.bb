# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radii"
PE = "1"
PV = "1.0.0"
PR = "1.el10_2"
PACKAGES = " \
 radii \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/radii-1.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a5ca8d2333730e3722844099b6544485e78aa8c4e55d30f2a54330dff31e4c09"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/radii-1.0.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_radii;unpack=0"
SRC_URI[x86_64_v2_radii.sha256sum] = "c80d543810eb64b980dd21e76eb2abcc5007247cf9ad924003cc982cd5a4e20e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/radii-1.0.0-1.el10_2.aarch64.rpm;name=aarch64_radii;unpack=0"
SRC_URI[aarch64_radii.sha256sum] = "ed0751e20c09b1736e515b59cde3fdefc2c661b9859f5b4d0341d21058669f0f"

RDEPENDS:radii = " \
 glibc \
 radii-hwdata-nv \
 "
