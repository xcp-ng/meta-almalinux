# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fcgi"
PV = "2.4.7"
PR = "1.el10_2"
PACKAGES = " \
 fcgi \
 fcgi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fcgi-2.4.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aab3cfd67d56d457437f1c72a42701f48eee9e09a0cc8998419b33edc2f0ae57"

URI_x86_64_v2_fcgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fcgi-2.4.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fcgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fcgi}"
SRC_URI[x86_64_v2_fcgi.sha256sum] = "24544cd1fa1110bf28f996362e1e93941fb73efe6dd03325e8d49b677680076a"

URI_x86_64_v2_fcgi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fcgi-devel-2.4.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fcgi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fcgi-devel}"
SRC_URI[x86_64_v2_fcgi-devel.sha256sum] = "22ccdd64d1d7d2aef56e1371648247f0a673c376f5be17da930b02e200fb5607"

URI_aarch64_fcgi = "${EPEL_MIRROR}/aarch64/Packages/f/fcgi-2.4.7-1.el10_2.aarch64.rpm;name=aarch64_fcgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_fcgi}"
SRC_URI[aarch64_fcgi.sha256sum] = "947b9bfd9400caaf2e78a56aceca8122a1659353020698588ab21e75da19e9b4"

URI_aarch64_fcgi-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fcgi-devel-2.4.7-1.el10_2.aarch64.rpm;name=aarch64_fcgi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fcgi-devel}"
SRC_URI[aarch64_fcgi-devel.sha256sum] = "a1f32088d1affc7aa4342f6be07bec61409ad2e27f8103eb99b7a2d92e2db760"

RDEPENDS:fcgi = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:fcgi-devel = " \
 fcgi \
 pkgconf-pkg-config \
 "
