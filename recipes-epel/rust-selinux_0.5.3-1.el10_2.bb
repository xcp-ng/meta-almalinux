# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-selinux"
PV = "0.5.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-selinux+default-devel \
 rust-selinux-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-selinux-0.5.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35ee6f849c9621ea055434f053d1cc7c6336687dd3e50f27f9b25f0e4fddb59f"

URI_x86_64_v2_rust-selinux+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-selinux+default-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-selinux+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-selinux+default-devel}"
SRC_URI[x86_64_v2_rust-selinux+default-devel.sha256sum] = "2a146f5699743de74827773f9775195eaef587abea81914508649f52d5c5fe06"

URI_x86_64_v2_rust-selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-selinux-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-selinux-devel}"
SRC_URI[x86_64_v2_rust-selinux-devel.sha256sum] = "c2e3c17a5058e982d125dd43a835a48aa6637b9482540778241a80cb68cc84d4"

URI_aarch64_rust-selinux+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-selinux+default-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-selinux+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-selinux+default-devel}"
SRC_URI[aarch64_rust-selinux+default-devel.sha256sum] = "7aa1e535ecbfc8d19e09abc538659f671172ccc525edcc28dab5d4422663e0d4"

URI_aarch64_rust-selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-selinux-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-selinux-devel}"
SRC_URI[aarch64_rust-selinux-devel.sha256sum] = "61e389d271ecd855f573d191395ef2e6f5cefbe903b8a058feb8d75bd454f44d"

RDEPENDS:rust-selinux+default-devel = " \
 cargo \
 rust-selinux-devel \
 "
RDEPENDS:rust-selinux-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-errno+default-devel \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 rust-parking_lot+default-devel \
 rust-selinux-sys+default-devel \
 rust-thiserror+default-devel \
 "
