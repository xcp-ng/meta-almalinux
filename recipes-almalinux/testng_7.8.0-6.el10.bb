# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "testng"
PV = "7.8.0"
PR = "6.el10"
PACKAGES = " \
 testng \
 testng-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/testng-7.8.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64061d0f77d7554475f1beaa268210339dcee18978671424f1e13493727af516"

URI_x86_64_v2_testng = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/testng-7.8.0-6.el10.noarch.rpm;name=x86_64_v2_testng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_testng}"
SRC_URI[x86_64_v2_testng.sha256sum] = "830f1e96c8bbddf3ec25d59dc87e04e35a29ff470040b0fd68f8270c062db8df"

URI_x86_64_v2_testng-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/testng-javadoc-7.8.0-6.el10.noarch.rpm;name=x86_64_v2_testng-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_testng-javadoc}"
SRC_URI[x86_64_v2_testng-javadoc.sha256sum] = "496cf6d9426edff11c2a8ff218848995c6df2cbb9c95fe50de27c33d88b378f2"

URI_aarch64_testng = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/testng-7.8.0-6.el10.noarch.rpm;name=aarch64_testng;unpack=0"
SRC_URI:append = " ${URI_aarch64_testng}"
SRC_URI[aarch64_testng.sha256sum] = "830f1e96c8bbddf3ec25d59dc87e04e35a29ff470040b0fd68f8270c062db8df"

URI_aarch64_testng-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/testng-javadoc-7.8.0-6.el10.noarch.rpm;name=aarch64_testng-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_testng-javadoc}"
SRC_URI[aarch64_testng-javadoc.sha256sum] = "496cf6d9426edff11c2a8ff218848995c6df2cbb9c95fe50de27c33d88b378f2"

RDEPENDS:testng = " \
 beust-jcommander \
 javapackages-filesystem \
 slf4j \
 "
RDEPENDS:testng-javadoc = " \
 javapackages-filesystem \
 "
