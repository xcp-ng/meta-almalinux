# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Compress"
PV = "2.212"
PR = "512.el10"
PACKAGES = " \
 perl-IO-Compress \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-IO-Compress-2.212-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c2e93d9e99b93db899ee026590777261a16f310bf272039ff5273dd5d4ec825"

URI_x86_64_v2_perl-IO-Compress = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IO-Compress-2.212-512.el10.noarch.rpm;name=x86_64_v2_perl-IO-Compress;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Compress}"
SRC_URI[x86_64_v2_perl-IO-Compress.sha256sum] = "ea03f48d67511b393dbf19f0c04f7959e19ce2db1795b34e3cc5200563305c55"

URI_aarch64_perl-IO-Compress = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IO-Compress-2.212-512.el10.noarch.rpm;name=aarch64_perl-IO-Compress;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Compress}"
SRC_URI[aarch64_perl-IO-Compress.sha256sum] = "ea03f48d67511b393dbf19f0c04f7959e19ce2db1795b34e3cc5200563305c55"

RDEPENDS:perl-IO-Compress = " \
 perl-Carp \
 perl-Compress-Raw-Bzip2 \
 perl-Compress-Raw-Zlib \
 perl-Data-Dumper \
 perl-Encode \
 perl-Exporter \
 perl-Fcntl \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-Compress \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-Time-Local \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-parent \
 "
