# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gimli"
PV = "0.31.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-gimli+default-devel \
 rust-gimli+endian-reader-devel \
 rust-gimli+fallible-iterator-devel \
 rust-gimli+read-all-devel \
 rust-gimli+read-core-devel \
 rust-gimli+read-devel \
 rust-gimli+std-devel \
 rust-gimli+write-devel \
 rust-gimli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gimli-0.31.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "739d3a4b72abfdf2dee601fc22d177ec0aa203c4f6cae4353ec0ccbce87a2221"

URI_x86_64_v2_rust-gimli+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+default-devel-0.31.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+default-devel}"
SRC_URI[x86_64_v2_rust-gimli+default-devel.sha256sum] = "3eaddcb62c1c84e0958455d780b18c12fd5073ef01ef16b1ace5109a0797ecf3"

URI_x86_64_v2_rust-gimli+endian-reader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+endian-reader-devel-0.31.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+endian-reader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+endian-reader-devel}"
SRC_URI[x86_64_v2_rust-gimli+endian-reader-devel.sha256sum] = "536540b1ff82ce14c3f747d781f3122ae664a07334a19239eafa30dde9c8a967"

URI_x86_64_v2_rust-gimli+fallible-iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+fallible-iterator-devel-0.31.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+fallible-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+fallible-iterator-devel}"
SRC_URI[x86_64_v2_rust-gimli+fallible-iterator-devel.sha256sum] = "cde9cb7ede851f3aed31e8a58ce979bf685cc1152269b4e2a59edd7b8a1ee294"

URI_x86_64_v2_rust-gimli+read-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+read-all-devel-0.31.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+read-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+read-all-devel}"
SRC_URI[x86_64_v2_rust-gimli+read-all-devel.sha256sum] = "96d930ac81bf77249ad317e60f601790b4b65b1c3e468ad36b4ec3855bbf9e79"

URI_x86_64_v2_rust-gimli+read-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+read-core-devel-0.31.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+read-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+read-core-devel}"
SRC_URI[x86_64_v2_rust-gimli+read-core-devel.sha256sum] = "5473aad71124277d1ee2e1247142dbc6a583a828cf4908254d376ed30d5c3540"

URI_x86_64_v2_rust-gimli+read-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+read-devel-0.31.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+read-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+read-devel}"
SRC_URI[x86_64_v2_rust-gimli+read-devel.sha256sum] = "c4ef74782e98057560f86769823e256ef7b67a8e861dfda4a76e9dbecfc99ab3"

URI_x86_64_v2_rust-gimli+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+std-devel-0.31.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+std-devel}"
SRC_URI[x86_64_v2_rust-gimli+std-devel.sha256sum] = "7c2f542771af441093b61715ce7bbed590269217cf2ada59b1d3f821d877df4a"

URI_x86_64_v2_rust-gimli+write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+write-devel-0.31.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+write-devel}"
SRC_URI[x86_64_v2_rust-gimli+write-devel.sha256sum] = "e1204d74f1574d27a88cd63904bd2e8ab99b3b86621eebfdf9f0aaf2cc9e08c0"

URI_x86_64_v2_rust-gimli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli-devel-0.31.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli-devel}"
SRC_URI[x86_64_v2_rust-gimli-devel.sha256sum] = "ac8c6991c3221913db64319295a145907b9e8e1d617e799a1485fbfd9c965016"

URI_aarch64_rust-gimli+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+default-devel-0.31.1-1.el10_0.noarch.rpm;name=aarch64_rust-gimli+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+default-devel}"
SRC_URI[aarch64_rust-gimli+default-devel.sha256sum] = "577813b419e670d29d8c35b58d2ada79527215079a0550f19745bc26ca7713bc"

URI_aarch64_rust-gimli+endian-reader-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+endian-reader-devel-0.31.1-1.el10_0.noarch.rpm;name=aarch64_rust-gimli+endian-reader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+endian-reader-devel}"
SRC_URI[aarch64_rust-gimli+endian-reader-devel.sha256sum] = "fc485187d6f5636a3640e2b12799d6c4163de0569742b7ad395ed98ef0e4e78d"

URI_aarch64_rust-gimli+fallible-iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+fallible-iterator-devel-0.31.1-1.el10_0.noarch.rpm;name=aarch64_rust-gimli+fallible-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+fallible-iterator-devel}"
SRC_URI[aarch64_rust-gimli+fallible-iterator-devel.sha256sum] = "9902335a447ef132dcd36491f28b636c81890b94adc6be9a34b6908f25e7be3c"

URI_aarch64_rust-gimli+read-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+read-all-devel-0.31.1-1.el10_0.noarch.rpm;name=aarch64_rust-gimli+read-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+read-all-devel}"
SRC_URI[aarch64_rust-gimli+read-all-devel.sha256sum] = "e848b0d504098698d5a0b399f3d56d53f33e30599b3364dc2a26e10b565c0341"

URI_aarch64_rust-gimli+read-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+read-core-devel-0.31.1-1.el10_0.noarch.rpm;name=aarch64_rust-gimli+read-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+read-core-devel}"
SRC_URI[aarch64_rust-gimli+read-core-devel.sha256sum] = "ae46bbadfe4b78a8716dbb1ad70a119086b96191078222247882dfccb3f16385"

URI_aarch64_rust-gimli+read-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+read-devel-0.31.1-1.el10_0.noarch.rpm;name=aarch64_rust-gimli+read-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+read-devel}"
SRC_URI[aarch64_rust-gimli+read-devel.sha256sum] = "bec4ee7b4199d78efe14b9429d6f23124c7dedba44d91b79f2df34850e92db3c"

URI_aarch64_rust-gimli+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+std-devel-0.31.1-1.el10_0.noarch.rpm;name=aarch64_rust-gimli+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+std-devel}"
SRC_URI[aarch64_rust-gimli+std-devel.sha256sum] = "c8490a8b4eba9919fc39ceb00f392bae695a82f6ec67767e6c713d028b0973c3"

URI_aarch64_rust-gimli+write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+write-devel-0.31.1-1.el10_0.noarch.rpm;name=aarch64_rust-gimli+write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+write-devel}"
SRC_URI[aarch64_rust-gimli+write-devel.sha256sum] = "5eb300aa63da4132ac2831bece961fc9a8cb0794e3005236892746fb26e25811"

URI_aarch64_rust-gimli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli-devel-0.31.1-1.el10_0.noarch.rpm;name=aarch64_rust-gimli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli-devel}"
SRC_URI[aarch64_rust-gimli-devel.sha256sum] = "695f65b5ce6c1b536a84d4b723e3b600841b24b52db999c49ac7bb7d819fb0af"

RDEPENDS:rust-gimli+default-devel = " \
 cargo \
 rust-gimli+read-all-devel \
 rust-gimli+write-devel \
 rust-gimli-devel \
 "
RDEPENDS:rust-gimli+endian-reader-devel = " \
 cargo \
 rust-gimli+read-devel \
 rust-gimli-devel \
 rust-stable_deref_trait-devel \
 "
RDEPENDS:rust-gimli+fallible-iterator-devel = " \
 cargo \
 rust-fallible-iterator-devel \
 rust-gimli-devel \
 "
RDEPENDS:rust-gimli+read-all-devel = " \
 cargo \
 rust-gimli+endian-reader-devel \
 rust-gimli+fallible-iterator-devel \
 rust-gimli+read-devel \
 rust-gimli+std-devel \
 rust-gimli-devel \
 "
RDEPENDS:rust-gimli+read-core-devel = " \
 cargo \
 rust-gimli-devel \
 "
RDEPENDS:rust-gimli+read-devel = " \
 cargo \
 rust-gimli+read-core-devel \
 rust-gimli-devel \
 "
RDEPENDS:rust-gimli+std-devel = " \
 cargo \
 rust-fallible-iterator+std-devel \
 rust-fallible-iterator-devel \
 rust-gimli-devel \
 rust-stable_deref_trait+std-devel \
 rust-stable_deref_trait-devel \
 "
RDEPENDS:rust-gimli+write-devel = " \
 cargo \
 rust-gimli-devel \
 rust-indexmap+default-devel \
 "
RDEPENDS:rust-gimli-devel = " \
 cargo \
 rust \
 "
