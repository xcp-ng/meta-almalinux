# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-body-util"
PV = "0.1.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-http-body-util+channel-devel \
 rust-http-body-util+default-devel \
 rust-http-body-util+full-devel \
 rust-http-body-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-body-util-0.1.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b6cdd99a1ae184958c2d54438c64f2f2a3f127f7ed8c09a10deed21c418422a"

URI_x86_64_v2_rust-http-body-util+channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+channel-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util+channel-devel}"
SRC_URI[x86_64_v2_rust-http-body-util+channel-devel.sha256sum] = "9147c3a1e40d88970b14fc149af2af29eac4d5840d81032b25044b2bc42edd3a"

URI_x86_64_v2_rust-http-body-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+default-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util+default-devel}"
SRC_URI[x86_64_v2_rust-http-body-util+default-devel.sha256sum] = "90115456afa6c24b285a337c14949e7364fc981ec89d2e0e95b39db3369cb1dc"

URI_x86_64_v2_rust-http-body-util+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+full-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util+full-devel}"
SRC_URI[x86_64_v2_rust-http-body-util+full-devel.sha256sum] = "e600f5609af80d4ad1f15fa576774c5bfe96be092d9965a10dcd0b6e6d77a065"

URI_x86_64_v2_rust-http-body-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util-devel}"
SRC_URI[x86_64_v2_rust-http-body-util-devel.sha256sum] = "fa366871ac8eb7bb947346ac88185624566731d2e81b3a0f471238de8775bc63"

URI_aarch64_rust-http-body-util+channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+channel-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-http-body-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util+channel-devel}"
SRC_URI[aarch64_rust-http-body-util+channel-devel.sha256sum] = "c8255cd39dc8cce0849d095d3a87b9bc4e3da0ee8c3312ae6fc4dcbbc0aaf53f"

URI_aarch64_rust-http-body-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+default-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-http-body-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util+default-devel}"
SRC_URI[aarch64_rust-http-body-util+default-devel.sha256sum] = "4f77533f9bdcbd2c36b5fbb28ce28dcfee2b27591111a591ab4259a61a81c6c5"

URI_aarch64_rust-http-body-util+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+full-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-http-body-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util+full-devel}"
SRC_URI[aarch64_rust-http-body-util+full-devel.sha256sum] = "d72c9e0f3ba2966474f7c6e28eceb9a88d7ddd64858617be8dcbe91b3d4f14d0"

URI_aarch64_rust-http-body-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-http-body-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util-devel}"
SRC_URI[aarch64_rust-http-body-util-devel.sha256sum] = "06c7b72dad86a9d08921aa1a1f71de8e9c6c43a77f84a11c6060812718d0c6fd"

RDEPENDS:rust-http-body-util+channel-devel = " \
 cargo \
 rust-http-body-util-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
RDEPENDS:rust-http-body-util+default-devel = " \
 cargo \
 rust-http-body-util-devel \
 "
RDEPENDS:rust-http-body-util+full-devel = " \
 cargo \
 rust-http-body-util+channel-devel \
 rust-http-body-util-devel \
 "
RDEPENDS:rust-http-body-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-futures-core-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-pin-project-lite+default-devel \
 "
