# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-session"
PV = "46.0"
PR = "11.el10"
PACKAGES = " \
 gnome-session \
 gnome-session-wayland-session \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-session-46.0-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "688af7c0885d045307d50b9a4d03c7e1bf77f5aa80a93b9f9d9c5cd355e4c290"

URI_x86_64_v2_gnome-session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-session-46.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-session}"
SRC_URI[x86_64_v2_gnome-session.sha256sum] = "8ad20086a5aa1e6576d93d64eefcf45d4cab5dd770371c5117ee36fa7cdd6ab1"

URI_x86_64_v2_gnome-session-wayland-session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-session-wayland-session-46.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-session-wayland-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-session-wayland-session}"
SRC_URI[x86_64_v2_gnome-session-wayland-session.sha256sum] = "00d1e6695802d392471b0e4c621cf6e639caee7dcfed901cdc6ec515851602a8"

URI_aarch64_gnome-session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-session-46.0-11.el10.aarch64.rpm;name=aarch64_gnome-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-session}"
SRC_URI[aarch64_gnome-session.sha256sum] = "0280c97c984738ec419fb1f2e55522198ad56252daece6a64c98fc226bb69f33"

URI_aarch64_gnome-session-wayland-session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-session-wayland-session-46.0-11.el10.aarch64.rpm;name=aarch64_gnome-session-wayland-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-session-wayland-session}"
SRC_URI[aarch64_gnome-session-wayland-session.sha256sum] = "bedb0de21518d5c50f3aea313a52cca1401be10839969e150278bc1dca33cb92"

RDEPENDS:gnome-session = " \
 almalinux-logos \
 bash \
 dbus \
 dconf \
 glib2 \
 glibc \
 gnome-control-center-filesystem \
 gnome-desktop3 \
 gsettings-desktop-schemas \
 gtk3 \
 json-glib \
 libICE \
 libSM \
 libX11 \
 libXcomposite \
 libepoxy \
 libgcc \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 systemd-libs \
 "
RDEPENDS:gnome-session-wayland-session = " \
 gnome-session \
 gnome-shell \
 xorg-x11-server-Xwayland \
 "
