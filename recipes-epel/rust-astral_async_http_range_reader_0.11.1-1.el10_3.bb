# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral_async_http_range_reader"
PV = "0.11.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-astral_async_http_range_reader+default-devel \
 rust-astral_async_http_range_reader-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-astral_async_http_range_reader-0.11.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0cfc59dc2a3f532efa1b039e50216e4e13582d09fdf6ac04ab92a5d52adf04fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_http_range_reader+default-devel-0.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_http_range_reader+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-astral_async_http_range_reader+default-devel.sha256sum] = "b910bdf95fb10aa67c56788a9399977a44c85c82d822c4580268ace472285596"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_http_range_reader-devel-0.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_http_range_reader-devel;unpack=0"
SRC_URI[x86_64_v2_rust-astral_async_http_range_reader-devel.sha256sum] = "35a309f9601e82073a1afcfb5bdda84951d3641fe8fdbd700b4c76fbec0a5c30"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_http_range_reader+default-devel-0.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_http_range_reader+default-devel;unpack=0"
SRC_URI[aarch64_rust-astral_async_http_range_reader+default-devel.sha256sum] = "75a7dc9bbd76d555b8ea622a6ad63ddb0cbca5910678c30480a7c0d6460eb36c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_http_range_reader-devel-0.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_http_range_reader-devel;unpack=0"
SRC_URI[aarch64_rust-astral_async_http_range_reader-devel.sha256sum] = "f0c1c3d2441b1408a080db9c97732eb70fb216814842ab0380dab6f4e8fbacb2"

RDEPENDS:rust-astral_async_http_range_reader+default-devel = " \
 cargo \
 rust-astral_async_http_range_reader-devel \
 "
RDEPENDS:rust-astral_async_http_range_reader-devel = " \
 cargo \
 rust \
 rust-astral-reqwest-middleware+default-devel \
 rust-futures+default-devel \
 rust-http-content-range+default-devel \
 rust-itertools0.14+default-devel \
 rust-memmap2+default-devel \
 rust-reqwest+stream-devel \
 rust-reqwest-devel \
 rust-thiserror+default-devel \
 rust-tokio-devel \
 rust-tokio-stream+default-devel \
 rust-tokio-stream+sync-devel \
 rust-tokio-util+default-devel \
 rust-tracing+default-devel \
 "
