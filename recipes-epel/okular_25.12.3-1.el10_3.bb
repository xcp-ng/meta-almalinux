# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "okular"
PV = "25.12.3"
PR = "1.el10_3"
PACKAGES = " \
 okular \
 okular-devel \
 okular-libs \
 okular-mobile \
 okular-part \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/okular-25.12.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfe5f777be46b95562d731c825094e37cbd8bd175f46204bcd418bd55e8c8cb2"

URI_x86_64_v2_okular = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-25.12.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular}"
SRC_URI[x86_64_v2_okular.sha256sum] = "438bb2b42df30b1268001598d1e41d2a0ed82bc9ecbd94e5de4dd3564051f7a5"

URI_x86_64_v2_okular-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-devel-25.12.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-devel}"
SRC_URI[x86_64_v2_okular-devel.sha256sum] = "bf3cb38e52dce0d4c5cd115af36975312818586dc5f75e3572348e318fdd2472"

URI_x86_64_v2_okular-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-libs-25.12.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-libs}"
SRC_URI[x86_64_v2_okular-libs.sha256sum] = "ebeb00e795a6307e4cbb27f6ebe680babff26fbd2ada7faaa631c2e57f9609f5"

URI_x86_64_v2_okular-mobile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-mobile-25.12.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-mobile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-mobile}"
SRC_URI[x86_64_v2_okular-mobile.sha256sum] = "f0091697996d333dd3a01bf4b95bd08cc45f3185eccd4162265f69b652670417"

URI_x86_64_v2_okular-part = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-part-25.12.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-part;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-part}"
SRC_URI[x86_64_v2_okular-part.sha256sum] = "1160c2c45569f7d18aabcff7309baa824b2355ca26f33fb9eb9c4ec072a5700f"

URI_aarch64_okular = "${EPEL_MIRROR}/aarch64/Packages/o/okular-25.12.3-1.el10_3.aarch64.rpm;name=aarch64_okular;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular}"
SRC_URI[aarch64_okular.sha256sum] = "20f11d751e02c2e51fb63e52e9ccb510563dd0f894ac51241ae8a137ab389caa"

URI_aarch64_okular-devel = "${EPEL_MIRROR}/aarch64/Packages/o/okular-devel-25.12.3-1.el10_3.aarch64.rpm;name=aarch64_okular-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-devel}"
SRC_URI[aarch64_okular-devel.sha256sum] = "7c07d02d3a770c5a4d882f50673283b0a7af25def315487651b593d2365907fe"

URI_aarch64_okular-libs = "${EPEL_MIRROR}/aarch64/Packages/o/okular-libs-25.12.3-1.el10_3.aarch64.rpm;name=aarch64_okular-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-libs}"
SRC_URI[aarch64_okular-libs.sha256sum] = "fd5295bf30178adf1081b547dedc6847aa902365b589679a805183c6781aa5c3"

URI_aarch64_okular-mobile = "${EPEL_MIRROR}/aarch64/Packages/o/okular-mobile-25.12.3-1.el10_3.aarch64.rpm;name=aarch64_okular-mobile;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-mobile}"
SRC_URI[aarch64_okular-mobile.sha256sum] = "febbf75f185d4d07afd9ab098de7a2c994d0452c590c843d4ae130976b832ce7"

URI_aarch64_okular-part = "${EPEL_MIRROR}/aarch64/Packages/o/okular-part-25.12.3-1.el10_3.aarch64.rpm;name=aarch64_okular-part;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-part}"
SRC_URI[aarch64_okular-part.sha256sum] = "f1c5d712747eb7caf7a06d12bf5a0081a82e932c26dba382d33cb6f558b973ad"

RDEPENDS:okular = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-purpose \
 libstdc++ \
 okular-part \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:okular-devel = " \
 cmake-filesystem \
 okular-libs \
 "
RDEPENDS:okular-libs = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-threadweaver \
 libstdc++ \
 phonon-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 zlib-ng-compat \
 "
RDEPENDS:okular-mobile = " \
 glibc \
 kf6-kbookmarks \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 okular-libs \
 okular-part \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:okular-part = " \
 freetype \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 libkexiv2-qt6 \
 libmarkdown \
 libspectre \
 libstdc++ \
 libtiff \
 okular-libs \
 phonon-qt6 \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 "
