# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sweeper"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 sweeper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sweeper-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37bb73690366aae49c2b154a40c8ae8752cb46d1ed9890a56d2471b221aec64f"

URI_x86_64_v2_sweeper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sweeper-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sweeper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sweeper}"
SRC_URI[x86_64_v2_sweeper.sha256sum] = "e58a6aae2a0858838010440aeb4372ea3f7d29689401e86e41ef0fd10678aa21"

URI_aarch64_sweeper = "${EPEL_MIRROR}/aarch64/Packages/s/sweeper-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_sweeper;unpack=0"
SRC_URI:append = " ${URI_aarch64_sweeper}"
SRC_URI[aarch64_sweeper.sha256sum] = "d16e5cbe9008e262a93a699900e2beec02c73794846600e485e62dac49a55ada"

RDEPENDS:sweeper = " \
 glibc \
 kf6-kbookmarks \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 plasma-activities-stats \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
