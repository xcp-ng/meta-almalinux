# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-image-builder"
PV = "94"
PR = "1.el10"
PACKAGES = " \
 cockpit-image-builder \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-image-builder-94-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8f2ee8921d067557a4013026a992eeb83fe005dc0645930b82e3b2ca28ead74"

URI_x86_64_v2_cockpit-image-builder = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-image-builder-94-1.el10.noarch.rpm;name=x86_64_v2_cockpit-image-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-image-builder}"
SRC_URI[x86_64_v2_cockpit-image-builder.sha256sum] = "6220efaafa7b06043f3c55b6e983a4385be0b53c03d3fe9d7959f26e5d4926d6"

URI_aarch64_cockpit-image-builder = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-image-builder-94-1.el10.noarch.rpm;name=aarch64_cockpit-image-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-image-builder}"
SRC_URI[aarch64_cockpit-image-builder.sha256sum] = "6220efaafa7b06043f3c55b6e983a4385be0b53c03d3fe9d7959f26e5d4926d6"

RDEPENDS:cockpit-image-builder = " \
 cockpit \
 cockpit-files \
 osbuild-composer \
 "
