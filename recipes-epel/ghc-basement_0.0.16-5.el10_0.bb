# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-basement"
PV = "0.0.16"
PR = "5.el10_0"
PACKAGES = " \
 ghc-basement \
 ghc-basement-devel \
 ghc-basement-doc \
 ghc-basement-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-basement-0.0.16-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e1ff37c78b6269d50b2f5f2744e831b3d844a17a2420a016ff73d5e50c348e59"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-basement-0.0.16-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-basement;unpack=0"
SRC_URI[x86_64_v2_ghc-basement.sha256sum] = "5b18323ca71d602f3fbf602785f5d6dae54fa977d5b49cb81aa38c30a9b02552"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-basement-devel-0.0.16-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-basement-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-basement-devel.sha256sum] = "4b52345965a2a47e89b88ab7e74fd8aca1af8dfca5273fcc1f7a9e81820e2058"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-basement-doc-0.0.16-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-basement-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-basement-doc.sha256sum] = "2e6776404ffc903ea162d42011e47128af91db7e29562b5b2d545c41368d333a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-basement-prof-0.0.16-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-basement-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-basement-prof.sha256sum] = "ecb3406c0ee95ea90ed6ed69a7e436f7853baf35edf98a30acc6e7e9c1ca2bd7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-basement-0.0.16-5.el10_0.aarch64.rpm;name=aarch64_ghc-basement;unpack=0"
SRC_URI[aarch64_ghc-basement.sha256sum] = "24fef9e3ffa96ae1ef1964c9d7901a71ba83c3bc213196e5660da813676f7284"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-basement-devel-0.0.16-5.el10_0.aarch64.rpm;name=aarch64_ghc-basement-devel;unpack=0"
SRC_URI[aarch64_ghc-basement-devel.sha256sum] = "8d8e452ac9d77dbe6b89197a39cb1808738da2b8c11e6eaf715e06edda7360da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-basement-doc-0.0.16-5.el10_0.noarch.rpm;name=aarch64_ghc-basement-doc;unpack=0"
SRC_URI[aarch64_ghc-basement-doc.sha256sum] = "4543fdba40499d079b74330d642d0ffb665d5a0c4604824b34fc2ab1f562b689"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-basement-prof-0.0.16-5.el10_0.aarch64.rpm;name=aarch64_ghc-basement-prof;unpack=0"
SRC_URI[aarch64_ghc-basement-prof.sha256sum] = "fff460c55130393a2571e7ebd0ab92ad63dab95c3afa128d5c611c0bb70e7ec2"

RDEPENDS:ghc-basement = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-basement-devel = " \
 ghc-base-devel \
 ghc-basement \
 ghc-compiler \
 "
RDEPENDS:ghc-basement-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-basement-prof = " \
 ghc-base-prof \
 ghc-basement-devel \
 "
