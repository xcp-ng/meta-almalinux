# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-language"
PV = "0.1.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-language+default-devel \
 rust-tree-sitter-language-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-language-0.1.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c128a389f6ef0582884d9627570dba4ab3c1588e9df7911b0841ffcbac50bd3"

URI_x86_64_v2_rust-tree-sitter-language+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-language+default-devel-0.1.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-language+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-language+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-language+default-devel.sha256sum] = "f1428a96a31f8e17d776eb53c60ea68e9faed9086ac592a57ab4c705ab3510cc"

URI_x86_64_v2_rust-tree-sitter-language-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-language-devel-0.1.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-language-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-language-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-language-devel.sha256sum] = "6b081c21b149338fcae98a342c5f10f126394eb49317553d78b198596b230b7a"

URI_aarch64_rust-tree-sitter-language+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-language+default-devel-0.1.7-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-language+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-language+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-language+default-devel.sha256sum] = "f5006a9ddf5071bf8212739cbd099084c5e65b760342e245624feba4f7b207fe"

URI_aarch64_rust-tree-sitter-language-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-language-devel-0.1.7-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-language-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-language-devel}"
SRC_URI[aarch64_rust-tree-sitter-language-devel.sha256sum] = "a4bd63f05521f0bfdd084a5cef6129a48e0094c1f137dfb782b7eaa99b457d03"

RDEPENDS:rust-tree-sitter-language+default-devel = " \
 cargo \
 rust-tree-sitter-language-devel \
 "
RDEPENDS:rust-tree-sitter-language-devel = " \
 cargo \
 rust \
 "
