# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-CheckManifest"
PV = "1.43"
PR = "5.el10_0"
PACKAGES = " \
 perl-Test-CheckManifest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-CheckManifest-1.43-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bd2840b4d53c65d2952de7064a521db708446113cd9fdbd9f252145041d0979"

URI_x86_64_v2_perl-Test-CheckManifest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-CheckManifest-1.43-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-CheckManifest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-CheckManifest}"
SRC_URI[x86_64_v2_perl-Test-CheckManifest.sha256sum] = "e3fdce0a1a2cbc922c1624b8ad1a1fcd8e57d473bb9de21f89d51754ca2f205f"

URI_aarch64_perl-Test-CheckManifest = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-CheckManifest-1.43-5.el10_0.noarch.rpm;name=aarch64_perl-Test-CheckManifest;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-CheckManifest}"
SRC_URI[aarch64_perl-Test-CheckManifest.sha256sum] = "c6a07fbddd5fa8a96f021ab5cb0de60f536896e7acc5bad75fc003883ffe932b"

RDEPENDS:perl-Test-CheckManifest = " \
 perl-Carp \
 perl-File-Basename \
 perl-File-Find \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Test-Simple \
 perl-libs \
 "
