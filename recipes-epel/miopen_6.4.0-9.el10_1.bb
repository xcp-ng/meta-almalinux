# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "miopen"
PV = "6.4.0"
PR = "9.el10_1"
PACKAGES:x86_64_v2 = " \
 miopen \
 miopen-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/m/miopen-6.4.0-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7135221898f8c021bd5d9b7e0fea61bcaa52826a33c4384e5c78894981cbdc69"

URI_x86_64_v2_miopen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/miopen-6.4.0-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_miopen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_miopen}"
SRC_URI[x86_64_v2_miopen.sha256sum] = "1c7dce753a2fcfa0daf6c4fab10eceabb66614b9ebad69ecde8e8d65b694262f"

URI_x86_64_v2_miopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/miopen-devel-6.4.0-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_miopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_miopen-devel}"
SRC_URI[x86_64_v2_miopen-devel.sha256sum] = "59fe58e9abbfd97c1aa86d6178201e0517d5eef5a2eebd32eded8e271674fb51"

RDEPENDS:miopen = " \
 bash \
 boost-filesystem \
 bzip2-libs \
 glibc \
 libgcc \
 libstdc++ \
 rocblas \
 rocm-comgr \
 rocm-hip \
 rocm-hip-devel \
 rocrand-devel \
 roctracer \
 sqlite-libs \
 "
RDEPENDS:miopen-devel = " \
 cmake-filesystem \
 miopen \
 "
