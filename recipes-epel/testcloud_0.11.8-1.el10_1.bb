# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "testcloud"
PV = "0.11.8"
PR = "1.el10_1"
PACKAGES = " \
 python3-testcloud \
 testcloud \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/testcloud-0.11.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99514923ea24daaa6a90392150940dd5c8f26a0882991767ac6c85d153f3d14a"

URI_x86_64_v2_python3-testcloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-testcloud-0.11.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-testcloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-testcloud}"
SRC_URI[x86_64_v2_python3-testcloud.sha256sum] = "c8535d37e1195139dd8ca1134d514adf48d38dffa1096ca48a623ea098dd1beb"

URI_x86_64_v2_testcloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/testcloud-0.11.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_testcloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_testcloud}"
SRC_URI[x86_64_v2_testcloud.sha256sum] = "57bd0e9c433f35388e951323d3878edaa4fc9edf3f5624569804dd970b2da28a"

URI_aarch64_python3-testcloud = "${EPEL_MIRROR}/aarch64/Packages/p/python3-testcloud-0.11.8-1.el10_1.noarch.rpm;name=aarch64_python3-testcloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-testcloud}"
SRC_URI[aarch64_python3-testcloud.sha256sum] = "168ca2395b2fa7f6d4a2812215040e80603cb572e29f98f4abe4eb9f44e22770"

URI_aarch64_testcloud = "${EPEL_MIRROR}/aarch64/Packages/t/testcloud-0.11.8-1.el10_1.noarch.rpm;name=aarch64_testcloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_testcloud}"
SRC_URI[aarch64_testcloud.sha256sum] = "693e354fca00c93796084f14259bd6b58be951fc6a1e2e82e1cf2bae21bd48f2"

RDEPENDS:python3-testcloud = " \
 acl \
 genisoimage \
 libvirt-daemon \
 libvirt-daemon-config-network \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-storage-core \
 python3 \
 python3-libvirt \
 python3-packaging \
 python3-peewee \
 python3-requests \
 "
RDEPENDS:testcloud = " \
 bash \
 polkit \
 python3 \
 python3-testcloud \
 shadow-utils \
 "
