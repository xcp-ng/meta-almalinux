# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-build-context"
PV = "0.1.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-build-context+default-devel \
 rust-build-context-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-build-context-0.1.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93936efb11887c4bc0ea6498ad3bf8a6480ee9e665059f6cecd574518b1e02bd"

URI_x86_64_v2_rust-build-context+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-build-context+default-devel-0.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-build-context+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-build-context+default-devel}"
SRC_URI[x86_64_v2_rust-build-context+default-devel.sha256sum] = "79804e4632681515f0631a611d849ccc237b8a9fa8b9ac2abf78d3ee4eb40eaf"

URI_x86_64_v2_rust-build-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-build-context-devel-0.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-build-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-build-context-devel}"
SRC_URI[x86_64_v2_rust-build-context-devel.sha256sum] = "1945e63ca475c24ef45dbee24eb66f231e4b84fe039864a5eafec1bcb060149d"

URI_aarch64_rust-build-context+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-build-context+default-devel-0.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-build-context+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-build-context+default-devel}"
SRC_URI[aarch64_rust-build-context+default-devel.sha256sum] = "b69e7fd9c968388f0801a9035663fe1203263b8d44a3ad698aa304cc0bbe4583"

URI_aarch64_rust-build-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-build-context-devel-0.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-build-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-build-context-devel}"
SRC_URI[aarch64_rust-build-context-devel.sha256sum] = "a17a647937d663a48993ca5f61c5c716379c4ff3d2e3f3d077d5843ce4136b37"

RDEPENDS:rust-build-context+default-devel = " \
 cargo \
 rust-build-context-devel \
 "
RDEPENDS:rust-build-context-devel = " \
 cargo \
 rust \
 "
