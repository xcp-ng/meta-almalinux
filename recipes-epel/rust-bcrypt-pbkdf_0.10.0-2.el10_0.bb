# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bcrypt-pbkdf"
PV = "0.10.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-bcrypt-pbkdf+alloc-devel \
 rust-bcrypt-pbkdf+default-devel \
 rust-bcrypt-pbkdf+std-devel \
 rust-bcrypt-pbkdf+zeroize-devel \
 rust-bcrypt-pbkdf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bcrypt-pbkdf-0.10.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28e7d162de495d1d423bb61ece360c8dccd10ee4ac49af097972b590b7c3baf6"

URI_x86_64_v2_rust-bcrypt-pbkdf+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt-pbkdf+alloc-devel-0.10.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt-pbkdf+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt-pbkdf+alloc-devel}"
SRC_URI[x86_64_v2_rust-bcrypt-pbkdf+alloc-devel.sha256sum] = "2e1c8087208ea93d9cb23431887e612723b1b0c24cf558fa1f3e75992032a16b"

URI_x86_64_v2_rust-bcrypt-pbkdf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt-pbkdf+default-devel-0.10.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt-pbkdf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt-pbkdf+default-devel}"
SRC_URI[x86_64_v2_rust-bcrypt-pbkdf+default-devel.sha256sum] = "508761cab9c0689c00649db333e65f19b5add5f13ed76ffedf2da7329d9f01f1"

URI_x86_64_v2_rust-bcrypt-pbkdf+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt-pbkdf+std-devel-0.10.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt-pbkdf+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt-pbkdf+std-devel}"
SRC_URI[x86_64_v2_rust-bcrypt-pbkdf+std-devel.sha256sum] = "d863771cb947d7b1d13d25c1e2f9e0c1bbc130aecd37e15d97533e0e3355a0b8"

URI_x86_64_v2_rust-bcrypt-pbkdf+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt-pbkdf+zeroize-devel-0.10.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt-pbkdf+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt-pbkdf+zeroize-devel}"
SRC_URI[x86_64_v2_rust-bcrypt-pbkdf+zeroize-devel.sha256sum] = "8f22ce98d87394948701bc2c45eb5fa13e1822c6d93455af26a66270f6dc0ad3"

URI_x86_64_v2_rust-bcrypt-pbkdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt-pbkdf-devel-0.10.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt-pbkdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt-pbkdf-devel}"
SRC_URI[x86_64_v2_rust-bcrypt-pbkdf-devel.sha256sum] = "a5b809400599f1bb0dd260f56fec0c5a1e20e3d4b80d537be81d624c168d1f41"

URI_aarch64_rust-bcrypt-pbkdf+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt-pbkdf+alloc-devel-0.10.0-2.el10_0.noarch.rpm;name=aarch64_rust-bcrypt-pbkdf+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt-pbkdf+alloc-devel}"
SRC_URI[aarch64_rust-bcrypt-pbkdf+alloc-devel.sha256sum] = "a6107be07f7e2a7d859f9287395e83a214d694b8a49f829b8ede7ee47e3a0305"

URI_aarch64_rust-bcrypt-pbkdf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt-pbkdf+default-devel-0.10.0-2.el10_0.noarch.rpm;name=aarch64_rust-bcrypt-pbkdf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt-pbkdf+default-devel}"
SRC_URI[aarch64_rust-bcrypt-pbkdf+default-devel.sha256sum] = "f45bd40fccbb7af7090c46cc4664d15d8a33766a7015163473572ada7e4ee31e"

URI_aarch64_rust-bcrypt-pbkdf+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt-pbkdf+std-devel-0.10.0-2.el10_0.noarch.rpm;name=aarch64_rust-bcrypt-pbkdf+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt-pbkdf+std-devel}"
SRC_URI[aarch64_rust-bcrypt-pbkdf+std-devel.sha256sum] = "c97dbe5874e6f9f19bd6d20e580b834a4c30038cc90d80e69926d5080c36dd69"

URI_aarch64_rust-bcrypt-pbkdf+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt-pbkdf+zeroize-devel-0.10.0-2.el10_0.noarch.rpm;name=aarch64_rust-bcrypt-pbkdf+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt-pbkdf+zeroize-devel}"
SRC_URI[aarch64_rust-bcrypt-pbkdf+zeroize-devel.sha256sum] = "d9e68e29ae06d13182818ff57e6697b2a4320696b58940d7cf76575da09d7eca"

URI_aarch64_rust-bcrypt-pbkdf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt-pbkdf-devel-0.10.0-2.el10_0.noarch.rpm;name=aarch64_rust-bcrypt-pbkdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt-pbkdf-devel}"
SRC_URI[aarch64_rust-bcrypt-pbkdf-devel.sha256sum] = "c7ff9dec5169dfed29b594043fb8359072125d33c47bd24677928826521d592c"

RDEPENDS:rust-bcrypt-pbkdf+alloc-devel = " \
 cargo \
 rust-bcrypt-pbkdf-devel \
 "
RDEPENDS:rust-bcrypt-pbkdf+default-devel = " \
 cargo \
 rust-bcrypt-pbkdf+alloc-devel \
 rust-bcrypt-pbkdf+std-devel \
 rust-bcrypt-pbkdf-devel \
 "
RDEPENDS:rust-bcrypt-pbkdf+std-devel = " \
 cargo \
 rust-bcrypt-pbkdf-devel \
 "
RDEPENDS:rust-bcrypt-pbkdf+zeroize-devel = " \
 cargo \
 rust-bcrypt-pbkdf-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-bcrypt-pbkdf-devel = " \
 cargo \
 rust \
 rust-blowfish0.9+bcrypt-devel \
 rust-blowfish0.9+default-devel \
 rust-pbkdf2_0.12-devel \
 rust-sha2_0.10-devel \
 "
