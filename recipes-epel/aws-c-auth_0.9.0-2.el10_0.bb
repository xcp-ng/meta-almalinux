# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-auth"
PV = "0.9.0"
PR = "2.el10_0"
PACKAGES = " \
 aws-c-auth \
 aws-c-auth-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-auth-0.9.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1632b5f7879545b6caf99152b87e136b29f8b4d6c4049b6ea2fff1231dc33d6"

URI_x86_64_v2_aws-c-auth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-auth-0.9.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-auth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-auth}"
SRC_URI[x86_64_v2_aws-c-auth.sha256sum] = "b6d00ac197a108a421ae7983eea96d36905debafa698d5fab11b72c0d403ac8f"

URI_x86_64_v2_aws-c-auth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-auth-devel-0.9.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-auth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-auth-devel}"
SRC_URI[x86_64_v2_aws-c-auth-devel.sha256sum] = "063e3e0c778059d8bbac2d46e1de45c68b5a28f82ee242f2318bd7a06e6b2db2"

URI_aarch64_aws-c-auth = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-auth-0.9.0-2.el10_0.aarch64.rpm;name=aarch64_aws-c-auth;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-auth}"
SRC_URI[aarch64_aws-c-auth.sha256sum] = "c4525714b87450d2b4278de57a9143f4539b6421c45ed0f2d2f3a3522dc774cf"

URI_aarch64_aws-c-auth-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-auth-devel-0.9.0-2.el10_0.aarch64.rpm;name=aarch64_aws-c-auth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-auth-devel}"
SRC_URI[aarch64_aws-c-auth-devel.sha256sum] = "974b43a145fc1cbeca0e16796ea1fbe9edb4ede5dcf74e9e9cdc4e08c7ebfa0f"

RDEPENDS:aws-c-auth = " \
 aws-c-cal-libs \
 aws-c-common-libs \
 aws-c-http-libs \
 aws-c-io \
 aws-c-sdkutils-libs \
 glibc \
 "
RDEPENDS:aws-c-auth-devel = " \
 aws-c-auth \
 aws-c-cal-devel \
 aws-c-compression-devel \
 aws-c-http-devel \
 aws-c-io-devel \
 aws-c-sdkutils-devel \
 cmake-filesystem \
 openssl-devel \
 "
