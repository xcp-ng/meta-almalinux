# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-session"
PV = "46.0"
PR = "8.el10_0.alma.1"
PACKAGES = " \
 gnome-session \
 gnome-session-wayland-session \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-session-46.0-8.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23acc1106f021210537a05b685a041cda3c78549a798f94710c58ce70ee8b4a7"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - gnome-session-wayland-session: gnome-shell

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - gnome-session-wayland-session: gnome-shell

URI_x86_64_v2_gnome-session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-session-46.0-8.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_gnome-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-session}"
SRC_URI[x86_64_v2_gnome-session.sha256sum] = "e7fa09abcde4fc4b3c06a515b988d984e18761ac10e06ce79a9abf349ff05791"

URI_x86_64_v2_gnome-session-wayland-session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-session-wayland-session-46.0-8.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_gnome-session-wayland-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-session-wayland-session}"
SRC_URI[x86_64_v2_gnome-session-wayland-session.sha256sum] = "75a9b8eedfaef3aaa90afbcbae5d9e425041c6ef47d8d22e12fd316c8c91b5bf"

URI_aarch64_gnome-session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-session-46.0-8.el10_0.alma.1.aarch64.rpm;name=aarch64_gnome-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-session}"
SRC_URI[aarch64_gnome-session.sha256sum] = "ecbefa6eb72ab71a67e26b51ad36cab9453809f6333ccfa48f1f8dc3b1ae656d"

URI_aarch64_gnome-session-wayland-session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-session-wayland-session-46.0-8.el10_0.alma.1.aarch64.rpm;name=aarch64_gnome-session-wayland-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-session-wayland-session}"
SRC_URI[aarch64_gnome-session-wayland-session.sha256sum] = "939854401be5ddceb57c262e17f50bcab4cb92277fe7db11c7c5e903ec14aac5"

RDEPENDS:gnome-session = " \
 almalinux-logos \
 bash \
 dbus \
 dconf \
 glib2 \
 glibc \
 gnome-control-center-filesystem \
 gnome-desktop3 \
 gsettings-desktop-schemas \
 gtk3 \
 json-glib \
 libICE \
 libSM \
 libX11 \
 libXcomposite \
 libepoxy \
 libgcc \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 systemd-libs \
 "
RDEPENDS:gnome-session-wayland-session = " \
 gnome-session \
 xorg-x11-server-Xwayland \
 "
