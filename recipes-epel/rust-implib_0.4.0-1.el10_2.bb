# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-implib"
PV = "0.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-implib+default-devel \
 rust-implib+gnu-devel \
 rust-implib+msvc-devel \
 rust-implib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-implib-0.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4451d5569229d945b6e3c351041edcad14afd40ff4d737b37d9542abf12582e7"

URI_x86_64_v2_rust-implib+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-implib+default-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-implib+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-implib+default-devel}"
SRC_URI[x86_64_v2_rust-implib+default-devel.sha256sum] = "e7c62b8dd52401b16331dc39bf1e546677505db76d193e809deed9fafcd66a39"

URI_x86_64_v2_rust-implib+gnu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-implib+gnu-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-implib+gnu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-implib+gnu-devel}"
SRC_URI[x86_64_v2_rust-implib+gnu-devel.sha256sum] = "8773f5536b191fa186e8e05e4b4f94d89a2209317b07dd52ee19e7a6f6c6b0a3"

URI_x86_64_v2_rust-implib+msvc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-implib+msvc-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-implib+msvc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-implib+msvc-devel}"
SRC_URI[x86_64_v2_rust-implib+msvc-devel.sha256sum] = "a5ea97fddce70de3fdce62d9d8a80e33c60fa963007fd8704d580c21a33b794a"

URI_x86_64_v2_rust-implib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-implib-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-implib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-implib-devel}"
SRC_URI[x86_64_v2_rust-implib-devel.sha256sum] = "e7acac36926f87d5835a543d0f6ebcf9eb48b7d656974e631f6a7d0b29cfa27e"

URI_aarch64_rust-implib+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-implib+default-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-implib+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-implib+default-devel}"
SRC_URI[aarch64_rust-implib+default-devel.sha256sum] = "c0aeb16a33189492758814aa73efa2458fddb18b4704fe8acd891f63ba8848d7"

URI_aarch64_rust-implib+gnu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-implib+gnu-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-implib+gnu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-implib+gnu-devel}"
SRC_URI[aarch64_rust-implib+gnu-devel.sha256sum] = "c69dd76da70d640be01947d6134c5c20eeb3be85d07574b493c887be4b7a5945"

URI_aarch64_rust-implib+msvc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-implib+msvc-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-implib+msvc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-implib+msvc-devel}"
SRC_URI[aarch64_rust-implib+msvc-devel.sha256sum] = "f8b88f2cefab00af51c68d73b805c1a7768c9cd1a4434e0f7a4a46237a9a21a4"

URI_aarch64_rust-implib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-implib-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-implib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-implib-devel}"
SRC_URI[aarch64_rust-implib-devel.sha256sum] = "386b1613891de72f111c5d305fedae0186f12978ee7d02b85db416cfa7a1d349"

RDEPENDS:rust-implib+default-devel = " \
 cargo \
 rust-implib+gnu-devel \
 rust-implib+msvc-devel \
 rust-implib-devel \
 "
RDEPENDS:rust-implib+gnu-devel = " \
 cargo \
 rust-implib-devel \
 rust-object0.37+write_std-devel \
 "
RDEPENDS:rust-implib+msvc-devel = " \
 cargo \
 rust-implib-devel \
 "
RDEPENDS:rust-implib-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-object0.37+pe-devel \
 rust-object0.37-devel \
 "
