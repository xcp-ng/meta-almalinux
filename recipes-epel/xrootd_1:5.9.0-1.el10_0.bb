# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xrootd"
PE = "1"
PV = "5.9.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-xrootd \
 xrdcl-http \
 xrootd \
 xrootd-client \
 xrootd-client-devel \
 xrootd-client-libs \
 xrootd-devel \
 xrootd-doc \
 xrootd-fuse \
 xrootd-libs \
 xrootd-private-devel \
 xrootd-scitokens \
 xrootd-selinux \
 xrootd-server \
 xrootd-server-devel \
 xrootd-server-libs \
 xrootd-voms \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xrootd-5.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "365ce3b4e94d4525f9b2370c29aa2d6ca72883bfcd8e1bd443ca35ca3449d0cb"

URI_x86_64_v2_python3-xrootd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xrootd-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-xrootd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-xrootd}"
SRC_URI[x86_64_v2_python3-xrootd.sha256sum] = "2057f99e15222b9ac7105b43d8780737b37469b4bfac1a65be08b711d96fa23e"

URI_x86_64_v2_xrdcl-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrdcl-http-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrdcl-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrdcl-http}"
SRC_URI[x86_64_v2_xrdcl-http.sha256sum] = "3952eca9b1a387c58312c950f257d3ca1c5bbf2942c4005076210a389b7073c7"

URI_x86_64_v2_xrootd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd}"
SRC_URI[x86_64_v2_xrootd.sha256sum] = "cb02327f6a57f0f2db9e664dbf5077f5546f6bc3968aaf13d2a01c0975902aaf"

URI_x86_64_v2_xrootd-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-client-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-client}"
SRC_URI[x86_64_v2_xrootd-client.sha256sum] = "acb1a1301773219827d2cecd1589e255b7076bbd208019a8cdde23979da3f631"

URI_x86_64_v2_xrootd-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-client-devel-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-client-devel}"
SRC_URI[x86_64_v2_xrootd-client-devel.sha256sum] = "13037a18a207b08b52b8a901bbd7137116bd39dc7ce3191762a09717d3dfa409"

URI_x86_64_v2_xrootd-client-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-client-libs-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-client-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-client-libs}"
SRC_URI[x86_64_v2_xrootd-client-libs.sha256sum] = "0477067055cebd7bbddf99a7d6404847725d886325a771f28d7d33e908929f86"

URI_x86_64_v2_xrootd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-devel-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-devel}"
SRC_URI[x86_64_v2_xrootd-devel.sha256sum] = "0ab5c247fce01a4c2d14f133ce93166552abe1a7b10d6c57496953d0f6fb47c5"

URI_x86_64_v2_xrootd-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-doc-5.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_xrootd-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-doc}"
SRC_URI[x86_64_v2_xrootd-doc.sha256sum] = "ecfba61449f30605fc18e7543e8fffca4e41a2b6626657f8a5f26dda6d7e34e1"

URI_x86_64_v2_xrootd-fuse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-fuse-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-fuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-fuse}"
SRC_URI[x86_64_v2_xrootd-fuse.sha256sum] = "1227e281a9d48897cf7645e7bf965eb25157da4183d061f9d00af898a51359bf"

URI_x86_64_v2_xrootd-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-libs-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-libs}"
SRC_URI[x86_64_v2_xrootd-libs.sha256sum] = "fec3eeaea7d929da513250766bfd936597921aa06f1965aa4357310b5db14359"

URI_x86_64_v2_xrootd-private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-private-devel-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-private-devel}"
SRC_URI[x86_64_v2_xrootd-private-devel.sha256sum] = "098f8fb7c671287e5ebef0e893d81c766dd8aada90e806ecd0c70222b984f382"

URI_x86_64_v2_xrootd-scitokens = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-scitokens-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-scitokens;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-scitokens}"
SRC_URI[x86_64_v2_xrootd-scitokens.sha256sum] = "294b36794e31d804568bbcb428f562c6c94a21ada936b3f4b98f8119eb69f357"

URI_x86_64_v2_xrootd-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-selinux-5.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_xrootd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-selinux}"
SRC_URI[x86_64_v2_xrootd-selinux.sha256sum] = "e74a77ea3af04017e761f6d939f559c93ca634cf2e5f7d1ab8082b9d7fa1642f"

URI_x86_64_v2_xrootd-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-server-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-server}"
SRC_URI[x86_64_v2_xrootd-server.sha256sum] = "748bff40853f6f2edcee5bdb71a8da56c2ad10bb893414d7e9e5cc669ae45056"

URI_x86_64_v2_xrootd-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-server-devel-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-server-devel}"
SRC_URI[x86_64_v2_xrootd-server-devel.sha256sum] = "d99a1fdfe23b49e8ce16421411dff2f1ba968e624bb578dbba3ab2773b776d7b"

URI_x86_64_v2_xrootd-server-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-server-libs-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-server-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-server-libs}"
SRC_URI[x86_64_v2_xrootd-server-libs.sha256sum] = "b0d2fdc1f38d9dae8212ad409359ed590e4fa286279187fce94ec20053624a4f"

URI_x86_64_v2_xrootd-voms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-voms-5.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-voms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-voms}"
SRC_URI[x86_64_v2_xrootd-voms.sha256sum] = "cb92c96e7edfefaeba7f8b1087e3e3a17e6deff94fbd3908f554934bdc5bd34e"

URI_aarch64_python3-xrootd = "${EPEL_MIRROR}/aarch64/Packages/p/python3-xrootd-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_python3-xrootd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-xrootd}"
SRC_URI[aarch64_python3-xrootd.sha256sum] = "c18b445fe58a686bf11beae765734a22302ac920f0dff26f3499be755a91110e"

URI_aarch64_xrdcl-http = "${EPEL_MIRROR}/aarch64/Packages/x/xrdcl-http-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrdcl-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrdcl-http}"
SRC_URI[aarch64_xrdcl-http.sha256sum] = "6a76a70482c04b7e6881f11bfff3f9a0f471bb107ef7efa598e0f1ef54efc9ff"

URI_aarch64_xrootd = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrootd;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd}"
SRC_URI[aarch64_xrootd.sha256sum] = "18dacd742f27a8648fd55371171c0059ad98c563900df4410da83256323df69e"

URI_aarch64_xrootd-client = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-client-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrootd-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-client}"
SRC_URI[aarch64_xrootd-client.sha256sum] = "74a3d18e79c278359a3c3535c75b8b5cdac9a6de8e215d7a883a42a435278320"

URI_aarch64_xrootd-client-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-client-devel-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrootd-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-client-devel}"
SRC_URI[aarch64_xrootd-client-devel.sha256sum] = "e395cbf1daf9ada9a8254ba58fe204394a8746f53ace849f9ae41997a3d9e459"

URI_aarch64_xrootd-client-libs = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-client-libs-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrootd-client-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-client-libs}"
SRC_URI[aarch64_xrootd-client-libs.sha256sum] = "685b1631eb0653bf70fa1dfc9b67ce6b7e9fe38d09d2848e21bf41ee53648e5d"

URI_aarch64_xrootd-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-devel-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrootd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-devel}"
SRC_URI[aarch64_xrootd-devel.sha256sum] = "7e871a2976141272ba5ffd20c3cff7da142b4d493d968875e6d8c1b37ac03161"

URI_aarch64_xrootd-doc = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-doc-5.9.0-1.el10_0.noarch.rpm;name=aarch64_xrootd-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-doc}"
SRC_URI[aarch64_xrootd-doc.sha256sum] = "3973072e90945ff6cbc4b56a0d45ee10cbd7cf44ba78d8c16e915e75adf34f9a"

URI_aarch64_xrootd-fuse = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-fuse-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrootd-fuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-fuse}"
SRC_URI[aarch64_xrootd-fuse.sha256sum] = "c102139a74f0e102b253814a73d06d68e82c7b569955a556fc76cf1a14c54fd4"

URI_aarch64_xrootd-libs = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-libs-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrootd-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-libs}"
SRC_URI[aarch64_xrootd-libs.sha256sum] = "550fd1724ecc7fc2f121f0885b2b5861383e3d0b5b81c37bc70e6a3090cae28e"

URI_aarch64_xrootd-private-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-private-devel-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrootd-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-private-devel}"
SRC_URI[aarch64_xrootd-private-devel.sha256sum] = "e6661a3d7cd9a979d399e3f36911053123330955a0c0636a3f359ba5f00af457"

URI_aarch64_xrootd-scitokens = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-scitokens-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrootd-scitokens;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-scitokens}"
SRC_URI[aarch64_xrootd-scitokens.sha256sum] = "6161578b8a9ccb3cbc2442b39b98902698aabf81c1554badfc4b884673ff30cc"

URI_aarch64_xrootd-selinux = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-selinux-5.9.0-1.el10_0.noarch.rpm;name=aarch64_xrootd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-selinux}"
SRC_URI[aarch64_xrootd-selinux.sha256sum] = "12b56cd11ea159e960409e97951d490acc1fe6d61a993bd3abbe4eab3b25bcf5"

URI_aarch64_xrootd-server = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-server-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrootd-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-server}"
SRC_URI[aarch64_xrootd-server.sha256sum] = "cb8e23e3997b8f40289d475fc59a91a24ea2668040b371359d20d6b778323295"

URI_aarch64_xrootd-server-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-server-devel-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrootd-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-server-devel}"
SRC_URI[aarch64_xrootd-server-devel.sha256sum] = "9e10576459fd427b2f71d74a3f2afa97014b0995aa47ab732211b59d3456255e"

URI_aarch64_xrootd-server-libs = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-server-libs-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrootd-server-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-server-libs}"
SRC_URI[aarch64_xrootd-server-libs.sha256sum] = "df68670bd9b3b4a48d46c67d6cd86aa2884a15144e004b1ec39d46b7f0a4a61a"

URI_aarch64_xrootd-voms = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-voms-5.9.0-1.el10_0.aarch64.rpm;name=aarch64_xrootd-voms;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-voms}"
SRC_URI[aarch64_xrootd-voms.sha256sum] = "840f0b0b3af434cd9d033c1b0cc8513557fcef75557a49780e54f21acde67428"

RDEPENDS:python3-xrootd = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrdcl-http = " \
 davix-libs \
 glibc \
 libgcc \
 libstdc++ \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrootd = " \
 xrootd-selinux \
 xrootd-server \
 "
RDEPENDS:xrootd-client = " \
 glibc \
 libgcc \
 libstdc++ \
 readline \
 xrootd-client-libs \
 xrootd-libs \
 zlib-ng-compat \
 "
RDEPENDS:xrootd-client-devel = " \
 xrootd-client-libs \
 xrootd-devel \
 "
RDEPENDS:xrootd-client-libs = " \
 glibc \
 isa-l \
 libgcc \
 libstdc++ \
 libuuid \
 xrootd-libs \
 zlib-ng-compat \
 "
RDEPENDS:xrootd-devel = " \
 bash \
 cmake-filesystem \
 xrootd-libs \
 "
RDEPENDS:xrootd-doc = " \
 "
RDEPENDS:xrootd-fuse = " \
 fuse \
 fuse-libs \
 glibc \
 libgcc \
 libstdc++ \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrootd-libs = " \
 glibc \
 krb5-libs \
 libcom_err \
 libgcc \
 libstdc++ \
 libxcrypt \
 libxml2 \
 openssl-libs \
 systemd-libs \
 tinyxml \
 zlib-ng-compat \
 "
RDEPENDS:xrootd-private-devel = " \
 xrootd-client-devel \
 xrootd-client-libs \
 xrootd-devel \
 xrootd-server-devel \
 "
RDEPENDS:xrootd-scitokens = " \
 glibc \
 libgcc \
 libstdc++ \
 scitokens-cpp \
 xrootd-libs \
 xrootd-server \
 "
RDEPENDS:xrootd-selinux = " \
 bash \
 policycoreutils \
 selinux-policy \
 "
RDEPENDS:xrootd-server = " \
 bash \
 expect \
 glibc \
 libgcc \
 libstdc++ \
 logrotate \
 perl-Exporter \
 perl-IO \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Socket \
 perl-interpreter \
 readline \
 shadow-utils \
 systemd \
 xrootd-client-libs \
 xrootd-libs \
 xrootd-server-libs \
 "
RDEPENDS:xrootd-server-devel = " \
 xrootd-client-devel \
 xrootd-devel \
 xrootd-server-libs \
 "
RDEPENDS:xrootd-server-libs = " \
 glibc \
 json-c \
 libgcc \
 libmacaroons \
 libstdc++ \
 libuuid \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrootd-voms = " \
 glibc \
 libgcc \
 libstdc++ \
 voms \
 xrootd-libs \
 "
