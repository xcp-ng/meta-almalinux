# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssl"
PE = "1"
PV = "3.5.7"
PR = "2.el10.alma.1"
PACKAGES = " \
 openssl \
 openssl-devel \
 openssl-fips-provider \
 openssl-libs \
 openssl-perl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openssl-3.5.7-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04ed9fafa6b5b2f23ba70c5ae7063ebc291848aa54fce06cc78bc9a71674b2b4"

URI_x86_64_v2_openssl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-3.5.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl}"
SRC_URI[x86_64_v2_openssl.sha256sum] = "cf43ecfa39a3914fc36e4d1615fcce6a75bb54fc80a026be1408874bdd827b0f"

URI_x86_64_v2_openssl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssl-devel-3.5.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-devel}"
SRC_URI[x86_64_v2_openssl-devel.sha256sum] = "c4ca3a0fe0fdfb0bdefd1d602d1d778f952e6c64ce00de79fc075114a84358e0"

URI_x86_64_v2_openssl-fips-provider = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-fips-provider-3.5.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-fips-provider;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-fips-provider}"
SRC_URI[x86_64_v2_openssl-fips-provider.sha256sum] = "a43fe6e002b030d3972548a8dd3d62b798a21f34d3643cee08ed07ebe676c84d"

URI_x86_64_v2_openssl-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-libs-3.5.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-libs}"
SRC_URI[x86_64_v2_openssl-libs.sha256sum] = "875ef5171748afb14167a89d8989a232f5ff86234c55bb38b218d838054d88e6"

URI_x86_64_v2_openssl-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssl-perl-3.5.7-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-perl}"
SRC_URI[x86_64_v2_openssl-perl.sha256sum] = "c24137ecb36d0a64c4b0cffa61d30c97d70811bf858bd11b4279a49717d73e5d"

URI_aarch64_openssl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-3.5.7-2.el10.alma.1.aarch64.rpm;name=aarch64_openssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl}"
SRC_URI[aarch64_openssl.sha256sum] = "40cc6299740b724280a3447f911723c4f97cdc7fdbd12e2122e5579997919eea"

URI_aarch64_openssl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssl-devel-3.5.7-2.el10.alma.1.aarch64.rpm;name=aarch64_openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-devel}"
SRC_URI[aarch64_openssl-devel.sha256sum] = "bba21ff68c1bfddb9ad20ea28b6e86483643796078021e198985a1eca6b8d2d8"

URI_aarch64_openssl-fips-provider = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-fips-provider-3.5.7-2.el10.alma.1.aarch64.rpm;name=aarch64_openssl-fips-provider;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-fips-provider}"
SRC_URI[aarch64_openssl-fips-provider.sha256sum] = "7ebe92d9e9e58a4222798b1cbc7bb0d9573dff55cda0cba0a9f03dd5b4f1f575"

URI_aarch64_openssl-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-libs-3.5.7-2.el10.alma.1.aarch64.rpm;name=aarch64_openssl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-libs}"
SRC_URI[aarch64_openssl-libs.sha256sum] = "e16fa3f9efd18e64422d182f04b8f05efd3b0cef377280865793e825dc17d604"

URI_aarch64_openssl-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssl-perl-3.5.7-2.el10.alma.1.aarch64.rpm;name=aarch64_openssl-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-perl}"
SRC_URI[aarch64_openssl-perl.sha256sum] = "25bc1d387d26ccfb9bab3e0d2cc0f36a011d41b1f2f988df1c8baee23333bbf1"

RDEPENDS:openssl = " \
 bash \
 glibc \
 openssl-libs \
 virtual/coreutils \
 "
RDEPENDS:openssl-devel = " \
 openssl-devel \
 openssl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openssl-fips-provider = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:openssl-libs = " \
 ca-certificates \
 crypto-policies \
 glibc \
 openssl-fips-provider \
 zlib-ng-compat \
 "
RDEPENDS:openssl-perl = " \
 openssl \
 perl-interpreter \
 "
