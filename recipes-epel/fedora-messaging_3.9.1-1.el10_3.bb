# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-messaging"
PV = "3.9.1"
PR = "1.el10_3"
PACKAGES = " \
 fedora-messaging \
 python3-fedora-messaging \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-messaging-3.9.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53071c49e403dc261c18c2b2663c6f7d9aa31bbe0fc7e83e54ec2c3d3858607b"

URI_x86_64_v2_fedora-messaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-messaging-3.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-messaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-messaging}"
SRC_URI[x86_64_v2_fedora-messaging.sha256sum] = "e405ee087540568018a01e5681a2f2463c7ee8e41bbbf5d6a805ad4d13ac7a43"

URI_x86_64_v2_python3-fedora-messaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fedora-messaging-3.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fedora-messaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fedora-messaging}"
SRC_URI[x86_64_v2_python3-fedora-messaging.sha256sum] = "beb562ae78f990c5939bd65583d4851d61645c7af1d1eb5719fcf8fa59c8bb67"

URI_aarch64_fedora-messaging = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-messaging-3.9.1-1.el10_3.noarch.rpm;name=aarch64_fedora-messaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-messaging}"
SRC_URI[aarch64_fedora-messaging.sha256sum] = "4872a3ec76fdf771f8f21993fe0c3bd60d1f6a997a029b0f5da60f54640fed3e"

URI_aarch64_python3-fedora-messaging = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fedora-messaging-3.9.1-1.el10_3.noarch.rpm;name=aarch64_python3-fedora-messaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fedora-messaging}"
SRC_URI[aarch64_python3-fedora-messaging.sha256sum] = "91858eb79d866789b9d231b7b32034c9115b17d9d0be1a93d18427df1cf8e67b"

RDEPENDS:fedora-messaging = " \
 python3 \
 python3-fedora-messaging \
 "
RDEPENDS:python3-fedora-messaging = " \
 python3 \
 python3-blinker \
 python3-click \
 python3-crochet \
 python3-jsonschema \
 python3-pika \
 python3-pyOpenSSL \
 python3-requests \
 python3-service-identity \
 python3-tomli \
 python3-twisted \
 "
