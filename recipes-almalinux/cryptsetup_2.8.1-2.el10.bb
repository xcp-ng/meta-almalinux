# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cryptsetup"
PV = "2.8.1"
PR = "2.el10"
PACKAGES = " \
 cryptsetup \
 cryptsetup-devel \
 cryptsetup-libs \
 integritysetup \
 veritysetup \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cryptsetup-2.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a1939af4327e9c416c7d59ebec80077e6e8955774678191eaaf105d56cfb8a6"

URI_x86_64_v2_cryptsetup = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cryptsetup-2.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_cryptsetup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptsetup}"
SRC_URI[x86_64_v2_cryptsetup.sha256sum] = "bd7ad14b36a9f5d2cb15569c41c68406b53cfe5398b010a4303b3a5424498813"

URI_x86_64_v2_cryptsetup-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cryptsetup-devel-2.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_cryptsetup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptsetup-devel}"
SRC_URI[x86_64_v2_cryptsetup-devel.sha256sum] = "ea9a5b1ed33ef1843943703e25c35848cac9ff2263d56a58daea07c7eeae6de0"

URI_x86_64_v2_cryptsetup-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cryptsetup-libs-2.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_cryptsetup-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptsetup-libs}"
SRC_URI[x86_64_v2_cryptsetup-libs.sha256sum] = "56237e75492a06c477f8d94dc2d52b5e227c57544c1f06127eb399d8388e899c"

URI_x86_64_v2_integritysetup = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/integritysetup-2.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_integritysetup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_integritysetup}"
SRC_URI[x86_64_v2_integritysetup.sha256sum] = "a9e195172f5c77e8874cc22a7eb367737fb9228b56667c53013076b038d132af"

URI_x86_64_v2_veritysetup = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/veritysetup-2.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_veritysetup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_veritysetup}"
SRC_URI[x86_64_v2_veritysetup.sha256sum] = "479ae12f643cc11b217c98c166c2fe20742c264f52acbe79faf70b28140a0bee"

URI_aarch64_cryptsetup = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cryptsetup-2.8.1-2.el10.aarch64.rpm;name=aarch64_cryptsetup;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptsetup}"
SRC_URI[aarch64_cryptsetup.sha256sum] = "eed5c2a871cd9a307c2af1a4e0b195e0988ee6dde252b177c9fee439f475c008"

URI_aarch64_cryptsetup-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cryptsetup-devel-2.8.1-2.el10.aarch64.rpm;name=aarch64_cryptsetup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptsetup-devel}"
SRC_URI[aarch64_cryptsetup-devel.sha256sum] = "14cfcf2343618f43f6bacda1c80b9a82e65a2222e250d96600cd857b6003054e"

URI_aarch64_cryptsetup-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cryptsetup-libs-2.8.1-2.el10.aarch64.rpm;name=aarch64_cryptsetup-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptsetup-libs}"
SRC_URI[aarch64_cryptsetup-libs.sha256sum] = "3dc8f0b1738fed51c4d14c3145bb4ed81cdfded4bb46c573f9536d5b75b9811e"

URI_aarch64_integritysetup = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/integritysetup-2.8.1-2.el10.aarch64.rpm;name=aarch64_integritysetup;unpack=0"
SRC_URI:append = " ${URI_aarch64_integritysetup}"
SRC_URI[aarch64_integritysetup.sha256sum] = "d759cd2586d24eb8513baf69f40ce12ba8abace4a4e7f22a1c9553f8ddbce235"

URI_aarch64_veritysetup = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/veritysetup-2.8.1-2.el10.aarch64.rpm;name=aarch64_veritysetup;unpack=0"
SRC_URI:append = " ${URI_aarch64_veritysetup}"
SRC_URI[aarch64_veritysetup.sha256sum] = "27e4d56e5c815ec10b5a8c3deb8c63b666cc62908028d5104966d16224291ee9"

RDEPENDS:cryptsetup = " \
 cryptsetup-libs \
 glibc \
 libblkid \
 libpwquality \
 libuuid \
 popt \
 "
RDEPENDS:cryptsetup-devel = " \
 cryptsetup-libs \
 device-mapper-devel \
 json-c-devel \
 libblkid-devel \
 libuuid-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:cryptsetup-libs = " \
 device-mapper-libs \
 glibc \
 json-c \
 libblkid \
 libuuid \
 openssl-libs \
 "
RDEPENDS:integritysetup = " \
 cryptsetup-libs \
 glibc \
 libblkid \
 libuuid \
 popt \
 "
RDEPENDS:veritysetup = " \
 cryptsetup-libs \
 glibc \
 popt \
 "
