# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "picmi"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 picmi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/picmi-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ab3b5c098fbdb07189e2bb313fb69491e4b03a9725bd32be5ec496e61d02cd3"

URI_x86_64_v2_picmi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/picmi-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_picmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_picmi}"
SRC_URI[x86_64_v2_picmi.sha256sum] = "a5a0e9824303b1369d1650325d09e033cf1218a02b4dab086b6ecb56862c494e"

URI_aarch64_picmi = "${EPEL_MIRROR}/aarch64/Packages/p/picmi-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_picmi;unpack=0"
SRC_URI:append = " ${URI_aarch64_picmi}"
SRC_URI[aarch64_picmi.sha256sum] = "8ed459f826a6104774f9e8ea496689e67aa05f22475b2b5eea2bdfe03aed8800"

RDEPENDS:picmi = " \
 glibc \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
