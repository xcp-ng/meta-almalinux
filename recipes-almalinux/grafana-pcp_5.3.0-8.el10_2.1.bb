# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grafana-pcp"
PV = "5.3.0"
PR = "8.el10_2.1"
PACKAGES = " \
 grafana-pcp \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/grafana-pcp-5.3.0-8.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "87aec02d4d4ea836f93a42cddc3911ee05e7bfc7ac9fafc34e7bcb32685482f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-pcp-5.3.0-8.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_grafana-pcp;unpack=0"
SRC_URI[x86_64_v2_grafana-pcp.sha256sum] = "631909a235b66efb2f5ba57d98a6d9a5c55b5c2b5215072d750273ecf885ead5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-pcp-5.3.0-8.el10_2.1.aarch64.rpm;name=aarch64_grafana-pcp;unpack=0"
SRC_URI[aarch64_grafana-pcp.sha256sum] = "e0ab7c490c4806c3a937ffa5553df06e809921816ca8972325393458b356ae78"

RDEPENDS:grafana-pcp = " \
 bash \
 glibc \
 grafana \
 systemd \
 "
