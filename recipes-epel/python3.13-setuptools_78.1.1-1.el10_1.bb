# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.13-setuptools"
PV = "78.1.1"
PR = "1.el10_1"
PACKAGES = " \
 python3.13-setuptools \
 python3.13-setuptools-wheel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3.13-setuptools-78.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3554803d254acdd2fa5b390925229587fa047ae20747d307db09ce8a6b6f970a"

URI_x86_64_v2_python3.13-setuptools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-setuptools-78.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3.13-setuptools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-setuptools}"
SRC_URI[x86_64_v2_python3.13-setuptools.sha256sum] = "8e88609e0bb98c9a48f28ad291f02055a7d0a4f7c4ea8cf0fd0ef3f21d966e39"

URI_x86_64_v2_python3.13-setuptools-wheel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-setuptools-wheel-78.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3.13-setuptools-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-setuptools-wheel}"
SRC_URI[x86_64_v2_python3.13-setuptools-wheel.sha256sum] = "cb9f1a1d42ecf53622f3efb7a9eda490dcdad09ee022b1a74075175bdf7a98f9"

URI_aarch64_python3.13-setuptools = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-setuptools-78.1.1-1.el10_1.noarch.rpm;name=aarch64_python3.13-setuptools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-setuptools}"
SRC_URI[aarch64_python3.13-setuptools.sha256sum] = "15adb2a3933afe2a189f4206b0851ae5dbc0f1e22748413080911740e3c0456d"

URI_aarch64_python3.13-setuptools-wheel = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-setuptools-wheel-78.1.1-1.el10_1.noarch.rpm;name=aarch64_python3.13-setuptools-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-setuptools-wheel}"
SRC_URI[aarch64_python3.13-setuptools-wheel.sha256sum] = "f7b836a70baf5904c07056d268bf33aeeb2371e92df3b24f827f4cfee2cb8028"

RDEPENDS:python3.13-setuptools = " \
 python3.13 \
 "
RDEPENDS:python3.13-setuptools-wheel = " \
 "
