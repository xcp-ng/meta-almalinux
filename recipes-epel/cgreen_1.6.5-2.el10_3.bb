# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cgreen"
PV = "1.6.5"
PR = "2.el10_3"
PACKAGES = " \
 cgreen \
 cgreen-devel \
 cgreen-runner \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cgreen-1.6.5-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ca516a1de9cfc33c5131d1ed87058aed00f59cff96a331018b9db1c769a67445"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgreen-1.6.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgreen;unpack=0"
SRC_URI[x86_64_v2_cgreen.sha256sum] = "515e009ea719e768f859a459f470a46fd4345bb239e7b833a6712433006e2947"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgreen-devel-1.6.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgreen-devel;unpack=0"
SRC_URI[x86_64_v2_cgreen-devel.sha256sum] = "74623fc9a4799cd2aee22bdd4f867a421d948eddd0194902531029acd6eee36d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgreen-runner-1.6.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgreen-runner;unpack=0"
SRC_URI[x86_64_v2_cgreen-runner.sha256sum] = "1feb3b49b7f138e588f671816f2c86b7559466c67cce1e75bb3f0d666897d9db"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cgreen-1.6.5-2.el10_3.aarch64.rpm;name=aarch64_cgreen;unpack=0"
SRC_URI[aarch64_cgreen.sha256sum] = "d9510c8cb08087ecd7355ba2a01b3c55ae2d958630589769df199157fd6593ee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cgreen-devel-1.6.5-2.el10_3.aarch64.rpm;name=aarch64_cgreen-devel;unpack=0"
SRC_URI[aarch64_cgreen-devel.sha256sum] = "9494d7e34ec52dcd4a05df416b5b5bc7fb6ffab663a8e7e12e279b561dd630f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cgreen-runner-1.6.5-2.el10_3.aarch64.rpm;name=aarch64_cgreen-runner;unpack=0"
SRC_URI[aarch64_cgreen-runner.sha256sum] = "3a8db4ce4bbf3511de0a0bfe9d77054b1623bf6841e46cccad1e60c4e5f68117"

RDEPENDS:cgreen = " \
 glibc \
 libxml2 \
 "
RDEPENDS:cgreen-devel = " \
 cgreen \
 cmake-filesystem \
 "
RDEPENDS:cgreen-runner = " \
 cgreen \
 glibc \
 "
