# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netcdf"
PV = "4.9.2"
PR = "7.el10_0"
PACKAGES = " \
 netcdf \
 netcdf-devel \
 netcdf-mpich \
 netcdf-mpich-devel \
 netcdf-mpich-static \
 netcdf-openmpi \
 netcdf-openmpi-devel \
 netcdf-openmpi-static \
 netcdf-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netcdf-4.9.2-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1164686822980fa7980451013eed5e52d2fcc749cde5ffce8c01aeb5a68b1829"

URI_x86_64_v2_netcdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-4.9.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf}"
SRC_URI[x86_64_v2_netcdf.sha256sum] = "e6381701bda4517b14bfff250e2c57ce6175b572bef79290cfd5ccb3c66de3f7"

URI_x86_64_v2_netcdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-devel-4.9.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-devel}"
SRC_URI[x86_64_v2_netcdf-devel.sha256sum] = "c240f1206ce0d51bae494a9dd3ef8c1a86e8fdc6d812340d3c36d42a7922c19d"

URI_x86_64_v2_netcdf-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-mpich-4.9.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-mpich}"
SRC_URI[x86_64_v2_netcdf-mpich.sha256sum] = "3a997e9fb6e3fd4c72c97a83f06f708d465994b7b4a55b5dce30c2ee24d6de5c"

URI_x86_64_v2_netcdf-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-mpich-devel-4.9.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-mpich-devel}"
SRC_URI[x86_64_v2_netcdf-mpich-devel.sha256sum] = "fe87e33e5610c48c1ea5437bd35366b746d4dc31ffd1f8b1093b472e8c007461"

URI_x86_64_v2_netcdf-mpich-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-mpich-static-4.9.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-mpich-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-mpich-static}"
SRC_URI[x86_64_v2_netcdf-mpich-static.sha256sum] = "16aa5fa027bd4d5093aeb53a27f8208a842d612bc69e52a5ae1ea26ffe7e063a"

URI_x86_64_v2_netcdf-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-openmpi-4.9.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-openmpi}"
SRC_URI[x86_64_v2_netcdf-openmpi.sha256sum] = "089c1427ae0d7b1779533ae2d0f17adfb61a65b4a831f2e4a394ed76181dcf49"

URI_x86_64_v2_netcdf-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-openmpi-devel-4.9.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-openmpi-devel}"
SRC_URI[x86_64_v2_netcdf-openmpi-devel.sha256sum] = "87e520cbd5bf28096c7be8fb4b48a7b3131bbebd6502d34688a6dbcbbcab1e48"

URI_x86_64_v2_netcdf-openmpi-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-openmpi-static-4.9.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-openmpi-static}"
SRC_URI[x86_64_v2_netcdf-openmpi-static.sha256sum] = "f25ce78e06cd5a7c09b4714b49e3ef0f2dc98eb1146031efe9e02498ca9cc466"

URI_x86_64_v2_netcdf-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-static-4.9.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-static}"
SRC_URI[x86_64_v2_netcdf-static.sha256sum] = "f5900112d8541a3d34db9aa30e0456c511a8e0820380f66badf510264a22fa97"

URI_aarch64_netcdf = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-4.9.2-7.el10_0.aarch64.rpm;name=aarch64_netcdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf}"
SRC_URI[aarch64_netcdf.sha256sum] = "f5a569d56c7537e6f8757ca3018ab0c285acbffbb95900cc014eaf75e28d1368"

URI_aarch64_netcdf-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-devel-4.9.2-7.el10_0.aarch64.rpm;name=aarch64_netcdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-devel}"
SRC_URI[aarch64_netcdf-devel.sha256sum] = "6f3958ad088fe3de4328a0af21d6e0b6fc7bb25f566a51fe0556fbd907677f59"

URI_aarch64_netcdf-mpich = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-mpich-4.9.2-7.el10_0.aarch64.rpm;name=aarch64_netcdf-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-mpich}"
SRC_URI[aarch64_netcdf-mpich.sha256sum] = "2f4ab16d4bd3b0be7f38a79ccfac6bab6f99170e8a2771e2d5d0580e9bc1b5b3"

URI_aarch64_netcdf-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-mpich-devel-4.9.2-7.el10_0.aarch64.rpm;name=aarch64_netcdf-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-mpich-devel}"
SRC_URI[aarch64_netcdf-mpich-devel.sha256sum] = "6f07be295191b0e54611f0b544e42550f0a83c6ddf52657c45cc384cc102e587"

URI_aarch64_netcdf-mpich-static = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-mpich-static-4.9.2-7.el10_0.aarch64.rpm;name=aarch64_netcdf-mpich-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-mpich-static}"
SRC_URI[aarch64_netcdf-mpich-static.sha256sum] = "84e899199f1a8cdc1a3d66191b0b6154f1f1f85bdd22a1e7708c77f8a8452101"

URI_aarch64_netcdf-openmpi = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-openmpi-4.9.2-7.el10_0.aarch64.rpm;name=aarch64_netcdf-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-openmpi}"
SRC_URI[aarch64_netcdf-openmpi.sha256sum] = "cd835248ef315afe948538372c66636f58423705c0b14b89e62b50648667e3e1"

URI_aarch64_netcdf-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-openmpi-devel-4.9.2-7.el10_0.aarch64.rpm;name=aarch64_netcdf-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-openmpi-devel}"
SRC_URI[aarch64_netcdf-openmpi-devel.sha256sum] = "875801e04abb321a1279552a493f424ea4bd2f5f730b0b730a8f4b903ce72b7c"

URI_aarch64_netcdf-openmpi-static = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-openmpi-static-4.9.2-7.el10_0.aarch64.rpm;name=aarch64_netcdf-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-openmpi-static}"
SRC_URI[aarch64_netcdf-openmpi-static.sha256sum] = "37c9079f6f0d300cd0ac0423f842cd937f415bc118ee9f55db8472c79147e8d9"

URI_aarch64_netcdf-static = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-static-4.9.2-7.el10_0.aarch64.rpm;name=aarch64_netcdf-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-static}"
SRC_URI[aarch64_netcdf-static.sha256sum] = "2da25e40cd3ed5c78a81dc3d8f3e8b76d57d9f0d4446f9ac5099ad6b502f2037"

RDEPENDS:netcdf = " \
 blosc \
 bzip2-libs \
 glibc \
 hdf5 \
 libaec \
 libxml2 \
 libzip \
 libzstd \
 virtual/libcurl.so.4___64bit_ \
 virtual/libmfhdf.so.0___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:netcdf-devel = " \
 bash \
 hdf5-devel \
 libcurl-devel \
 netcdf \
 pkgconf-pkg-config \
 "
RDEPENDS:netcdf-mpich = " \
 blosc \
 bzip2-libs \
 glibc \
 hdf5-mpich \
 libaec \
 libjpeg-turbo \
 libtirpc \
 libxml2 \
 libzip \
 libzstd \
 mpich \
 virtual/libcurl.so.4___64bit_ \
 virtual/libdf.so.0___64bit_ \
 virtual/libmfhdf.so.0___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:netcdf-mpich-devel = " \
 bash \
 hdf5-mpich-devel \
 libcurl-devel \
 netcdf-mpich \
 pkgconf-pkg-config \
 "
RDEPENDS:netcdf-mpich-static = " \
 netcdf-mpich-devel \
 "
RDEPENDS:netcdf-openmpi = " \
 blosc \
 bzip2-libs \
 glibc \
 hdf5-openmpi \
 libaec \
 libjpeg-turbo \
 libtirpc \
 libxml2 \
 libzip \
 libzstd \
 openmpi \
 virtual/libcurl.so.4___64bit_ \
 virtual/libdf.so.0___64bit_ \
 virtual/libmfhdf.so.0___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:netcdf-openmpi-devel = " \
 bash \
 hdf5-openmpi-devel \
 libcurl-devel \
 netcdf-openmpi \
 openmpi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:netcdf-openmpi-static = " \
 netcdf-openmpi-devel \
 "
RDEPENDS:netcdf-static = " \
 netcdf \
 "
