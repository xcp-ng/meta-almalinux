# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-lxml"
PV = "5.2.1"
PR = "4.el10"
PACKAGES = " \
 python3-lxml \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-lxml-5.2.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50bba3421768fec5515cc18b0b9f5e59c3cd33d390c5b86ca66929da7620ff6e"

URI_x86_64_v2_python3-lxml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lxml-5.2.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_python3-lxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lxml}"
SRC_URI[x86_64_v2_python3-lxml.sha256sum] = "d64aec49ec691f79282dab9c19f7ff54eb70d83b9b321cb92b224832fabf0177"

URI_aarch64_python3-lxml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lxml-5.2.1-4.el10.aarch64.rpm;name=aarch64_python3-lxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lxml}"
SRC_URI[aarch64_python3-lxml.sha256sum] = "ae5eb964c1319cf0211ed61adf46d80d8c373981a31c62dd5eb7ddd9e0919497"

RDEPENDS:python3-lxml = " \
 glibc \
 libxml2 \
 libxslt \
 python3 \
 "
