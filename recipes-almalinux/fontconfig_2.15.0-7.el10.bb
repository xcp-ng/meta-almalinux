# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fontconfig"
PV = "2.15.0"
PR = "7.el10"
PACKAGES = " \
 fontconfig \
 fontconfig-devel \
 fontconfig-devel-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fontconfig-2.15.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a1946c95800505f2f63591a8cf468fdd2e6646b1179467185231afc313db229"

URI_x86_64_v2_fontconfig = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fontconfig-2.15.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_fontconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fontconfig}"
SRC_URI[x86_64_v2_fontconfig.sha256sum] = "fe6f01d0e4f7096a1aa4555c3ca13c0e61082b7b008b17f9c00b6cfa3407c45a"

URI_x86_64_v2_fontconfig-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fontconfig-devel-2.15.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_fontconfig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fontconfig-devel}"
SRC_URI[x86_64_v2_fontconfig-devel.sha256sum] = "19c24789768de0ff2ab8c7a958f17770193b486f7fdae6b136611f3bd2281c56"

URI_x86_64_v2_fontconfig-devel-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fontconfig-devel-doc-2.15.0-7.el10.noarch.rpm;name=x86_64_v2_fontconfig-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fontconfig-devel-doc}"
SRC_URI[x86_64_v2_fontconfig-devel-doc.sha256sum] = "530497c58b64913af4d1736dbce3d6ad7f31a0d6088a04721ba25edf15956e9e"

URI_aarch64_fontconfig = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fontconfig-2.15.0-7.el10.aarch64.rpm;name=aarch64_fontconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_fontconfig}"
SRC_URI[aarch64_fontconfig.sha256sum] = "5003431f136d7469839941320a62d3791d240bfb90ba78ac67daa34955201408"

URI_aarch64_fontconfig-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fontconfig-devel-2.15.0-7.el10.aarch64.rpm;name=aarch64_fontconfig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fontconfig-devel}"
SRC_URI[aarch64_fontconfig-devel.sha256sum] = "e94009b2eab31c42b8875490429b5b584fea56f1089a18da902567268edc0cc6"

URI_aarch64_fontconfig-devel-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fontconfig-devel-doc-2.15.0-7.el10.noarch.rpm;name=aarch64_fontconfig-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fontconfig-devel-doc}"
SRC_URI[aarch64_fontconfig-devel-doc.sha256sum] = "530497c58b64913af4d1736dbce3d6ad7f31a0d6088a04721ba25edf15956e9e"

RDEPENDS:fontconfig = " \
 bash \
 default-fonts-core-sans \
 fonts-filesystem \
 freetype \
 glibc \
 grep \
 libxml2 \
 virtual/coreutils \
 xml-common \
 "
RDEPENDS:fontconfig-devel = " \
 fontconfig \
 freetype-devel \
 gettext \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:fontconfig-devel-doc = " \
 fontconfig-devel \
 "
