# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet9.0"
PV = "9.0.118"
PR = "3.el10"
PACKAGES = " \
 aspnetcore-runtime-9.0 \
 aspnetcore-runtime-dbg-9.0 \
 aspnetcore-targeting-pack-9.0 \
 dotnet-apphost-pack-9.0 \
 dotnet-hostfxr-9.0 \
 dotnet-runtime-9.0 \
 dotnet-runtime-dbg-9.0 \
 dotnet-sdk-9.0 \
 dotnet-sdk-9.0-source-built-artifacts \
 dotnet-sdk-aot-9.0 \
 dotnet-sdk-dbg-9.0 \
 dotnet-targeting-pack-9.0 \
 dotnet-templates-9.0 \
 netstandard-targeting-pack-2.1 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet9.0-9.0.118-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edfa6163a2865507bb5bbe8a75004d3966ab2dd50f82a53dcbf58dbe96090b18"

URI_x86_64_v2_aspnetcore-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-9.0-9.0.17-3.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-9.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-9.0.sha256sum] = "c3776988cebfdc72578506348d9816ae14eceb5433a82c44b0a3ae733c291dee"

URI_x86_64_v2_aspnetcore-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-9.0-9.0.17-3.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-dbg-9.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-9.0.sha256sum] = "20f544ecb18fe20d96249b75f1f01309855f55eb72c68fcbb2e98f010f38ddfe"

URI_x86_64_v2_aspnetcore-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-9.0-9.0.17-3.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-targeting-pack-9.0}"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-9.0.sha256sum] = "ca7c4aa1681addd3d18e4b79256e222b85960af2cf6ba802f3c0eb97c869a4f3"

URI_x86_64_v2_dotnet-apphost-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-9.0-9.0.17-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-apphost-pack-9.0}"
SRC_URI[x86_64_v2_dotnet-apphost-pack-9.0.sha256sum] = "4bc8ca03c20b078a68cc123453d8d57721b7e87b349cf17f13d0bfe4ea6ca8d3"

URI_x86_64_v2_dotnet-hostfxr-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-9.0-9.0.17-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-hostfxr-9.0}"
SRC_URI[x86_64_v2_dotnet-hostfxr-9.0.sha256sum] = "585d88e60e957143d0acf61e43e0269ef90aafa8e8a8e322d391b49ac3c34a9f"

URI_x86_64_v2_dotnet-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-9.0-9.0.17-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-9.0}"
SRC_URI[x86_64_v2_dotnet-runtime-9.0.sha256sum] = "612bbfd2edc26bd730aef2bc5792bf16aa190b1a431c0f782af2838ae657aa9b"

URI_x86_64_v2_dotnet-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-9.0-9.0.17-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-dbg-9.0}"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-9.0.sha256sum] = "e7e1dd7a6273d1aeaafca3dfb359ea3c642572bda4452b5f6fc7ea726c0ea3d0"

URI_x86_64_v2_dotnet-sdk-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-9.0-9.0.118-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-9.0}"
SRC_URI[x86_64_v2_dotnet-sdk-9.0.sha256sum] = "be4dc6f4f059766c5d3acc7a0d58e673a92e9139652d30d8b1a1da347446f536"

URI_x86_64_v2_dotnet-sdk-9.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-9.0-source-built-artifacts-9.0.118-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-9.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-9.0-source-built-artifacts}"
SRC_URI[x86_64_v2_dotnet-sdk-9.0-source-built-artifacts.sha256sum] = "e58a39e322b475f2bfbf6b1fd7722a9e3961f9a53d4a9619cb9e8dd86de2dac7"

URI_x86_64_v2_dotnet-sdk-aot-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-aot-9.0-9.0.118-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-aot-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-aot-9.0}"
SRC_URI[x86_64_v2_dotnet-sdk-aot-9.0.sha256sum] = "977306a995c982fadfef09c00ad608ba50ca5a5e1ddbef6927446b1c5ab0ad1c"

URI_x86_64_v2_dotnet-sdk-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-9.0-9.0.118-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-dbg-9.0}"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-9.0.sha256sum] = "662ee90801a9ba232349f48ebf0b2bae7c5d07ece15292fb4f04e1fa28fed407"

URI_x86_64_v2_dotnet-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-9.0-9.0.17-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-targeting-pack-9.0}"
SRC_URI[x86_64_v2_dotnet-targeting-pack-9.0.sha256sum] = "6a3c705ba662f2dfd0222506f8c9590277a0be2e543a2f48d51413a96bb34622"

URI_x86_64_v2_dotnet-templates-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-9.0-9.0.118-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-templates-9.0}"
SRC_URI[x86_64_v2_dotnet-templates-9.0.sha256sum] = "cbe687cb4e72a68453ee76295bf5982c0d63c23b8dc8b3b4cb3d9a7605fe6d19"

URI_x86_64_v2_netstandard-targeting-pack-2.1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/netstandard-targeting-pack-2.1-9.0.118-3.el10.x86_64_v2.rpm;name=x86_64_v2_netstandard-targeting-pack-2.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netstandard-targeting-pack-2.1}"
SRC_URI[x86_64_v2_netstandard-targeting-pack-2.1.sha256sum] = "456ad80aa774c092ae2368a270d4d0c47a59cff017d22945ca0cca3a93b7bc46"

URI_aarch64_aspnetcore-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-9.0-9.0.17-3.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-9.0}"
SRC_URI[aarch64_aspnetcore-runtime-9.0.sha256sum] = "48ee39cb46b0eee9d7b30d740bf7d18511831e1fc8baff96689bb0fa4f956894"

URI_aarch64_aspnetcore-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-9.0-9.0.17-3.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-dbg-9.0}"
SRC_URI[aarch64_aspnetcore-runtime-dbg-9.0.sha256sum] = "7d654299b8e948c8c0559a6e8193066d8cbfa991a7dcf1861171d363a7e8c152"

URI_aarch64_aspnetcore-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-9.0-9.0.17-3.el10.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-targeting-pack-9.0}"
SRC_URI[aarch64_aspnetcore-targeting-pack-9.0.sha256sum] = "bcd197997b66a8e644dbe0e5aa5692c82c5aa5d7be36e52cedad9e7e023ca750"

URI_aarch64_dotnet-apphost-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-9.0-9.0.17-3.el10.aarch64.rpm;name=aarch64_dotnet-apphost-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-apphost-pack-9.0}"
SRC_URI[aarch64_dotnet-apphost-pack-9.0.sha256sum] = "d11335db26e00b8ced2b8c0968ecaa03ca4a601292281563fe905a73c0825469"

URI_aarch64_dotnet-hostfxr-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-9.0-9.0.17-3.el10.aarch64.rpm;name=aarch64_dotnet-hostfxr-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-hostfxr-9.0}"
SRC_URI[aarch64_dotnet-hostfxr-9.0.sha256sum] = "4b42571dc3d0f1d1a7f7baecbe5cce7685e60a95300075e24d8f8ec51ef355ee"

URI_aarch64_dotnet-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-9.0-9.0.17-3.el10.aarch64.rpm;name=aarch64_dotnet-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-9.0}"
SRC_URI[aarch64_dotnet-runtime-9.0.sha256sum] = "f253e52801383a1938342190360c30ad6b9e0faa7c3c1f4ca036eee2d0d1de91"

URI_aarch64_dotnet-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-9.0-9.0.17-3.el10.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-dbg-9.0}"
SRC_URI[aarch64_dotnet-runtime-dbg-9.0.sha256sum] = "68e4718753949fbeb5e8a9710ac287ec9f0bb39e9aa7e5dfd067a1ae71d04db7"

URI_aarch64_dotnet-sdk-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-9.0-9.0.118-3.el10.aarch64.rpm;name=aarch64_dotnet-sdk-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-9.0}"
SRC_URI[aarch64_dotnet-sdk-9.0.sha256sum] = "0d398502c505d0262b6522255eb6bddf27c6079ec7227ff2cf553b0aa2b39603"

URI_aarch64_dotnet-sdk-9.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-9.0-source-built-artifacts-9.0.118-3.el10.aarch64.rpm;name=aarch64_dotnet-sdk-9.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-9.0-source-built-artifacts}"
SRC_URI[aarch64_dotnet-sdk-9.0-source-built-artifacts.sha256sum] = "4488d2ddef426f30012f65ac90709ef874d25b6e887317481299f0c3a4878774"

URI_aarch64_dotnet-sdk-aot-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-aot-9.0-9.0.118-3.el10.aarch64.rpm;name=aarch64_dotnet-sdk-aot-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-aot-9.0}"
SRC_URI[aarch64_dotnet-sdk-aot-9.0.sha256sum] = "a5f8ea29ace02add2a4250fe2ef6ec923f1c72716d4f3ebea7f8486e3cd910c0"

URI_aarch64_dotnet-sdk-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-9.0-9.0.118-3.el10.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-dbg-9.0}"
SRC_URI[aarch64_dotnet-sdk-dbg-9.0.sha256sum] = "1c09403564aa1a87e8e719b4adc0ed8ae589d6120dca9a0595fd7151e0d4ca74"

URI_aarch64_dotnet-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-9.0-9.0.17-3.el10.aarch64.rpm;name=aarch64_dotnet-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-targeting-pack-9.0}"
SRC_URI[aarch64_dotnet-targeting-pack-9.0.sha256sum] = "ef614c814b7fe97d2332517cfe97c276e5bb66185571ad98ff4c8ef2a23000de"

URI_aarch64_dotnet-templates-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-9.0-9.0.118-3.el10.aarch64.rpm;name=aarch64_dotnet-templates-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-templates-9.0}"
SRC_URI[aarch64_dotnet-templates-9.0.sha256sum] = "a89b4af04697e506d014205bc8a49315b79c14f1c5a78014b8aee09528bd4531"

URI_aarch64_netstandard-targeting-pack-2.1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/netstandard-targeting-pack-2.1-9.0.118-3.el10.aarch64.rpm;name=aarch64_netstandard-targeting-pack-2.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_netstandard-targeting-pack-2.1}"
SRC_URI[aarch64_netstandard-targeting-pack-2.1.sha256sum] = "d8f51417075d387384c2c0a602f577981e7c5c49c2f3871208a7a2dc14693eb4"

RDEPENDS:aspnetcore-runtime-9.0 = " \
 dotnet-runtime-9.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-9.0 = " \
 aspnetcore-runtime-9.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-9.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-9.0 = " \
 dotnet-host \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-hostfxr-9.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-9.0 = " \
 dotnet-hostfxr-9.0 \
 glibc \
 libbrotli \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-9.0 = " \
 dotnet-runtime-9.0 \
 "
RDEPENDS:dotnet-sdk-9.0 = " \
 aspnetcore-runtime-9.0 \
 aspnetcore-targeting-pack-9.0 \
 dotnet-apphost-pack-9.0 \
 dotnet-runtime-9.0 \
 dotnet-targeting-pack-9.0 \
 dotnet-templates-9.0 \
 glibc \
 libgcc \
 libstdc++ \
 netstandard-targeting-pack-2.1 \
 "
RDEPENDS:dotnet-sdk-9.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-aot-9.0 = " \
 bash \
 brotli-devel \
 clang \
 dotnet-sdk-9.0 \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-devel \
 openssl-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:dotnet-sdk-dbg-9.0 = " \
 dotnet-sdk-9.0 \
 "
RDEPENDS:dotnet-targeting-pack-9.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-9.0 = " \
 dotnet-host \
 "
RDEPENDS:netstandard-targeting-pack-2.1 = " \
 dotnet-host \
 "
