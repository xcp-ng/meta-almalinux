# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tiny-bip39"
PV = "2.0.0"
PR = "4.el10_3"
PACKAGES = " \
 rust-tiny-bip39+chinese-simplified-devel \
 rust-tiny-bip39+chinese-traditional-devel \
 rust-tiny-bip39+default-devel \
 rust-tiny-bip39+default-langs-devel \
 rust-tiny-bip39+french-devel \
 rust-tiny-bip39+italian-devel \
 rust-tiny-bip39+japanese-devel \
 rust-tiny-bip39+korean-devel \
 rust-tiny-bip39+rand-devel \
 rust-tiny-bip39+spanish-devel \
 rust-tiny-bip39-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tiny-bip39-2.0.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dfbaf5f5bed770faeafc7f1638c16e90275cf82a6bf69af3ffbbe6d8fb67cc2"

URI_x86_64_v2_rust-tiny-bip39+chinese-simplified-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-bip39+chinese-simplified-devel-2.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-bip39+chinese-simplified-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-bip39+chinese-simplified-devel}"
SRC_URI[x86_64_v2_rust-tiny-bip39+chinese-simplified-devel.sha256sum] = "b1358fee498093b535f2595270e058874158946503b813e153001510dd093971"

URI_x86_64_v2_rust-tiny-bip39+chinese-traditional-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-bip39+chinese-traditional-devel-2.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-bip39+chinese-traditional-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-bip39+chinese-traditional-devel}"
SRC_URI[x86_64_v2_rust-tiny-bip39+chinese-traditional-devel.sha256sum] = "ac9b757101e5b5b6938ba3c930a54aa388f7853b6663c488d366db398f6ba72a"

URI_x86_64_v2_rust-tiny-bip39+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-bip39+default-devel-2.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-bip39+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-bip39+default-devel}"
SRC_URI[x86_64_v2_rust-tiny-bip39+default-devel.sha256sum] = "d006802651745f2449b6b5e17649360501f2652a5b631e6e84fe5d82bfcf83f4"

URI_x86_64_v2_rust-tiny-bip39+default-langs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-bip39+default-langs-devel-2.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-bip39+default-langs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-bip39+default-langs-devel}"
SRC_URI[x86_64_v2_rust-tiny-bip39+default-langs-devel.sha256sum] = "fcef0bcecf7aec4fba070a4a6c8d3048638b771ba545c33fd755af1cd5d21a89"

URI_x86_64_v2_rust-tiny-bip39+french-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-bip39+french-devel-2.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-bip39+french-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-bip39+french-devel}"
SRC_URI[x86_64_v2_rust-tiny-bip39+french-devel.sha256sum] = "31a62091b8c9f12ad944ba780a8d3c9f30df9bcc4f6e1a79e93dd1241289daa4"

URI_x86_64_v2_rust-tiny-bip39+italian-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-bip39+italian-devel-2.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-bip39+italian-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-bip39+italian-devel}"
SRC_URI[x86_64_v2_rust-tiny-bip39+italian-devel.sha256sum] = "144d1374ae8b8292c822f81982822cff9445ff88bf13a9d7c09611490cf9b9c0"

URI_x86_64_v2_rust-tiny-bip39+japanese-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-bip39+japanese-devel-2.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-bip39+japanese-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-bip39+japanese-devel}"
SRC_URI[x86_64_v2_rust-tiny-bip39+japanese-devel.sha256sum] = "9c5d26cb45c2ff8eba0e320afe74e849e2983a63542b38f02034e7c77098e920"

URI_x86_64_v2_rust-tiny-bip39+korean-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-bip39+korean-devel-2.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-bip39+korean-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-bip39+korean-devel}"
SRC_URI[x86_64_v2_rust-tiny-bip39+korean-devel.sha256sum] = "1b2f70ca76ded70f48fc55ef7fc7595b7ea954af22efabac4d9e85253155159d"

URI_x86_64_v2_rust-tiny-bip39+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-bip39+rand-devel-2.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-bip39+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-bip39+rand-devel}"
SRC_URI[x86_64_v2_rust-tiny-bip39+rand-devel.sha256sum] = "be143696f1ae1169737b6f7538465e32b6bd532c8245cfc44b06604667d3f352"

URI_x86_64_v2_rust-tiny-bip39+spanish-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-bip39+spanish-devel-2.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-bip39+spanish-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-bip39+spanish-devel}"
SRC_URI[x86_64_v2_rust-tiny-bip39+spanish-devel.sha256sum] = "a591fc5c8d1bcd8b1e35d9fd7a01f53fa64c67c471a11232a5fe8c234e09771e"

URI_x86_64_v2_rust-tiny-bip39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-bip39-devel-2.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-bip39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-bip39-devel}"
SRC_URI[x86_64_v2_rust-tiny-bip39-devel.sha256sum] = "24b02db5d4fd05e9a4af72dab995e08b3d806389f1963d602a8856ca078207a4"

URI_aarch64_rust-tiny-bip39+chinese-simplified-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-bip39+chinese-simplified-devel-2.0.0-4.el10_3.noarch.rpm;name=aarch64_rust-tiny-bip39+chinese-simplified-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-bip39+chinese-simplified-devel}"
SRC_URI[aarch64_rust-tiny-bip39+chinese-simplified-devel.sha256sum] = "81e1caab50d5f430aa79bba893382730c31031dc2c382ff355592e363a994588"

URI_aarch64_rust-tiny-bip39+chinese-traditional-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-bip39+chinese-traditional-devel-2.0.0-4.el10_3.noarch.rpm;name=aarch64_rust-tiny-bip39+chinese-traditional-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-bip39+chinese-traditional-devel}"
SRC_URI[aarch64_rust-tiny-bip39+chinese-traditional-devel.sha256sum] = "6f9929ddc5b083a267882c48da9c8e4da89f11b0b792ebac2fa4e63fbff03403"

URI_aarch64_rust-tiny-bip39+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-bip39+default-devel-2.0.0-4.el10_3.noarch.rpm;name=aarch64_rust-tiny-bip39+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-bip39+default-devel}"
SRC_URI[aarch64_rust-tiny-bip39+default-devel.sha256sum] = "17812eddda8a7a9b887f115e53922208b320183a99e5547f39362ebdf25fa412"

URI_aarch64_rust-tiny-bip39+default-langs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-bip39+default-langs-devel-2.0.0-4.el10_3.noarch.rpm;name=aarch64_rust-tiny-bip39+default-langs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-bip39+default-langs-devel}"
SRC_URI[aarch64_rust-tiny-bip39+default-langs-devel.sha256sum] = "6e4c956da643760fccdf83533e7044292d0ff423f33b3b3c4fc523c6d058cca1"

URI_aarch64_rust-tiny-bip39+french-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-bip39+french-devel-2.0.0-4.el10_3.noarch.rpm;name=aarch64_rust-tiny-bip39+french-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-bip39+french-devel}"
SRC_URI[aarch64_rust-tiny-bip39+french-devel.sha256sum] = "dc6fa5628a83fe3e3790edeb11e4dfd6f858adec3e20fd44e4971edadb961a99"

URI_aarch64_rust-tiny-bip39+italian-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-bip39+italian-devel-2.0.0-4.el10_3.noarch.rpm;name=aarch64_rust-tiny-bip39+italian-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-bip39+italian-devel}"
SRC_URI[aarch64_rust-tiny-bip39+italian-devel.sha256sum] = "6f45f267713e7a94d5e5e6881a2e7a2eb33be2758ad5d3226b46246e0b293498"

URI_aarch64_rust-tiny-bip39+japanese-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-bip39+japanese-devel-2.0.0-4.el10_3.noarch.rpm;name=aarch64_rust-tiny-bip39+japanese-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-bip39+japanese-devel}"
SRC_URI[aarch64_rust-tiny-bip39+japanese-devel.sha256sum] = "7349f44d8b1c61e6e2611b3e9aea7ff6fba20d8c1ec6426cddaab4bd123f06ca"

URI_aarch64_rust-tiny-bip39+korean-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-bip39+korean-devel-2.0.0-4.el10_3.noarch.rpm;name=aarch64_rust-tiny-bip39+korean-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-bip39+korean-devel}"
SRC_URI[aarch64_rust-tiny-bip39+korean-devel.sha256sum] = "7035da9252b6de16478f8ec1b434aedc535399d7bb11cd1fca368dbcd0b3c5db"

URI_aarch64_rust-tiny-bip39+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-bip39+rand-devel-2.0.0-4.el10_3.noarch.rpm;name=aarch64_rust-tiny-bip39+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-bip39+rand-devel}"
SRC_URI[aarch64_rust-tiny-bip39+rand-devel.sha256sum] = "9d3407f57f7f18d5d6b75e6d1d155adaa70d3afe482bbbab38c7807cd2e2e9b7"

URI_aarch64_rust-tiny-bip39+spanish-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-bip39+spanish-devel-2.0.0-4.el10_3.noarch.rpm;name=aarch64_rust-tiny-bip39+spanish-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-bip39+spanish-devel}"
SRC_URI[aarch64_rust-tiny-bip39+spanish-devel.sha256sum] = "062d73ce45aa88393f9eda83fe3bcc8eed37f9f5fda3b0bc3cce410d7d89db74"

URI_aarch64_rust-tiny-bip39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-bip39-devel-2.0.0-4.el10_3.noarch.rpm;name=aarch64_rust-tiny-bip39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-bip39-devel}"
SRC_URI[aarch64_rust-tiny-bip39-devel.sha256sum] = "f88aa27bb9e3f467a0a66854e6af72dea77f54293a2c8a2b9303e9c9967af1af"

RDEPENDS:rust-tiny-bip39+chinese-simplified-devel = " \
 cargo \
 rust-tiny-bip39-devel \
 "
RDEPENDS:rust-tiny-bip39+chinese-traditional-devel = " \
 cargo \
 rust-tiny-bip39-devel \
 "
RDEPENDS:rust-tiny-bip39+default-devel = " \
 cargo \
 rust-tiny-bip39+default-langs-devel \
 rust-tiny-bip39+rand-devel \
 rust-tiny-bip39-devel \
 "
RDEPENDS:rust-tiny-bip39+default-langs-devel = " \
 cargo \
 rust-tiny-bip39+chinese-simplified-devel \
 rust-tiny-bip39+chinese-traditional-devel \
 rust-tiny-bip39+french-devel \
 rust-tiny-bip39+italian-devel \
 rust-tiny-bip39+japanese-devel \
 rust-tiny-bip39+korean-devel \
 rust-tiny-bip39+spanish-devel \
 rust-tiny-bip39-devel \
 "
RDEPENDS:rust-tiny-bip39+french-devel = " \
 cargo \
 rust-tiny-bip39-devel \
 "
RDEPENDS:rust-tiny-bip39+italian-devel = " \
 cargo \
 rust-tiny-bip39-devel \
 "
RDEPENDS:rust-tiny-bip39+japanese-devel = " \
 cargo \
 rust-tiny-bip39-devel \
 "
RDEPENDS:rust-tiny-bip39+korean-devel = " \
 cargo \
 rust-tiny-bip39-devel \
 "
RDEPENDS:rust-tiny-bip39+rand-devel = " \
 cargo \
 rust-rand0.8+default-devel \
 rust-tiny-bip39-devel \
 "
RDEPENDS:rust-tiny-bip39+spanish-devel = " \
 cargo \
 rust-tiny-bip39-devel \
 "
RDEPENDS:rust-tiny-bip39-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-pbkdf2_0.12+hmac-devel \
 rust-pbkdf2_0.12-devel \
 rust-rustc-hash1+default-devel \
 rust-sha2_0.10+default-devel \
 rust-thiserror1+default-devel \
 rust-unicode-normalization+default-devel \
 rust-zeroize+default-devel \
 rust-zeroize+zeroize_derive-devel \
 "
