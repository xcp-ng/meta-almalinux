# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gh"
PV = "2.97.0"
PR = "2.el10_2"
PACKAGES = " \
 gh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gh-2.97.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd8dc8107ec00a17e603ca5ce076d1c24eda18555ee59b21ce03b8603270bc8c"

URI_x86_64_v2_gh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gh-2.97.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gh}"
SRC_URI[x86_64_v2_gh.sha256sum] = "5a54d64b742c209300bccbae8e470053510182538c4ea72becf3515e7539e435"

URI_aarch64_gh = "${EPEL_MIRROR}/aarch64/Packages/g/gh-2.97.0-2.el10_2.aarch64.rpm;name=aarch64_gh;unpack=0"
SRC_URI:append = " ${URI_aarch64_gh}"
SRC_URI[aarch64_gh.sha256sum] = "b442022ba49fab2aed15c1b2f700b6f45426782b464b7b89c9d7257982b09956"

RDEPENDS:gh = " \
 git-core \
 glibc \
 "
