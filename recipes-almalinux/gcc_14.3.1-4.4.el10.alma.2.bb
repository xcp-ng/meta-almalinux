# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc"
PV = "14.3.1"
PR = "4.4.el10.alma.2"
PACKAGES:x86_64_v2 = " \
 cpp \
 gcc \
 gcc-c++ \
 gcc-gfortran \
 gcc-offload-amdgcn \
 gcc-offload-nvptx \
 gcc-plugin-annobin \
 gcc-plugin-devel \
 libasan \
 libatomic \
 libgcc \
 libgccjit \
 libgccjit-devel \
 libgfortran \
 libgfortran-static \
 libgomp \
 libgomp-offload-amdgcn \
 libgomp-offload-nvptx \
 libhwasan \
 libitm \
 libitm-devel \
 liblsan \
 libquadmath \
 libquadmath-devel \
 libquadmath-static \
 libstdc++ \
 libstdc++-devel \
 libstdc++-docs \
 libstdc++-static \
 libtsan \
 libubsan \
"
PACKAGES:aarch64 = " \
 cpp \
 gcc \
 gcc-c++ \
 gcc-gfortran \
 gcc-plugin-annobin \
 gcc-plugin-devel \
 libasan \
 libatomic \
 libgcc \
 libgccjit \
 libgccjit-devel \
 libgfortran \
 libgfortran-static \
 libgomp \
 libhwasan \
 libitm \
 libitm-devel \
 liblsan \
 libstdc++ \
 libstdc++-devel \
 libstdc++-docs \
 libstdc++-static \
 libtsan \
 libubsan \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gcc-14.3.1-4.4.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdd91eb86479d4c5411cc6da6eb34eea3d78d1fb753be35d0a5317c7068257a1"

URI_x86_64_v2_cpp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cpp-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpp}"
SRC_URI[x86_64_v2_cpp.sha256sum] = "e9c5bf9d36f2f3c179929f75adb2d93bfe29c78891e72b9ea5f11380cdf5c37a"

URI_x86_64_v2_gcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc}"
SRC_URI[x86_64_v2_gcc.sha256sum] = "426e42a1a54b90444735800d04005ef5223d18d0abf893b6c53e8834633b98b9"

URI_x86_64_v2_gcc-c++ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-c++-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++}"
SRC_URI[x86_64_v2_gcc-c++.sha256sum] = "030c8d8d8497b27d2ba06e35ee0495006670234b6c8509d90ecec9bf31af1caa"

URI_x86_64_v2_gcc-gfortran = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-gfortran-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-gfortran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-gfortran}"
SRC_URI[x86_64_v2_gcc-gfortran.sha256sum] = "6b4ece5ec23b29ca8da6bfec256f3998e0493cf33bfbb2fd7f33c48d62abf54d"

URI_x86_64_v2_gcc-offload-amdgcn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-offload-amdgcn-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-offload-amdgcn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-offload-amdgcn}"
SRC_URI[x86_64_v2_gcc-offload-amdgcn.sha256sum] = "70333aeb6d2b5be5a3928514689032994ea7684f1df51e9d5e6a40c7bf7d691e"

URI_x86_64_v2_gcc-offload-nvptx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-offload-nvptx-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-offload-nvptx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-offload-nvptx}"
SRC_URI[x86_64_v2_gcc-offload-nvptx.sha256sum] = "969d244d579b1d485271c49a56ffc329e81cddac90a07bf619d0c371879d5c0e"

URI_x86_64_v2_gcc-plugin-annobin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-plugin-annobin-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-plugin-annobin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-plugin-annobin}"
SRC_URI[x86_64_v2_gcc-plugin-annobin.sha256sum] = "10b3122238ce25f8496b01b044cb4c5a85fe12b755e4c16132249cf9f84d2583"

URI_x86_64_v2_gcc-plugin-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-plugin-devel-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-plugin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-plugin-devel}"
SRC_URI[x86_64_v2_gcc-plugin-devel.sha256sum] = "b5d260982274853dc4fb904aeca53ec7803cc7b4d73e8bc591f1feaeed01b47e"

URI_x86_64_v2_libasan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libasan-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libasan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libasan}"
SRC_URI[x86_64_v2_libasan.sha256sum] = "a0cb94245293d3a1c2c4c885efa2e8e7075da4f631ae38ee0f10f777a64311b7"

URI_x86_64_v2_libatomic = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libatomic-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libatomic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libatomic}"
SRC_URI[x86_64_v2_libatomic.sha256sum] = "ca641d17ebc854f30c0df9a55779fddcbba40bd964ab18bcf651b5a12318b943"

URI_x86_64_v2_libgcc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgcc-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgcc}"
SRC_URI[x86_64_v2_libgcc.sha256sum] = "4dc43670fb4b65fb3eda4324e3386af17aad39a48dbfafd8792ffee54b51ffa2"

URI_x86_64_v2_libgccjit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgccjit-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgccjit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgccjit}"
SRC_URI[x86_64_v2_libgccjit.sha256sum] = "a13c33501ce4fbd28f2bc66baff2429c44a79647c2076942d1162033313635d4"
RPROVIDES:libgccjit:x86_64_v2 = "virtual/libgccjit.so.0___64bit_"

URI_x86_64_v2_libgccjit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgccjit-devel-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgccjit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgccjit-devel}"
SRC_URI[x86_64_v2_libgccjit-devel.sha256sum] = "7b1f191c13ea5d5e82b4e70b21285b9c41034d8e0d08a6ecf01764093a103ccc"

URI_x86_64_v2_libgfortran = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgfortran-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgfortran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgfortran}"
SRC_URI[x86_64_v2_libgfortran.sha256sum] = "049d030c95f9617be7739e27f333c2cea0364d807621e0be599ac7327bf93633"

URI_x86_64_v2_libgfortran-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgfortran-static-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgfortran-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgfortran-static}"
SRC_URI[x86_64_v2_libgfortran-static.sha256sum] = "414bf2e50ce3b4c48deae212aa00d50e317d4ccea0b6aa5da78f7cc3bcfc6180"

URI_x86_64_v2_libgomp = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgomp-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgomp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgomp}"
SRC_URI[x86_64_v2_libgomp.sha256sum] = "bb5ede4a4cd552baa8463aeb950eab56d53173593fc4aeacc1025405e1f67181"

URI_x86_64_v2_libgomp-offload-amdgcn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgomp-offload-amdgcn-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgomp-offload-amdgcn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgomp-offload-amdgcn}"
SRC_URI[x86_64_v2_libgomp-offload-amdgcn.sha256sum] = "90125843ceced98493c4de1df997511c0295d117dc5ea25d9ebbbb11c02466d4"

URI_x86_64_v2_libgomp-offload-nvptx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgomp-offload-nvptx-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libgomp-offload-nvptx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgomp-offload-nvptx}"
SRC_URI[x86_64_v2_libgomp-offload-nvptx.sha256sum] = "2029959e2147cd1532a968f41a44d2f73ae9d04633e879a8dd44685ccf957527"

URI_x86_64_v2_libhwasan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libhwasan-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libhwasan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libhwasan}"
SRC_URI[x86_64_v2_libhwasan.sha256sum] = "c625f9cf3049dcff0ec578a42add356658c99e288aa815d1144774c2062e9070"

URI_x86_64_v2_libitm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libitm-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libitm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libitm}"
SRC_URI[x86_64_v2_libitm.sha256sum] = "aaa671a2ab3343d5c7f68be72c2116c812aee023d4081b282d4156c2ee267cc1"

URI_x86_64_v2_libitm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libitm-devel-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libitm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libitm-devel}"
SRC_URI[x86_64_v2_libitm-devel.sha256sum] = "95feb7c6b1f71601f0ee6405edbf7901d446bbd2b964e7c20ea5e875b5b5a1c2"

URI_x86_64_v2_liblsan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liblsan-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_liblsan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblsan}"
SRC_URI[x86_64_v2_liblsan.sha256sum] = "6be8d7ec9406f97efc0c10d05ae8d72e1a42fe37b74c0a5a3285c2b340aeead3"

URI_x86_64_v2_libquadmath = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libquadmath-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libquadmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquadmath}"
SRC_URI[x86_64_v2_libquadmath.sha256sum] = "5d247022d549e3526195c25ff9132beaa5308ea6532d180b669d7511ddcb5981"

URI_x86_64_v2_libquadmath-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libquadmath-devel-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libquadmath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquadmath-devel}"
SRC_URI[x86_64_v2_libquadmath-devel.sha256sum] = "c14b8327cc4d5c326b132ef1b4945ce9b951a962e3810cc38f83c984a9dc74ed"

URI_x86_64_v2_libquadmath-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libquadmath-static-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libquadmath-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquadmath-static}"
SRC_URI[x86_64_v2_libquadmath-static.sha256sum] = "606aec4e6f4f458625feea23e57751f005142619bb388b9ae040ed4112b5623d"

URI_x86_64_v2_libstdc++ = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libstdc++-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libstdc++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++}"
SRC_URI[x86_64_v2_libstdc++.sha256sum] = "c93a43126ac19716c076ea234b014d471fe7b1b320137ea603a48768389e56b3"

URI_x86_64_v2_libstdc++-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstdc++-devel-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++-devel}"
SRC_URI[x86_64_v2_libstdc++-devel.sha256sum] = "0009fd00ce85ec81642030676ffd237e50796d2402442c91f05b7ad35c19ad05"

URI_x86_64_v2_libstdc++-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstdc++-docs-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libstdc++-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++-docs}"
SRC_URI[x86_64_v2_libstdc++-docs.sha256sum] = "4915ccddb0957a6d86051ac4a0fde7c5aa7a60ede2fda097c49d742116dbf627"

URI_x86_64_v2_libstdc++-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libstdc++-static-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libstdc++-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstdc++-static}"
SRC_URI[x86_64_v2_libstdc++-static.sha256sum] = "86f60f647a7c5218ba5087d1666bf6f6115ad3b664edae0414a0915a5d3dd979"

URI_x86_64_v2_libtsan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtsan-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libtsan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtsan}"
SRC_URI[x86_64_v2_libtsan.sha256sum] = "6e1158679bfc23f67cf39b5903111f40431d04459c2b5e5af12c2300561e7dfb"

URI_x86_64_v2_libubsan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libubsan-14.3.1-4.4.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_libubsan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libubsan}"
SRC_URI[x86_64_v2_libubsan.sha256sum] = "26b77d1a3a1d955f6e65e2228fc9553cc94df80a780bd989abb05df28e515859"

URI_aarch64_cpp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cpp-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpp}"
SRC_URI[aarch64_cpp.sha256sum] = "64455574d32d22b7c767f8ad28cfe87a0007a5000fe0d1adeb32754e3520caac"

URI_aarch64_gcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc}"
SRC_URI[aarch64_gcc.sha256sum] = "e15b77573a6d8bbfda5230d5fda066ff2b4fbb7b999ea358cb1363450374d5ab"

URI_aarch64_gcc-c++ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-c++-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_gcc-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++}"
SRC_URI[aarch64_gcc-c++.sha256sum] = "a8e702add08c978b79ec6dc9ae53bdcbd61466db6ec4583a73764e1a4b540374"

URI_aarch64_gcc-gfortran = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-gfortran-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_gcc-gfortran;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-gfortran}"
SRC_URI[aarch64_gcc-gfortran.sha256sum] = "fa3b57d1447f5fad1ffe2e0bbbe8e3af6f01b9d5c5d311821a11f63afb30154e"

URI_aarch64_gcc-plugin-annobin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-plugin-annobin-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_gcc-plugin-annobin;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-plugin-annobin}"
SRC_URI[aarch64_gcc-plugin-annobin.sha256sum] = "32b8e0100b6cbef233d8360304c8d4bd8a312c4e7ca35907cbf66fdb1e63e81e"

URI_aarch64_gcc-plugin-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-plugin-devel-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_gcc-plugin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-plugin-devel}"
SRC_URI[aarch64_gcc-plugin-devel.sha256sum] = "38bd347ce636ca01957c0482d36ac3a9b32d2bf7af79b29047a03969a42f877c"

URI_aarch64_libasan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libasan-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libasan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libasan}"
SRC_URI[aarch64_libasan.sha256sum] = "80a432282fc01425a7bef96cc664b55c1b27383b415a16e03fc42a216b9c8eaa"

URI_aarch64_libatomic = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libatomic-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libatomic;unpack=0"
SRC_URI:append = " ${URI_aarch64_libatomic}"
SRC_URI[aarch64_libatomic.sha256sum] = "76d6cce96395839ccdb12795f83a15f680432c204e6787c5fdbf48bccd081e1e"

URI_aarch64_libgcc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgcc-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libgcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgcc}"
SRC_URI[aarch64_libgcc.sha256sum] = "4c2128d9827bc440821e71b3311f3083598881e4411248cff24fc0ee15702655"

URI_aarch64_libgccjit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgccjit-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libgccjit;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgccjit}"
SRC_URI[aarch64_libgccjit.sha256sum] = "eb7905b80c21e11fc5a98bcf6e1247a140c3c805ea9da3de656840368f8a3d86"
RPROVIDES:libgccjit:aarch64 = "virtual/libgccjit.so.0___64bit_"

URI_aarch64_libgccjit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgccjit-devel-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libgccjit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgccjit-devel}"
SRC_URI[aarch64_libgccjit-devel.sha256sum] = "5977563b4ab25ed91b66e5a1b96b45a06420558f483ba43b4b6fa2d126973489"

URI_aarch64_libgfortran = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgfortran-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libgfortran;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgfortran}"
SRC_URI[aarch64_libgfortran.sha256sum] = "aca94f23cbb9bc7aec3d5cde73896986999e97d350870c2be09789dc14e11d57"

URI_aarch64_libgfortran-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgfortran-static-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libgfortran-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgfortran-static}"
SRC_URI[aarch64_libgfortran-static.sha256sum] = "f1a4bfbb4a95ec9a5f7bf058ffdeaf8b8b4bedbdd59ce59fabb1023a98d3244b"

URI_aarch64_libgomp = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgomp-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libgomp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgomp}"
SRC_URI[aarch64_libgomp.sha256sum] = "f6522fb52a99984b4168afce72aa9016f3ca33482eb44ebc213f624c69aae53f"

URI_aarch64_libhwasan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libhwasan-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libhwasan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libhwasan}"
SRC_URI[aarch64_libhwasan.sha256sum] = "21c7a6af09bdbf89bdfb131cad6fa09b6b489b4265502595fe105a49447db963"

URI_aarch64_libitm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libitm-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libitm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libitm}"
SRC_URI[aarch64_libitm.sha256sum] = "36f6ade731558c2c010fef9af875d663f589312f98ab529636c675b2dfde45d9"

URI_aarch64_libitm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libitm-devel-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libitm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libitm-devel}"
SRC_URI[aarch64_libitm-devel.sha256sum] = "0833a5ae248b7f341b7222d058f56d4937b434500f3c8c6eaf94d402a98f24d7"

URI_aarch64_liblsan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liblsan-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_liblsan;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblsan}"
SRC_URI[aarch64_liblsan.sha256sum] = "8250f6cf98ed863acf6fe98af6d910668371ef117bb2daa7e4041b1b68af8ab4"

URI_aarch64_libstdc++ = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libstdc++-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libstdc++;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++}"
SRC_URI[aarch64_libstdc++.sha256sum] = "beefc59eab8d0b804c1dc9ee48da5efeb44a6cfbbe5ff90e1ad295f17cdc28cf"

URI_aarch64_libstdc++-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstdc++-devel-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++-devel}"
SRC_URI[aarch64_libstdc++-devel.sha256sum] = "869edf472d39af83d533dda31492d4978734d836b1ffd8a3954f02a36d19c2b1"

URI_aarch64_libstdc++-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstdc++-docs-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libstdc++-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++-docs}"
SRC_URI[aarch64_libstdc++-docs.sha256sum] = "b80efc0a43a973b2e6f9b557cfd57b9dd5d2e0eaeb5656c84e5902436819f259"

URI_aarch64_libstdc++-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libstdc++-static-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libstdc++-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstdc++-static}"
SRC_URI[aarch64_libstdc++-static.sha256sum] = "b51b3753241d3f99e04c44bd0c0fe2eff822adbf949b54b11e3e3a0eff49b02a"

URI_aarch64_libtsan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtsan-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libtsan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtsan}"
SRC_URI[aarch64_libtsan.sha256sum] = "ed5d4bd9083d74c815ecc9de30f37d9bc13cbd8702b177af94ea88a84a38d9e4"

URI_aarch64_libubsan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libubsan-14.3.1-4.4.el10.alma.2.aarch64.rpm;name=aarch64_libubsan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libubsan}"
SRC_URI[aarch64_libubsan.sha256sum] = "91fcce1e343fbd3a391fa4379728945a3d475774070110abdf20b329945df073"

RDEPENDS:cpp = " \
 filesystem \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc:x86_64_v2 = " \
 bash \
 binutils \
 cpp \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc:aarch64 = " \
 bash \
 binutils \
 cpp \
 glibc \
 glibc-devel \
 gmp \
 libasan \
 libatomic \
 libgcc \
 libgomp \
 libmpc \
 libubsan \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-c++ = " \
 gcc \
 glibc \
 gmp \
 libmpc \
 libstdc++ \
 libstdc++-devel \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-gfortran:x86_64_v2 = " \
 gcc \
 glibc \
 gmp \
 libgfortran \
 libmpc \
 libquadmath \
 libquadmath-devel \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-gfortran:aarch64 = " \
 gcc \
 glibc \
 gmp \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-offload-amdgcn = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-amdgcn \
 libmpc \
 libstdc++ \
 libzstd \
 lld \
 llvm \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-offload-nvptx = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-nvptx \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-plugin-annobin = " \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gcc-plugin-devel = " \
 gcc \
 glibc \
 gmp-devel \
 libmpc-devel \
 mpfr-devel \
 "
RDEPENDS:libasan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libatomic = " \
 glibc \
 "
RDEPENDS:libgcc = " \
 "
RDEPENDS:libgccjit = " \
 gcc \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:libgccjit-devel = " \
 libgccjit \
 virtual/libgccjit.so.0___64bit_ \
 "
RDEPENDS:libgfortran = " \
 glibc \
 libgcc \
 "
RDEPENDS:libgfortran-static:x86_64_v2 = " \
 gcc \
 libgfortran \
 libquadmath-static \
"
RDEPENDS:libgfortran-static:aarch64 = " \
 gcc \
 libgfortran \
"
RDEPENDS:libgomp = " \
 glibc \
 "
RDEPENDS:libgomp-offload-amdgcn = " \
 glibc \
 libgomp \
 "
RDEPENDS:libgomp-offload-nvptx = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:libhwasan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libitm = " \
 glibc \
 "
RDEPENDS:libitm-devel = " \
 gcc \
 libitm \
 "
RDEPENDS:liblsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libquadmath = " \
 glibc \
 libgcc \
 "
RDEPENDS:libquadmath-devel = " \
 gcc \
 libquadmath \
 "
RDEPENDS:libquadmath-static = " \
 libquadmath-devel \
 "
RDEPENDS:libstdc++ = " \
 glibc \
 libgcc \
 "
RDEPENDS:libstdc++-devel = " \
 libstdc++ \
 "
RDEPENDS:libstdc++-docs = " \
 "
RDEPENDS:libstdc++-static = " \
 libstdc++-devel \
 "
RDEPENDS:libtsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libubsan = " \
 glibc \
 libgcc \
 libstdc++ \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libgccjit.so.0___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libgccjit.so.0___64bit_"
