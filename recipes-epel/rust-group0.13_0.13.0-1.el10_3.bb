# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-group0.13"
PV = "0.13.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-group0.13+alloc-devel \
 rust-group0.13+default-devel \
 rust-group0.13+rand-devel \
 rust-group0.13+rand_xorshift-devel \
 rust-group0.13+tests-devel \
 rust-group0.13-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-group0.13-0.13.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eac5f1ad6d6c290303e0713da8105792d3bbe831ddcee352fcb48c639c23dced"

URI_x86_64_v2_rust-group0.13+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group0.13+alloc-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group0.13+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group0.13+alloc-devel}"
SRC_URI[x86_64_v2_rust-group0.13+alloc-devel.sha256sum] = "c2924bb155666dd9742c1fab2480768c5607bc56d4d70d85c09fb2395b55dcbc"

URI_x86_64_v2_rust-group0.13+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group0.13+default-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group0.13+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group0.13+default-devel}"
SRC_URI[x86_64_v2_rust-group0.13+default-devel.sha256sum] = "c4e9af676278004bb75fba5a6601bcb5e6204730ff1a48213a64d2b6ab31bc50"

URI_x86_64_v2_rust-group0.13+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group0.13+rand-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group0.13+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group0.13+rand-devel}"
SRC_URI[x86_64_v2_rust-group0.13+rand-devel.sha256sum] = "fcbb13aa191bf3fae8cc39a4ecaa840f720678b18dd0d610247b5f10eb30eece"

URI_x86_64_v2_rust-group0.13+rand_xorshift-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group0.13+rand_xorshift-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group0.13+rand_xorshift-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group0.13+rand_xorshift-devel}"
SRC_URI[x86_64_v2_rust-group0.13+rand_xorshift-devel.sha256sum] = "954ce40b3876aeee887f2cc6b30d12b2978d4a524b3347cc0b4beb0bf12efd25"

URI_x86_64_v2_rust-group0.13+tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group0.13+tests-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group0.13+tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group0.13+tests-devel}"
SRC_URI[x86_64_v2_rust-group0.13+tests-devel.sha256sum] = "0c4c0c9e01938a0b3c4cbf9c3d3577eb4d5f9127494a28ac9bf2f79bd54be215"

URI_x86_64_v2_rust-group0.13-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-group0.13-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-group0.13-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-group0.13-devel}"
SRC_URI[x86_64_v2_rust-group0.13-devel.sha256sum] = "28c5ea8f3f1c6b192b3126a2e421c9485b442f7b2e4fb63080d29e9e9c06651f"

URI_aarch64_rust-group0.13+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group0.13+alloc-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-group0.13+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group0.13+alloc-devel}"
SRC_URI[aarch64_rust-group0.13+alloc-devel.sha256sum] = "933bff5c602b3bba322fce032164fe3e098daac25255c3b184bf276d1e121b5c"

URI_aarch64_rust-group0.13+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group0.13+default-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-group0.13+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group0.13+default-devel}"
SRC_URI[aarch64_rust-group0.13+default-devel.sha256sum] = "e68eafbf14ca402e938a5998d79f3a656fd429c8677147ab4cb4a6a05eb65395"

URI_aarch64_rust-group0.13+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group0.13+rand-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-group0.13+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group0.13+rand-devel}"
SRC_URI[aarch64_rust-group0.13+rand-devel.sha256sum] = "80bf05112f259e91c673b182d9aadaad972e913cc78da5933a5bea49af6bf387"

URI_aarch64_rust-group0.13+rand_xorshift-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group0.13+rand_xorshift-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-group0.13+rand_xorshift-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group0.13+rand_xorshift-devel}"
SRC_URI[aarch64_rust-group0.13+rand_xorshift-devel.sha256sum] = "fb0f3c1259b7477b9982b152085fed02bb2c87846e5ded81ebc5ed593480d94c"

URI_aarch64_rust-group0.13+tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group0.13+tests-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-group0.13+tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group0.13+tests-devel}"
SRC_URI[aarch64_rust-group0.13+tests-devel.sha256sum] = "a09c831e0b0c90aacad7955e1576e91497d52c128d32ca3014c16f796bd3c3db"

URI_aarch64_rust-group0.13-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-group0.13-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-group0.13-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-group0.13-devel}"
SRC_URI[aarch64_rust-group0.13-devel.sha256sum] = "a893da97ebbcbe110628aca9eca55b167848a5bd7ef91d13adf773e1ccc73146"

RDEPENDS:rust-group0.13+alloc-devel = " \
 cargo \
 rust-group0.13-devel \
 "
RDEPENDS:rust-group0.13+default-devel = " \
 cargo \
 rust-group0.13+alloc-devel \
 rust-group0.13-devel \
 "
RDEPENDS:rust-group0.13+rand-devel = " \
 cargo \
 rust-group0.13-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-group0.13+rand_xorshift-devel = " \
 cargo \
 rust-group0.13-devel \
 rust-rand_xorshift0.3+default-devel \
 "
RDEPENDS:rust-group0.13+tests-devel = " \
 cargo \
 rust-group0.13+alloc-devel \
 rust-group0.13+rand-devel \
 rust-group0.13+rand_xorshift-devel \
 rust-group0.13-devel \
 "
RDEPENDS:rust-group0.13-devel = " \
 cargo \
 rust-ff0.13-devel \
 rust-rand_core0.6-devel \
 rust-subtle-devel \
 "
