# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3"
PV = "0.29.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-pyo3+abi3-devel \
 rust-pyo3+abi3-py310-devel \
 rust-pyo3+abi3-py311-devel \
 rust-pyo3+abi3-py312-devel \
 rust-pyo3+abi3-py313-devel \
 rust-pyo3+abi3-py314-devel \
 rust-pyo3+abi3-py315-devel \
 rust-pyo3+abi3-py38-devel \
 rust-pyo3+abi3-py39-devel \
 rust-pyo3+abi3t-devel \
 rust-pyo3+abi3t-py315-devel \
 rust-pyo3+anyhow-devel \
 rust-pyo3+arc_lock-devel \
 rust-pyo3+auto-initialize-devel \
 rust-pyo3+bigdecimal-devel \
 rust-pyo3+bytes-devel \
 rust-pyo3+chrono-devel \
 rust-pyo3+chrono-local-devel \
 rust-pyo3+chrono-tz-devel \
 rust-pyo3+default-devel \
 rust-pyo3+either-devel \
 rust-pyo3+experimental-async-devel \
 rust-pyo3+experimental-inspect-devel \
 rust-pyo3+extension-module-devel \
 rust-pyo3+eyre-devel \
 rust-pyo3+full-devel \
 rust-pyo3+hashbrown-devel \
 rust-pyo3+indexmap-devel \
 rust-pyo3+inventory-devel \
 rust-pyo3+jiff-02-devel \
 rust-pyo3+lock_api-devel \
 rust-pyo3+macros-devel \
 rust-pyo3+multiple-pymethods-devel \
 rust-pyo3+nightly-devel \
 rust-pyo3+num-bigint-devel \
 rust-pyo3+num-complex-devel \
 rust-pyo3+num-rational-devel \
 rust-pyo3+ordered-float-devel \
 rust-pyo3+parking_lot-devel \
 rust-pyo3+py-clone-devel \
 rust-pyo3+pyo3-macros-devel \
 rust-pyo3+rust_decimal-devel \
 rust-pyo3+serde-devel \
 rust-pyo3+smallvec-devel \
 rust-pyo3+time-devel \
 rust-pyo3+uuid-devel \
 rust-pyo3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-0.29.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95773abceae3cabc42896a71f73bfe59542f184fd4ff4fb31d9fac660c2daeb6"

URI_x86_64_v2_rust-pyo3+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-devel.sha256sum] = "63f0ef35e8ce8f51d11f7eed87af3dcb08f46f98c424368ab1f001ad4a98dc9f"

URI_x86_64_v2_rust-pyo3+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py310-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py310-devel.sha256sum] = "2f4e091805e84a726e5314472d865b6dbfd39a9595a25a99595f48269d774d17"

URI_x86_64_v2_rust-pyo3+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py311-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py311-devel.sha256sum] = "88ce71dcb91d93eeae122e6e82689b2db85e6bd55564131de4676e21a428b6c5"

URI_x86_64_v2_rust-pyo3+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py312-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py312-devel.sha256sum] = "65a3d4d2c6e6f413200a5d3c642900ba3b2d25d8c0e4cec1b2af17ac04f096db"

URI_x86_64_v2_rust-pyo3+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py313-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py313-devel.sha256sum] = "f4cd01268bd3ef8be62b97c4483653cf8ff2e94ad32c5615c715017640250329"

URI_x86_64_v2_rust-pyo3+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py314-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py314-devel.sha256sum] = "48a6e7bd319c51841d3654247bfae0e5e62f39c1aaccf9b32bb92d4c507c014d"

URI_x86_64_v2_rust-pyo3+abi3-py315-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py315-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py315-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py315-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py315-devel.sha256sum] = "150a3c957193fa6ee60d7f1c6fc0298b2e6cfb8a848f2a89905096b04f2dd5ee"

URI_x86_64_v2_rust-pyo3+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py38-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py38-devel.sha256sum] = "aa3ada5dc448a62a0fe836c5d1ca879e6953c885409c4ea6ea1ecc829ba5364a"

URI_x86_64_v2_rust-pyo3+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py39-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py39-devel.sha256sum] = "b1c421dfe021479581fcf2c752c100446f7370878e23e512efdaadf099797ca4"

URI_x86_64_v2_rust-pyo3+abi3t-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3t-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3t-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3t-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3t-devel.sha256sum] = "d2e3fd206be7a7094cb480fa5b076b0c98e812f84ce4bea95597f1a081260eac"

URI_x86_64_v2_rust-pyo3+abi3t-py315-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3t-py315-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3t-py315-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3t-py315-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3t-py315-devel.sha256sum] = "2924f6a6231b025a4e5fd345ea38df0adc6d76a4d5d0541cc81c0c13c6d7aa90"

URI_x86_64_v2_rust-pyo3+anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+anyhow-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+anyhow-devel}"
SRC_URI[x86_64_v2_rust-pyo3+anyhow-devel.sha256sum] = "f6edd33b6cd4e1e9d0622fc5c99d851f265f22274abe0cd1e977e0ada2f15711"

URI_x86_64_v2_rust-pyo3+arc_lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+arc_lock-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+arc_lock-devel}"
SRC_URI[x86_64_v2_rust-pyo3+arc_lock-devel.sha256sum] = "8354377a0184b81b9ddd4bebeb54f1e11a1e17d9e27a987206faf886e19f1a11"

URI_x86_64_v2_rust-pyo3+auto-initialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+auto-initialize-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+auto-initialize-devel}"
SRC_URI[x86_64_v2_rust-pyo3+auto-initialize-devel.sha256sum] = "3854495f832235c3e79de8474d464034b961bf5105bcf4a9b029bc59cc5cd201"

URI_x86_64_v2_rust-pyo3+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+bigdecimal-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3+bigdecimal-devel.sha256sum] = "ad55adfea704e0034c514164757adb16d6644b283c58aa9534681810a106e677"

URI_x86_64_v2_rust-pyo3+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+bytes-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+bytes-devel}"
SRC_URI[x86_64_v2_rust-pyo3+bytes-devel.sha256sum] = "12b3bc19f3fe1efe5baaf8250571f1dd67bb17d345a0f8eae6f6df271f99c98b"

URI_x86_64_v2_rust-pyo3+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+chrono-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+chrono-devel}"
SRC_URI[x86_64_v2_rust-pyo3+chrono-devel.sha256sum] = "a5d9e3428edddc3ad6db7053af3409dc88b03812395c4250e3e3accc60f0c494"

URI_x86_64_v2_rust-pyo3+chrono-local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+chrono-local-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+chrono-local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+chrono-local-devel}"
SRC_URI[x86_64_v2_rust-pyo3+chrono-local-devel.sha256sum] = "104dd2ef889249bf8d7ab900414a1f3f60f064e80be51dc6f477d8afacd99eef"

URI_x86_64_v2_rust-pyo3+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+chrono-tz-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-pyo3+chrono-tz-devel.sha256sum] = "8b1f71554c07afa589394d5617210b31dddb60834a6750a56103c8583d24cc15"

URI_x86_64_v2_rust-pyo3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+default-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3+default-devel.sha256sum] = "7a2bad752e27135fde0622f065e0a518d0448081b417c37109e61f2adf426950"

URI_x86_64_v2_rust-pyo3+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+either-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+either-devel}"
SRC_URI[x86_64_v2_rust-pyo3+either-devel.sha256sum] = "aa04cd55521be740c3b923320a1cf9576fff022ccafeb965ab018d527e9845d2"

URI_x86_64_v2_rust-pyo3+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+experimental-async-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3+experimental-async-devel.sha256sum] = "b903246379368f30a5b3178a33f9b7378a0294f2a7928c39f9aa56e2b4917e17"

URI_x86_64_v2_rust-pyo3+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+experimental-inspect-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3+experimental-inspect-devel.sha256sum] = "e0eb6559bb8400f77b68ed6860f45a5ff136e7d45441bc70bb179f7782ebb595"

URI_x86_64_v2_rust-pyo3+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+extension-module-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3+extension-module-devel.sha256sum] = "6a573bde1f50c0975d721ec57f66385a424f265e88f376c73ec6064b22592c47"

URI_x86_64_v2_rust-pyo3+eyre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+eyre-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+eyre-devel}"
SRC_URI[x86_64_v2_rust-pyo3+eyre-devel.sha256sum] = "d9c296c80e5e42477be00cfd21f6002bc305486524435e085e5a4d1f6828495e"

URI_x86_64_v2_rust-pyo3+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+full-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+full-devel}"
SRC_URI[x86_64_v2_rust-pyo3+full-devel.sha256sum] = "fab4216ac3eee7b577e48f0409a5e59d5ac019cc151771d35189390a497d8037"

URI_x86_64_v2_rust-pyo3+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+hashbrown-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-pyo3+hashbrown-devel.sha256sum] = "0267c294f4244bd325447751ee84c5e927aaad40f0d4e94094a1b1233bf8838c"

URI_x86_64_v2_rust-pyo3+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+indexmap-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+indexmap-devel}"
SRC_URI[x86_64_v2_rust-pyo3+indexmap-devel.sha256sum] = "49045577061ad6bb0a36edbee17c9315cd0b48554ca5c2d918c9ed349d64dc78"

URI_x86_64_v2_rust-pyo3+inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+inventory-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+inventory-devel}"
SRC_URI[x86_64_v2_rust-pyo3+inventory-devel.sha256sum] = "5517cc80a296270e58c87474f56d9d8183d318689e0af49ceead0023a1778e9e"

URI_x86_64_v2_rust-pyo3+jiff-02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+jiff-02-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+jiff-02-devel}"
SRC_URI[x86_64_v2_rust-pyo3+jiff-02-devel.sha256sum] = "3bd6b2c10579e32ccf90950c9d021abf88b798e0701bf94629c1d32d1b55f7db"

URI_x86_64_v2_rust-pyo3+lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+lock_api-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+lock_api-devel}"
SRC_URI[x86_64_v2_rust-pyo3+lock_api-devel.sha256sum] = "46fb1055404a35cdfecf93c9a13bf4045b88a49c91b1dbdb1de6747e16ea214a"

URI_x86_64_v2_rust-pyo3+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+macros-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3+macros-devel.sha256sum] = "33b94abfdb4c66fec2d51bd22a096af4c4d6ea20f247aedd95ab28a5b0fd8571"

URI_x86_64_v2_rust-pyo3+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+multiple-pymethods-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3+multiple-pymethods-devel.sha256sum] = "93896d9845d3d96e49d18691bf739d89006591e25c09275ec77c6350e020876e"

URI_x86_64_v2_rust-pyo3+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+nightly-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+nightly-devel}"
SRC_URI[x86_64_v2_rust-pyo3+nightly-devel.sha256sum] = "f147a386725e0f274e2395c36f73c651f94ee821b70e5a59a084460131702c40"

URI_x86_64_v2_rust-pyo3+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+num-bigint-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-pyo3+num-bigint-devel.sha256sum] = "f16ac13acbbfec7c8bfc33098a12449365278e5a7201d989b82f77941bb0c32b"

URI_x86_64_v2_rust-pyo3+num-complex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+num-complex-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+num-complex-devel}"
SRC_URI[x86_64_v2_rust-pyo3+num-complex-devel.sha256sum] = "ef3631b8f397e161705c42a09ae2999c381e56c118223b37f9ffb9aa094e87f8"

URI_x86_64_v2_rust-pyo3+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+num-rational-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+num-rational-devel}"
SRC_URI[x86_64_v2_rust-pyo3+num-rational-devel.sha256sum] = "36e06c9c849a1322a8457446ef37d10549ea8edebc4f25dc92f1afcc116c4dcf"

URI_x86_64_v2_rust-pyo3+ordered-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+ordered-float-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+ordered-float-devel}"
SRC_URI[x86_64_v2_rust-pyo3+ordered-float-devel.sha256sum] = "75e44b4bc21845a5b1bd56ebd60787cc2c0a240612e2fc79d65a1802c55a208b"

URI_x86_64_v2_rust-pyo3+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+parking_lot-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-pyo3+parking_lot-devel.sha256sum] = "741ee9bc1499e7f918c4abf4d7adfc5b938fb9dc0f2e3e660e54fc7aa50290ba"

URI_x86_64_v2_rust-pyo3+py-clone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+py-clone-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+py-clone-devel}"
SRC_URI[x86_64_v2_rust-pyo3+py-clone-devel.sha256sum] = "ec9481d8990004aec1916364a30187141be5acd674247519f6d5ec9c1d8d1c6c"

URI_x86_64_v2_rust-pyo3+pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+pyo3-macros-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3+pyo3-macros-devel.sha256sum] = "6993980ab6acb0ee972fd07298ed65c9bd6ccbc8f2038a0a922f7befbda40eff"

URI_x86_64_v2_rust-pyo3+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+rust_decimal-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3+rust_decimal-devel.sha256sum] = "cd835eff71a66d502c1a7c4bd6846ee82d2eab44a559084ae233d64e913501aa"

URI_x86_64_v2_rust-pyo3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+serde-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+serde-devel}"
SRC_URI[x86_64_v2_rust-pyo3+serde-devel.sha256sum] = "c8f42f243aac89a221007a8657ac9a84d1ed3093771ef12035f55054b62962d3"

URI_x86_64_v2_rust-pyo3+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+smallvec-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+smallvec-devel}"
SRC_URI[x86_64_v2_rust-pyo3+smallvec-devel.sha256sum] = "8c135b115973f4ff8a7cf22464c0fb354492c2d5c92934cbd9d7bf5d6ecde6a2"

URI_x86_64_v2_rust-pyo3+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+time-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+time-devel}"
SRC_URI[x86_64_v2_rust-pyo3+time-devel.sha256sum] = "f01432dfb56854f516b25873a3eb531f9efec25289044b8a1f1f33b0a4a85cae"

URI_x86_64_v2_rust-pyo3+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+uuid-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+uuid-devel}"
SRC_URI[x86_64_v2_rust-pyo3+uuid-devel.sha256sum] = "62c6e373d5b383bcaf1b425b4d7dceef9db537876137e67e52c3c31e83ab90b4"

URI_x86_64_v2_rust-pyo3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-devel.sha256sum] = "43785b47d94ec54cc62e5ae454bf1594dba318ebab2a0e463f5f9575591f664a"

URI_aarch64_rust-pyo3+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-devel.sha256sum] = "b3e69e4d7da0d4af35d1eb0269d7854eee2451c113a38a529fc897ff6eef59ff"

URI_aarch64_rust-pyo3+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py310-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py310-devel.sha256sum] = "f4531c1bb0f095516b82a90e56b0851c7e2774466580f09330b641eecd89ce4b"

URI_aarch64_rust-pyo3+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py311-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py311-devel.sha256sum] = "b0dfb56c4c05c5d96bff4ff7871c1d1948ac63c0fcd0e7628d3ef65401892c13"

URI_aarch64_rust-pyo3+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py312-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py312-devel.sha256sum] = "939b1003ae314de40e987864c4eff0494bf67e7d97e5ebbd6da7bb30f11a45f7"

URI_aarch64_rust-pyo3+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py313-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py313-devel.sha256sum] = "5e5703a55db2fb91ff1cbcbcdb2ed1f296d23588f230167f78143b5b6843a40f"

URI_aarch64_rust-pyo3+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py314-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py314-devel.sha256sum] = "0b7021f1403741364478d0a573b6fb4ff00e5693a2d8afa50534b98d4af793de"

URI_aarch64_rust-pyo3+abi3-py315-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py315-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+abi3-py315-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py315-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py315-devel.sha256sum] = "99a94133c847d2f64175e4ae40635ab3cc05249e9509f1d744c78aec1aecc2b9"

URI_aarch64_rust-pyo3+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py38-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py38-devel.sha256sum] = "da04b66a6d1ecd0c594e4a507c53489484d827664f1909b8f389c9bb0f0ecebd"

URI_aarch64_rust-pyo3+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py39-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py39-devel.sha256sum] = "ff04b821e0f6b28c19516a2ce4953351fd64de6e67359106a7a81ed4f749526e"

URI_aarch64_rust-pyo3+abi3t-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3t-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+abi3t-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3t-devel}"
SRC_URI[aarch64_rust-pyo3+abi3t-devel.sha256sum] = "0c021882afbc8a6ef9d6b068905435c41f42d82c2fd311bf03a882471d0be188"

URI_aarch64_rust-pyo3+abi3t-py315-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3t-py315-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+abi3t-py315-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3t-py315-devel}"
SRC_URI[aarch64_rust-pyo3+abi3t-py315-devel.sha256sum] = "5ef663c4421fa0a946ba511f8817326497a103a0ea17330e615d17c05c267add"

URI_aarch64_rust-pyo3+anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+anyhow-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+anyhow-devel}"
SRC_URI[aarch64_rust-pyo3+anyhow-devel.sha256sum] = "c8e30416018f86ce95ae2e53c8adfabd689adc49f00e55fa9a2da924cf211ee1"

URI_aarch64_rust-pyo3+arc_lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+arc_lock-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+arc_lock-devel}"
SRC_URI[aarch64_rust-pyo3+arc_lock-devel.sha256sum] = "8c203760fd7cc61abc6158449f690d450b0de1386c8c4d94cf35b6d5b6e2ce00"

URI_aarch64_rust-pyo3+auto-initialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+auto-initialize-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+auto-initialize-devel}"
SRC_URI[aarch64_rust-pyo3+auto-initialize-devel.sha256sum] = "8a0d084fe6f0832083a8e2a28bdaf1e74712523eced842659d82516d60fcc8e1"

URI_aarch64_rust-pyo3+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+bigdecimal-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+bigdecimal-devel}"
SRC_URI[aarch64_rust-pyo3+bigdecimal-devel.sha256sum] = "04362b0274b373649b4894b8906fcfdae29a6f7d1228792d215ca9ce5e4626a2"

URI_aarch64_rust-pyo3+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+bytes-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+bytes-devel}"
SRC_URI[aarch64_rust-pyo3+bytes-devel.sha256sum] = "183e85e694155ea9cc0d8112511c01ee1466f0c4a71399831c1eb2120e484aaf"

URI_aarch64_rust-pyo3+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+chrono-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+chrono-devel}"
SRC_URI[aarch64_rust-pyo3+chrono-devel.sha256sum] = "bc2b9ff00b828af2d696d78b6e8b7faa57ad9222b0df0fef537f1ea833cded2b"

URI_aarch64_rust-pyo3+chrono-local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+chrono-local-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+chrono-local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+chrono-local-devel}"
SRC_URI[aarch64_rust-pyo3+chrono-local-devel.sha256sum] = "d57f56d198d6ebbd8ed9e79355d38f1a153a2a1fd23ba96613ac6c8ef86b230d"

URI_aarch64_rust-pyo3+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+chrono-tz-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+chrono-tz-devel}"
SRC_URI[aarch64_rust-pyo3+chrono-tz-devel.sha256sum] = "492b4fd98985f9768aa36bac56db94a82c22e85ef1f96e39e9dea8ab10224c9f"

URI_aarch64_rust-pyo3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+default-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+default-devel}"
SRC_URI[aarch64_rust-pyo3+default-devel.sha256sum] = "22ae5a2e03192db3b860bc336d651f2431331a326686c7502bb7d6f517f1ce0c"

URI_aarch64_rust-pyo3+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+either-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+either-devel}"
SRC_URI[aarch64_rust-pyo3+either-devel.sha256sum] = "f4d559d5f69bb123769078b49830955fbd2b55d758165c5dd8aa8257f79dc070"

URI_aarch64_rust-pyo3+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+experimental-async-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3+experimental-async-devel.sha256sum] = "fb7fe0ff1eb8ed73ffd3ffea27f8d34040a1cfce66293a3852a6e11005276bc8"

URI_aarch64_rust-pyo3+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+experimental-inspect-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3+experimental-inspect-devel.sha256sum] = "b5bca9821df93c5eee6bc8098a0e9e8312566243a6f50cd1fc79f27ce7bba79c"

URI_aarch64_rust-pyo3+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+extension-module-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3+extension-module-devel.sha256sum] = "7fb0637f6e00b9a77826bafbf5671b0590a62cda3851c9d83311aa912bdc3a3e"

URI_aarch64_rust-pyo3+eyre-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+eyre-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+eyre-devel}"
SRC_URI[aarch64_rust-pyo3+eyre-devel.sha256sum] = "0de1bbe3802777f778a535f23ded2e3ecfa4aafb83ccaa1233fc0d4335a5d4ee"

URI_aarch64_rust-pyo3+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+full-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+full-devel}"
SRC_URI[aarch64_rust-pyo3+full-devel.sha256sum] = "a6407124de38375095c8fec59cf7e7cd5c39646ea6db9c36e13625f0da510d0e"

URI_aarch64_rust-pyo3+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+hashbrown-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+hashbrown-devel}"
SRC_URI[aarch64_rust-pyo3+hashbrown-devel.sha256sum] = "fc4f77834d9abfed55dba62f6adf2f6638ea555493164b14ffdbae79d4b80df3"

URI_aarch64_rust-pyo3+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+indexmap-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+indexmap-devel}"
SRC_URI[aarch64_rust-pyo3+indexmap-devel.sha256sum] = "b2bf30cac09fa653377f42e46871a39d3dc292731d9a47259206f1bf7640b42d"

URI_aarch64_rust-pyo3+inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+inventory-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+inventory-devel}"
SRC_URI[aarch64_rust-pyo3+inventory-devel.sha256sum] = "77712b2af73c2b6673f8bdd28223d68a7e4f191e049306edb7e90356cb8b5c95"

URI_aarch64_rust-pyo3+jiff-02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+jiff-02-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+jiff-02-devel}"
SRC_URI[aarch64_rust-pyo3+jiff-02-devel.sha256sum] = "92de87b8881d6e5bbf388e15ef5bfb65bfe5c728ca22dde915df2ac2f75a57bd"

URI_aarch64_rust-pyo3+lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+lock_api-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+lock_api-devel}"
SRC_URI[aarch64_rust-pyo3+lock_api-devel.sha256sum] = "f41d46fb209addf4464e8253fbd3b97fcc65fdf9358822e9373f2c1c21b22d09"

URI_aarch64_rust-pyo3+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+macros-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+macros-devel}"
SRC_URI[aarch64_rust-pyo3+macros-devel.sha256sum] = "35f3618d9a23fc5f838d5869fce758e50e86ff192eb71622916f7a908cd7e767"

URI_aarch64_rust-pyo3+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+multiple-pymethods-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3+multiple-pymethods-devel.sha256sum] = "7ad715142867a19213bc464643a69d3102a3b58fd316f808cb8cc389baed839e"

URI_aarch64_rust-pyo3+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+nightly-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+nightly-devel}"
SRC_URI[aarch64_rust-pyo3+nightly-devel.sha256sum] = "376bd40755919ab123b926f3f4e42e9a534fb2b861fcc1ffc3100a6ffb0631a0"

URI_aarch64_rust-pyo3+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+num-bigint-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+num-bigint-devel}"
SRC_URI[aarch64_rust-pyo3+num-bigint-devel.sha256sum] = "0a2f88b3344e2d641b1078c260e173068eb23ba4b86f96da14a818ea87a20177"

URI_aarch64_rust-pyo3+num-complex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+num-complex-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+num-complex-devel}"
SRC_URI[aarch64_rust-pyo3+num-complex-devel.sha256sum] = "ecd082f25722889d37d3ec328a1d0fef7cc7ce9a3e8be9a3ed5ade9f85a3161b"

URI_aarch64_rust-pyo3+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+num-rational-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+num-rational-devel}"
SRC_URI[aarch64_rust-pyo3+num-rational-devel.sha256sum] = "c14762ec03f3c9d6390471c2ef933c0a89e4bffbee877ea37a8cdd77eadea045"

URI_aarch64_rust-pyo3+ordered-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+ordered-float-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+ordered-float-devel}"
SRC_URI[aarch64_rust-pyo3+ordered-float-devel.sha256sum] = "80914709c3deba7b15d90e4ed6b86b39c4a3951699421917ae0401c003d4e156"

URI_aarch64_rust-pyo3+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+parking_lot-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+parking_lot-devel}"
SRC_URI[aarch64_rust-pyo3+parking_lot-devel.sha256sum] = "e11ef5be49610b4bcd49ac03e3d4bcf05a1d757a83b6e91a622d5cd9e9aa54c5"

URI_aarch64_rust-pyo3+py-clone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+py-clone-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+py-clone-devel}"
SRC_URI[aarch64_rust-pyo3+py-clone-devel.sha256sum] = "3bcfb8dba18f6c81cbcbaeb7354ba89f28ff54be10d44af524dc8442a8c46ce7"

URI_aarch64_rust-pyo3+pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+pyo3-macros-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3+pyo3-macros-devel.sha256sum] = "5c729ddfd7c669a14275124b05fc13cb616693364d0b5f10828a17607b90c9fa"

URI_aarch64_rust-pyo3+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+rust_decimal-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+rust_decimal-devel}"
SRC_URI[aarch64_rust-pyo3+rust_decimal-devel.sha256sum] = "5c309cfdacc54a4b197d8a2b93713e9ac6e7e4acdc47e1cea893d5b6a22eb794"

URI_aarch64_rust-pyo3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+serde-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+serde-devel}"
SRC_URI[aarch64_rust-pyo3+serde-devel.sha256sum] = "694e219c3758b8b16c2b8c46f3e82210991156fc5f0cc06b1fae57b5be0c1d6d"

URI_aarch64_rust-pyo3+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+smallvec-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+smallvec-devel}"
SRC_URI[aarch64_rust-pyo3+smallvec-devel.sha256sum] = "435dbda01f5b0fa36d30dd66210611efdd8ccc0db6d52a1ffd763a9f46eceb94"

URI_aarch64_rust-pyo3+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+time-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+time-devel}"
SRC_URI[aarch64_rust-pyo3+time-devel.sha256sum] = "7520810dc128e72c96c95a3592e61707716895b89da2d4ad1b5071ac5f1e6b8f"

URI_aarch64_rust-pyo3+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+uuid-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+uuid-devel}"
SRC_URI[aarch64_rust-pyo3+uuid-devel.sha256sum] = "3d3b27b4765e14c45790ede79f3c053edf2fd3f7afac71ff82d50caa1665bfb7"

URI_aarch64_rust-pyo3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-devel}"
SRC_URI[aarch64_rust-pyo3-devel.sha256sum] = "494a3e5a852f1fa81036561b986303db1fca2e6ab47014bb06c87b152eba32db"

RDEPENDS:rust-pyo3+abi3-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-devel \
 "
RDEPENDS:rust-pyo3+abi3-py310-devel = " \
 cargo \
 rust-pyo3+abi3-py311-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py310-devel \
 "
RDEPENDS:rust-pyo3+abi3-py311-devel = " \
 cargo \
 rust-pyo3+abi3-py312-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py311-devel \
 "
RDEPENDS:rust-pyo3+abi3-py312-devel = " \
 cargo \
 rust-pyo3+abi3-py313-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py312-devel \
 "
RDEPENDS:rust-pyo3+abi3-py313-devel = " \
 cargo \
 rust-pyo3+abi3-py314-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py313-devel \
 "
RDEPENDS:rust-pyo3+abi3-py314-devel = " \
 cargo \
 rust-pyo3+abi3-py315-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py314-devel \
 "
RDEPENDS:rust-pyo3+abi3-py315-devel = " \
 cargo \
 rust-pyo3+abi3-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py315-devel \
 "
RDEPENDS:rust-pyo3+abi3-py38-devel = " \
 cargo \
 rust-pyo3+abi3-py39-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py38-devel \
 "
RDEPENDS:rust-pyo3+abi3-py39-devel = " \
 cargo \
 rust-pyo3+abi3-py310-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py39-devel \
 "
RDEPENDS:rust-pyo3+abi3t-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3t-devel \
 "
RDEPENDS:rust-pyo3+abi3t-py315-devel = " \
 cargo \
 rust-pyo3+abi3t-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3t-py315-devel \
 "
RDEPENDS:rust-pyo3+anyhow-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+arc_lock-devel = " \
 cargo \
 rust-lock_api+arc_lock-devel \
 rust-lock_api+default-devel \
 rust-parking_lot+arc_lock-devel \
 rust-parking_lot+default-devel \
 rust-pyo3+lock_api-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+auto-initialize-devel = " \
 cargo \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+bigdecimal-devel = " \
 cargo \
 rust-bigdecimal+default-devel \
 rust-pyo3+num-bigint-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+chrono-local-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-iana-time-zone+default-devel \
 rust-iana-time-zone+fallback-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+default-devel = " \
 cargo \
 rust-pyo3+macros-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+either-devel = " \
 cargo \
 rust-either+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+experimental-async-devel = " \
 cargo \
 rust-pyo3+macros-devel \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+experimental-async-devel \
 "
RDEPENDS:rust-pyo3+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+experimental-inspect-devel \
 "
RDEPENDS:rust-pyo3+extension-module-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-ffi+extension-module-devel \
 "
RDEPENDS:rust-pyo3+eyre-devel = " \
 cargo \
 rust-eyre+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+full-devel = " \
 cargo \
 rust-pyo3+anyhow-devel \
 rust-pyo3+arc_lock-devel \
 rust-pyo3+bigdecimal-devel \
 rust-pyo3+bytes-devel \
 rust-pyo3+chrono-devel \
 rust-pyo3+chrono-local-devel \
 rust-pyo3+chrono-tz-devel \
 rust-pyo3+either-devel \
 rust-pyo3+experimental-async-devel \
 rust-pyo3+experimental-inspect-devel \
 rust-pyo3+eyre-devel \
 rust-pyo3+hashbrown-devel \
 rust-pyo3+indexmap-devel \
 rust-pyo3+jiff-02-devel \
 rust-pyo3+lock_api-devel \
 rust-pyo3+macros-devel \
 rust-pyo3+num-bigint-devel \
 rust-pyo3+num-complex-devel \
 rust-pyo3+num-rational-devel \
 rust-pyo3+ordered-float-devel \
 rust-pyo3+parking_lot-devel \
 rust-pyo3+py-clone-devel \
 rust-pyo3+rust_decimal-devel \
 rust-pyo3+serde-devel \
 rust-pyo3+smallvec-devel \
 rust-pyo3+time-devel \
 rust-pyo3+uuid-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+hashbrown-devel = " \
 cargo \
 rust-pyo3-devel \
 virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~ \
 virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~ \
 "
RDEPENDS:rust-pyo3+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+inventory-devel = " \
 cargo \
 rust-inventory+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+jiff-02-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+lock_api-devel = " \
 cargo \
 rust-lock_api+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+macros-devel = " \
 cargo \
 rust-pyo3+pyo3-macros-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3+inventory-devel \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+multiple-pymethods-devel \
 "
RDEPENDS:rust-pyo3+nightly-devel = " \
 cargo \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-num-traits+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+num-complex-devel = " \
 cargo \
 rust-num-complex+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+num-rational-devel = " \
 cargo \
 rust-num-rational+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+ordered-float-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-pyo3+lock_api-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+py-clone-devel = " \
 cargo \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+pyo3-macros-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 "
RDEPENDS:rust-pyo3+rust_decimal-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-pyo3+serde-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-pyo3+smallvec-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-pyo3+time-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-time-devel \
 "
RDEPENDS:rust-pyo3+uuid-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-pyo3-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-ffi+default-devel \
 "
