# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tikv-jemallocator"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tikv-jemallocator+alloc_trait-devel \
 rust-tikv-jemallocator+background_threads_runtime_support-devel \
 rust-tikv-jemallocator+default-devel \
 rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel \
 rust-tikv-jemallocator+profiling-devel \
 rust-tikv-jemallocator+stats-devel \
 rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemallocator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tikv-jemallocator-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6951817736fdd3ca997edf813a3260f767a3f6ae5eb69071143baf4d9f90fa19"

URI_x86_64_v2_rust-tikv-jemallocator+alloc_trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+alloc_trait-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+alloc_trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+alloc_trait-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+alloc_trait-devel.sha256sum] = "41e12933250dca545f56301ac55bfabdf8540acbf71858dc08141aa240ee2108"

URI_x86_64_v2_rust-tikv-jemallocator+background_threads_runtime_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+background_threads_runtime_support-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+background_threads_runtime_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+background_threads_runtime_support-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+background_threads_runtime_support-devel.sha256sum] = "3b817333a85b8ad05e1594ec895278adc80de3d8d0dffa68b258127b0e5fddab"

URI_x86_64_v2_rust-tikv-jemallocator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+default-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+default-devel.sha256sum] = "c7460e350251cec0b38b0b6526290a53c9d16785552937e6c55352e06a96e66e"

URI_x86_64_v2_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel.sha256sum] = "a3ae91472e16d696019c989780bf8c5b12326caf93a057eeb3c136309f63771c"

URI_x86_64_v2_rust-tikv-jemallocator+profiling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+profiling-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+profiling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+profiling-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+profiling-devel.sha256sum] = "6814a8927f4b6a2edf42f2d470c18636d57e51ebbf75ec74c36a261b9ad1c9fe"

URI_x86_64_v2_rust-tikv-jemallocator+stats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+stats-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+stats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+stats-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+stats-devel.sha256sum] = "846d72d15e6f42e726d84cfcd6838dcba06914d192f946b315b30d7e4f436611"

URI_x86_64_v2_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel.sha256sum] = "61b84a95b357853b68b30c07192e97e2a0200ba336f239d5afe0d26fed58337f"

URI_x86_64_v2_rust-tikv-jemallocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator-devel.sha256sum] = "080c7b59002addd42a0786011fda00107abc49fb1662283ffcd9daaf6e6b8be9"

URI_aarch64_rust-tikv-jemallocator+alloc_trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+alloc_trait-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemallocator+alloc_trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+alloc_trait-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+alloc_trait-devel.sha256sum] = "ad1a4a398ca5d8871e92eedb5b8ac749755958e503b1bf5a09fa57ee336044d1"

URI_aarch64_rust-tikv-jemallocator+background_threads_runtime_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+background_threads_runtime_support-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemallocator+background_threads_runtime_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+background_threads_runtime_support-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+background_threads_runtime_support-devel.sha256sum] = "f651bea755ddb8c796ff4e0626db8e10484d9987ee7606ce9b8792999886a817"

URI_aarch64_rust-tikv-jemallocator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemallocator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+default-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+default-devel.sha256sum] = "144611dcfbb19dfdf06c6493fab440e82ac698d2e446fe901a6460f5f61771e6"

URI_aarch64_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel.sha256sum] = "6b2ded27034efe93b39a1b616cbccf3ac2d2bcedd265f231d58676fefb0f17c6"

URI_aarch64_rust-tikv-jemallocator+profiling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+profiling-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemallocator+profiling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+profiling-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+profiling-devel.sha256sum] = "2baa6b83429e7746ac5882ace58e98af6713aeb85fb0ff9ff71246ba7227a3cd"

URI_aarch64_rust-tikv-jemallocator+stats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+stats-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemallocator+stats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+stats-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+stats-devel.sha256sum] = "b232d481773bc40ba8ab983f532784a7d6c2a7c83e12525ae1d0ae308fd452a2"

URI_aarch64_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel.sha256sum] = "d354b81f86164ad69051a97e493f16606e423d75602167eec070d600c9dc2b21"

URI_aarch64_rust-tikv-jemallocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemallocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator-devel.sha256sum] = "2c1d6c70b47f9312a30c85f6143c139cd72e093197e9c48d631cbb513df1e9e1"

RDEPENDS:rust-tikv-jemallocator+alloc_trait-devel = " \
 cargo \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+background_threads_runtime_support-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+background_threads_runtime_support-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+default-devel = " \
 cargo \
 rust-tikv-jemallocator+background_threads_runtime_support-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel \
 rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+profiling-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+profiling-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+stats-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+stats-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator-devel = " \
 cargo \
 rust-libc-devel \
 rust-tikv-jemalloc-sys-devel \
 "
