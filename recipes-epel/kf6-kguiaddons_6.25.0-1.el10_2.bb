# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kguiaddons"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kguiaddons \
 kf6-kguiaddons-devel \
 kf6-kguiaddons-doc \
 kf6-kguiaddons-html \
 python3-kf6-kguiaddons \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kguiaddons-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dffc9d1850b065becbed4ba96ff7801e1f02db2d80b77dc1b7e5badfb47f53c7"

URI_x86_64_v2_kf6-kguiaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kguiaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kguiaddons}"
SRC_URI[x86_64_v2_kf6-kguiaddons.sha256sum] = "9ff6f59ca9279864cfb2e541fd089ac9a1ffc07796c6875edcf3a9ea0542c04a"

URI_x86_64_v2_kf6-kguiaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kguiaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kguiaddons-devel}"
SRC_URI[x86_64_v2_kf6-kguiaddons-devel.sha256sum] = "55bab9db609695253379870885e19625d034c1c0699dff3a7083178b7a4a58cc"

URI_x86_64_v2_kf6-kguiaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kguiaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kguiaddons-doc}"
SRC_URI[x86_64_v2_kf6-kguiaddons-doc.sha256sum] = "3cdeba74f87e7744cba54bd359026f9b480403d823c659952203e4c2235f335a"

URI_x86_64_v2_kf6-kguiaddons-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kguiaddons-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kguiaddons-html}"
SRC_URI[x86_64_v2_kf6-kguiaddons-html.sha256sum] = "4dcf11b140b9a1f4717328dcabbfd7f611ea22e33bbe7bfa0ef8c1506691b750"

URI_x86_64_v2_python3-kf6-kguiaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kguiaddons-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kguiaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kguiaddons}"
SRC_URI[x86_64_v2_python3-kf6-kguiaddons.sha256sum] = "ca25e0d865c9624d42dbb1c797800a94b42414c8a4d4da1ee38d518f37942996"

URI_aarch64_kf6-kguiaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kguiaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kguiaddons}"
SRC_URI[aarch64_kf6-kguiaddons.sha256sum] = "ec5d1fe3c97524585f3c4829c0358afb41fb46623f54dddd0978d57264ce1f4c"

URI_aarch64_kf6-kguiaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kguiaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kguiaddons-devel}"
SRC_URI[aarch64_kf6-kguiaddons-devel.sha256sum] = "9a674f8d9596d76d7fd907ed12a734fb9853c2638325d4e3f73614ab52640f68"

URI_aarch64_kf6-kguiaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kguiaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kguiaddons-doc}"
SRC_URI[aarch64_kf6-kguiaddons-doc.sha256sum] = "d5b6a7778573802bc789dc9d2e3f0acf90a0683bbdfdfc09d318ee81a0eea079"

URI_aarch64_kf6-kguiaddons-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kguiaddons-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kguiaddons-html}"
SRC_URI[aarch64_kf6-kguiaddons-html.sha256sum] = "464ca3e899e17b48c580bab56e4bf35eb42079c704e5f20a7fb86172e1e4e3af"

URI_aarch64_python3-kf6-kguiaddons = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kguiaddons-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_python3-kf6-kguiaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kguiaddons}"
SRC_URI[aarch64_python3-kf6-kguiaddons.sha256sum] = "4dce9b91df1fafc7dd326a99677526578c3d305c25ec9e82bc9f55b3b6478565"

RDEPENDS:kf6-kguiaddons = " \
 glibc \
 kf6-filesystem \
 libX11 \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kguiaddons-devel = " \
 cmake-filesystem \
 kf6-kguiaddons \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kguiaddons-doc = " \
 "
RDEPENDS:kf6-kguiaddons-html = " \
 "
RDEPENDS:python3-kf6-kguiaddons = " \
 glibc \
 kf6-kguiaddons \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
