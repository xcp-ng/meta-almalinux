# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-th"
PV = "0.20061212"
PR = "34.el10"
PACKAGES = " \
 hunspell-th \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-th-0.20061212-34.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "55a67cef6e78505f6b9454c86aa21e382d63bebf7c4ad76d11c20a89c802ab39"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-th-0.20061212-34.el10.noarch.rpm;name=x86_64_v2_hunspell-th;unpack=0"
SRC_URI[x86_64_v2_hunspell-th.sha256sum] = "5b56d4dd6a795f337425003e40d63c5ce3316628ccdd9e818d26f52631414f2e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-th-0.20061212-34.el10.noarch.rpm;name=aarch64_hunspell-th;unpack=0"
SRC_URI[aarch64_hunspell-th.sha256sum] = "5b56d4dd6a795f337425003e40d63c5ce3316628ccdd9e818d26f52631414f2e"

RDEPENDS:hunspell-th = " \
 hunspell-filesystem \
 "
