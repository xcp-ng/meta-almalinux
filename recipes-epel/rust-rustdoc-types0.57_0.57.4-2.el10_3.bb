# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustdoc-types0.57"
PV = "0.57.4"
PR = "2.el10_3"
PACKAGES = " \
 rust-rustdoc-types0.57+default-devel \
 rust-rustdoc-types0.57+rkyv_0_8-devel \
 rust-rustdoc-types0.57+rustc-hash-devel \
 rust-rustdoc-types0.57-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rustdoc-types0.57-0.57.4-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a9ea91546454f70a760f6f846f55fcaf76abb49bcbb7fecc86208e904d4d944d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdoc-types0.57+default-devel-0.57.4-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdoc-types0.57+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustdoc-types0.57+default-devel.sha256sum] = "5cfe7f55d754d6eb3dc4f424d2332350ffaa15ca37be788b80371abaa1321365"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdoc-types0.57+rkyv_0_8-devel-0.57.4-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdoc-types0.57+rkyv_0_8-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustdoc-types0.57+rkyv_0_8-devel.sha256sum] = "f3dce0e30e54b67591c8b42570f2ed7ed1a1cef27e603384375adff4eafd820a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdoc-types0.57+rustc-hash-devel-0.57.4-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdoc-types0.57+rustc-hash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustdoc-types0.57+rustc-hash-devel.sha256sum] = "d72851cd78896aafaffbd2c1d2b48318ab269cd805a9f1b126079ab7f7f7f884"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdoc-types0.57-devel-0.57.4-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdoc-types0.57-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustdoc-types0.57-devel.sha256sum] = "15621ac543c677f81838044ba7aad48ffc4fe5b5d10ff1e46ece6e4c4e0a93c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdoc-types0.57+default-devel-0.57.4-2.el10_3.noarch.rpm;name=aarch64_rust-rustdoc-types0.57+default-devel;unpack=0"
SRC_URI[aarch64_rust-rustdoc-types0.57+default-devel.sha256sum] = "fde27f25f865b016b64bd25fec2511f80c01649bea87efce7cc81502ee7cc1a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdoc-types0.57+rkyv_0_8-devel-0.57.4-2.el10_3.noarch.rpm;name=aarch64_rust-rustdoc-types0.57+rkyv_0_8-devel;unpack=0"
SRC_URI[aarch64_rust-rustdoc-types0.57+rkyv_0_8-devel.sha256sum] = "17ff0782a81c351715823035f633a8f141002b4d0b740f874448114734576173"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdoc-types0.57+rustc-hash-devel-0.57.4-2.el10_3.noarch.rpm;name=aarch64_rust-rustdoc-types0.57+rustc-hash-devel;unpack=0"
SRC_URI[aarch64_rust-rustdoc-types0.57+rustc-hash-devel.sha256sum] = "20650aa3d44c032dfd35272f68b62952471daa0545b22b1b60cdb5098c67b9c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdoc-types0.57-devel-0.57.4-2.el10_3.noarch.rpm;name=aarch64_rust-rustdoc-types0.57-devel;unpack=0"
SRC_URI[aarch64_rust-rustdoc-types0.57-devel.sha256sum] = "32d4c94cfa05b197a7a5c351fd600bc8137e012c1da7925fe4228207eaa471e5"

RDEPENDS:rust-rustdoc-types0.57+default-devel = " \
 cargo \
 rust-rustdoc-types0.57-devel \
 "
RDEPENDS:rust-rustdoc-types0.57+rkyv_0_8-devel = " \
 cargo \
 rust-rkyv+default-devel \
 rust-rustdoc-types0.57-devel \
 "
RDEPENDS:rust-rustdoc-types0.57+rustc-hash-devel = " \
 cargo \
 rust-rustc-hash+default-devel \
 rust-rustdoc-types0.57-devel \
 "
RDEPENDS:rust-rustdoc-types0.57-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 "
