# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-text-short"
PV = "0.1.6"
PR = "1.el10_0"
PACKAGES = " \
 ghc-text-short \
 ghc-text-short-devel \
 ghc-text-short-doc \
 ghc-text-short-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-text-short-0.1.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e96264c56b8fcac5e6092cf1af35faf56c48b47e7151e3dbca50d91a7f516df4"

URI_x86_64_v2_ghc-text-short = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-short-0.1.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-short;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-short}"
SRC_URI[x86_64_v2_ghc-text-short.sha256sum] = "cb6e77201937d38a4cc4b4079cf1a16fc04a2cdd0f41e64771d2af1d7a43644e"

URI_x86_64_v2_ghc-text-short-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-short-devel-0.1.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-short-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-short-devel}"
SRC_URI[x86_64_v2_ghc-text-short-devel.sha256sum] = "34c500db28600d57d3407e735865fec47b1c6455efef2726de7537eb23be0746"

URI_x86_64_v2_ghc-text-short-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-short-doc-0.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-text-short-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-short-doc}"
SRC_URI[x86_64_v2_ghc-text-short-doc.sha256sum] = "c03587bcacf8674af183c028f1ca2eb78f5575b463928e81f9e60004991e1946"

URI_x86_64_v2_ghc-text-short-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-short-prof-0.1.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-short-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-short-prof}"
SRC_URI[x86_64_v2_ghc-text-short-prof.sha256sum] = "c43b54d55d18121cc9ba1110d0d358de239233a3a3b4c2034bb940f28874db69"

URI_aarch64_ghc-text-short = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-short-0.1.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-text-short;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-short}"
SRC_URI[aarch64_ghc-text-short.sha256sum] = "c637740610547fbaa378cac2a647c873e0ad60f5a716d11614eb7331a1f56733"

URI_aarch64_ghc-text-short-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-short-devel-0.1.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-text-short-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-short-devel}"
SRC_URI[aarch64_ghc-text-short-devel.sha256sum] = "529ca18e800ee64bc2fa1dfa836a88a511c5b95b206fe8ce8ead93277c80b93d"

URI_aarch64_ghc-text-short-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-short-doc-0.1.6-1.el10_0.noarch.rpm;name=aarch64_ghc-text-short-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-short-doc}"
SRC_URI[aarch64_ghc-text-short-doc.sha256sum] = "a55ff1c9e851cfcf5529c16d5abc7aec12cc3cfae82df2703775ccff5c04151c"

URI_aarch64_ghc-text-short-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-short-prof-0.1.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-text-short-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-short-prof}"
SRC_URI[aarch64_ghc-text-short-prof.sha256sum] = "c1cbacec37c60036b964b8682271a67139f7e3e6ea29c2d93057829d4b79091c"

RDEPENDS:ghc-text-short = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-text-short-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-hashable-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-text-short \
 "
RDEPENDS:ghc-text-short-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-text-short-prof = " \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-hashable-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-text-short-devel \
 "
