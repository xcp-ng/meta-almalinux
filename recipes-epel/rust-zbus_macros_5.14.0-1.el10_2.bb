# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zbus_macros"
PV = "5.14.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-zbus_macros+blocking-api-devel \
 rust-zbus_macros+default-devel \
 rust-zbus_macros+gvariant-devel \
 rust-zbus_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zbus_macros-5.14.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6df954f1e48dc942daa2facabd23ab5b19b5fed493b3901bbf4f8ac73a0f91e1"

URI_x86_64_v2_rust-zbus_macros+blocking-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_macros+blocking-api-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_macros+blocking-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_macros+blocking-api-devel}"
SRC_URI[x86_64_v2_rust-zbus_macros+blocking-api-devel.sha256sum] = "ddd9d91e3d9a9bf1fb8427c11c1f4972629be4d8f6a452a27f302d80de874326"

URI_x86_64_v2_rust-zbus_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_macros+default-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_macros+default-devel}"
SRC_URI[x86_64_v2_rust-zbus_macros+default-devel.sha256sum] = "c2545fbcd594f19b37ef14de4a9ca3bc614f96511344233b1b94610762017e92"

URI_x86_64_v2_rust-zbus_macros+gvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_macros+gvariant-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_macros+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_macros+gvariant-devel}"
SRC_URI[x86_64_v2_rust-zbus_macros+gvariant-devel.sha256sum] = "d1444399f9bc3758f392e2105c7e84e594b54539969e22b8ba95395acf5bc493"

URI_x86_64_v2_rust-zbus_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_macros-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_macros-devel}"
SRC_URI[x86_64_v2_rust-zbus_macros-devel.sha256sum] = "505f742c3b59cf6651095f0fdce701d7c03303feca573ec52b655ae24e784e43"

URI_aarch64_rust-zbus_macros+blocking-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_macros+blocking-api-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus_macros+blocking-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_macros+blocking-api-devel}"
SRC_URI[aarch64_rust-zbus_macros+blocking-api-devel.sha256sum] = "f70db3e38aa936cd67fa1a39b6636f6aee2e3b573d8e28d0efe7baaa18c1da2d"

URI_aarch64_rust-zbus_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_macros+default-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_macros+default-devel}"
SRC_URI[aarch64_rust-zbus_macros+default-devel.sha256sum] = "15b0e39b1fb7750d29bc9c7c491f9fe2b436599fba90c2d0f4d1eb39e5c67aec"

URI_aarch64_rust-zbus_macros+gvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_macros+gvariant-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus_macros+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_macros+gvariant-devel}"
SRC_URI[aarch64_rust-zbus_macros+gvariant-devel.sha256sum] = "1b50b0102d2b020051af08d9d1a158875924480fc502a1d387e6dc685b59f7f8"

URI_aarch64_rust-zbus_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_macros-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_macros-devel}"
SRC_URI[aarch64_rust-zbus_macros-devel.sha256sum] = "f9ccb9e5614e9936df9aa354ee3ec6a5b1d5504727b6c577cba5e44e8b23c26e"

RDEPENDS:rust-zbus_macros+blocking-api-devel = " \
 cargo \
 rust-zbus_macros-devel \
 "
RDEPENDS:rust-zbus_macros+default-devel = " \
 cargo \
 rust-zbus_macros-devel \
 "
RDEPENDS:rust-zbus_macros+gvariant-devel = " \
 cargo \
 rust-zbus_macros-devel \
 rust-zvariant+gvariant-devel \
 rust-zvariant_utils+gvariant-devel \
 "
RDEPENDS:rust-zbus_macros-devel = " \
 cargo \
 rust \
 rust-proc-macro-crate+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 rust-zbus_names+default-devel \
 rust-zvariant+default-devel \
 rust-zvariant_utils+default-devel \
 "
