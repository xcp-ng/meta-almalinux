# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmodulemd"
PV = "2.15.0"
PR = "12.el10"
PACKAGES = " \
 libmodulemd \
 libmodulemd-devel \
 python3-libmodulemd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libmodulemd-2.15.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6224c6986c63f30e51a3385eff748f1758e422915d37d924e0dd0b61f2ede595"

URI_x86_64_v2_libmodulemd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libmodulemd-2.15.0-12.el10.x86_64_v2.rpm;name=x86_64_v2_libmodulemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmodulemd}"
SRC_URI[x86_64_v2_libmodulemd.sha256sum] = "b456e569d04cf4352bf04cd32e5fb51b33f879a540b2dd312d61bc6c73a00f41"

URI_x86_64_v2_libmodulemd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libmodulemd-devel-2.15.0-12.el10.x86_64_v2.rpm;name=x86_64_v2_libmodulemd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmodulemd-devel}"
SRC_URI[x86_64_v2_libmodulemd-devel.sha256sum] = "6bb07e15095906dc7a0f462cbbff3d61f9666f4c85deeeabd00864f4f06aa3c0"

URI_x86_64_v2_python3-libmodulemd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libmodulemd-2.15.0-12.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libmodulemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libmodulemd}"
SRC_URI[x86_64_v2_python3-libmodulemd.sha256sum] = "21d10476473070cd50c0fc64f0b91813e9c440e248ab5371708a5ae0cfb7217e"

URI_aarch64_libmodulemd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libmodulemd-2.15.0-12.el10.aarch64.rpm;name=aarch64_libmodulemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmodulemd}"
SRC_URI[aarch64_libmodulemd.sha256sum] = "edc244d9b69ab0442686f09da06ad2646d4b01ce249a52bba4c98459bfbbb0db"

URI_aarch64_libmodulemd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libmodulemd-devel-2.15.0-12.el10.aarch64.rpm;name=aarch64_libmodulemd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmodulemd-devel}"
SRC_URI[aarch64_libmodulemd-devel.sha256sum] = "f671e7173e5ff48de696b54359cbf0bf39b0e5795ab2f945ab66e086b0eb83e5"

URI_aarch64_python3-libmodulemd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libmodulemd-2.15.0-12.el10.aarch64.rpm;name=aarch64_python3-libmodulemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libmodulemd}"
SRC_URI[aarch64_python3-libmodulemd.sha256sum] = "6a20fd9ed2c79656476083cef166496fcd0f429c4c92187d0635fde482707448"

RDEPENDS:libmodulemd = " \
 glib2 \
 glibc \
 libgcc \
 libyaml \
 rpm-libs \
 "
RDEPENDS:libmodulemd-devel = " \
 glib2-devel \
 libmodulemd \
 libyaml-devel \
 pkgconf-pkg-config \
 rpm-devel \
 "
RDEPENDS:python3-libmodulemd = " \
 libmodulemd \
 python3 \
 python3-gobject-base \
 python3-six \
 "
