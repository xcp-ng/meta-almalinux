# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-csv-core"
PV = "0.1.13"
PR = "1.el10_1"
PACKAGES = " \
 rust-csv-core+default-devel \
 rust-csv-core+libc-devel \
 rust-csv-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-csv-core-0.1.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91982edc5fc9104a3adea688c7ad850f740b73bd153c7f04aaac6560d9b5ead9"

URI_x86_64_v2_rust-csv-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv-core+default-devel-0.1.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv-core+default-devel}"
SRC_URI[x86_64_v2_rust-csv-core+default-devel.sha256sum] = "704a179be5d77e0ce63c4a3dbf4381c7231d2b391a2a96d47bd4821f23de1bc6"

URI_x86_64_v2_rust-csv-core+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv-core+libc-devel-0.1.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv-core+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv-core+libc-devel}"
SRC_URI[x86_64_v2_rust-csv-core+libc-devel.sha256sum] = "dac4ef2e079d9a6c44746381ff379e5bf4a63e1aa4d38b510087fcfa2e3f8015"

URI_x86_64_v2_rust-csv-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv-core-devel-0.1.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv-core-devel}"
SRC_URI[x86_64_v2_rust-csv-core-devel.sha256sum] = "266f437f40bf0a7b110ef51985afc86d9716549a4720fbc7bdadb24859adfc24"

URI_aarch64_rust-csv-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv-core+default-devel-0.1.13-1.el10_1.noarch.rpm;name=aarch64_rust-csv-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv-core+default-devel}"
SRC_URI[aarch64_rust-csv-core+default-devel.sha256sum] = "5d7a84a10e9e436c79bb8f0df24cc160e371e818a033de5067ef90d2d1796ff5"

URI_aarch64_rust-csv-core+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv-core+libc-devel-0.1.13-1.el10_1.noarch.rpm;name=aarch64_rust-csv-core+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv-core+libc-devel}"
SRC_URI[aarch64_rust-csv-core+libc-devel.sha256sum] = "e42436e1f7636eb522927da41a87102b124ad1d01fa5dfa65eed7ab16d421602"

URI_aarch64_rust-csv-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv-core-devel-0.1.13-1.el10_1.noarch.rpm;name=aarch64_rust-csv-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv-core-devel}"
SRC_URI[aarch64_rust-csv-core-devel.sha256sum] = "ac44de2ef92c2b5cf4b8892e99fe4f48fb51ec1d808aec395554b7217f18e144"

RDEPENDS:rust-csv-core+default-devel = " \
 cargo \
 rust-csv-core-devel \
 "
RDEPENDS:rust-csv-core+libc-devel = " \
 cargo \
 rust-csv-core-devel \
 rust-memchr+libc-devel \
 "
RDEPENDS:rust-csv-core-devel = " \
 cargo \
 rust-memchr-devel \
 "
