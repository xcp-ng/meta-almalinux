# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral-tl"
PV = "0.7.11"
PR = "3.el10_2"
PACKAGES = " \
 rust-astral-tl+default-devel \
 rust-astral-tl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-astral-tl-0.7.11-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e19141c0d9384592aa7bfdbeafadeeae3debfea43e9ba4f1525f3b2e456ee7e9"

URI_x86_64_v2_rust-astral-tl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-tl+default-devel-0.7.11-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-tl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-tl+default-devel}"
SRC_URI[x86_64_v2_rust-astral-tl+default-devel.sha256sum] = "0e184dea00a1548f3ec99cefb24a1d7bce84e11e5d159ce5b1b6c86aafed82ee"

URI_x86_64_v2_rust-astral-tl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-tl-devel-0.7.11-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-tl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-tl-devel}"
SRC_URI[x86_64_v2_rust-astral-tl-devel.sha256sum] = "00e01ce9e09bc8e5b482ebe3f0ae0acbc92bc1f4312dec86334b3e8d3a8760bd"

URI_aarch64_rust-astral-tl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-tl+default-devel-0.7.11-3.el10_2.noarch.rpm;name=aarch64_rust-astral-tl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-tl+default-devel}"
SRC_URI[aarch64_rust-astral-tl+default-devel.sha256sum] = "c1486e2a3b81aebb1600875e4f3c84fb28a49e8a5fef571a54a0cc8575700a35"

URI_aarch64_rust-astral-tl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-tl-devel-0.7.11-3.el10_2.noarch.rpm;name=aarch64_rust-astral-tl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-tl-devel}"
SRC_URI[aarch64_rust-astral-tl-devel.sha256sum] = "fd71ccb82c00c9e686038adbce3befdae8f32278dcb79d626f3a40e1da08d896"

RDEPENDS:rust-astral-tl+default-devel = " \
 cargo \
 rust-astral-tl-devel \
 "
RDEPENDS:rust-astral-tl-devel = " \
 cargo \
 rust-memchr+default-devel \
 "
