# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "weldr-client"
PV = "35.11"
PR = "4.el10.0.1"
PACKAGES = " \
 weldr-client \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/weldr-client-35.11-4.el10.0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c3927d805a5c1ee877301a3c35cbc8cadf6e0649218beee80ad470ae6fc7592"

URI_x86_64_v2_weldr-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/weldr-client-35.11-4.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_weldr-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weldr-client}"
SRC_URI[x86_64_v2_weldr-client.sha256sum] = "46b6f6fb6555df46d5e7882090f960736e683536636f36fa53a85f7787572fa1"

URI_aarch64_weldr-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/weldr-client-35.11-4.el10.0.1.aarch64.rpm;name=aarch64_weldr-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_weldr-client}"
SRC_URI[aarch64_weldr-client.sha256sum] = "a6dd949265e28e4cc0e256255898250af728bf73c33c054777d623d88b50c196"

RDEPENDS:weldr-client = " \
 diffutils \
 glibc \
 "
