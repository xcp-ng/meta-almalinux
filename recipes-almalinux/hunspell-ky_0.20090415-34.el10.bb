# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ky"
PV = "0.20090415"
PR = "34.el10"
PACKAGES = " \
 hunspell-ky \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ky-0.20090415-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74c75d577e8acc9440406129356083d7a4f458ce5d8e7214318b6238940ac03f"

URI_x86_64_v2_hunspell-ky = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ky-0.20090415-34.el10.noarch.rpm;name=x86_64_v2_hunspell-ky;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-ky}"
SRC_URI[x86_64_v2_hunspell-ky.sha256sum] = "c9ec0dba383fe2b30133745ebf869525f041584e2f3e8ccced3423f0b5d16e3d"

URI_aarch64_hunspell-ky = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ky-0.20090415-34.el10.noarch.rpm;name=aarch64_hunspell-ky;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-ky}"
SRC_URI[aarch64_hunspell-ky.sha256sum] = "c9ec0dba383fe2b30133745ebf869525f041584e2f3e8ccced3423f0b5d16e3d"

RDEPENDS:hunspell-ky = " \
 hunspell-filesystem \
 "
