# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro-crate"
PV = "3.5.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-proc-macro-crate+default-devel \
 rust-proc-macro-crate-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro-crate-3.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ec8fda05e2a1a8b7c3097538946e2446c5631a0fef209d391f25c81faf29190e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-crate+default-devel-3.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-crate+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro-crate+default-devel.sha256sum] = "3dd49e4ac4a30b3fb3f9b47f13bccc1117dbaf9c5523337d62e86f7a6fa3dfd8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-crate-devel-3.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-crate-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro-crate-devel.sha256sum] = "ced1f00ac6cbc80fa5332376532000cd368d2650e788b5b8e04097cd9dfd5a0d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-crate+default-devel-3.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-crate+default-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro-crate+default-devel.sha256sum] = "70668305c6275767c5689c7a92d3f40a717049c960b5d58eef35417cb3f1ef66"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-crate-devel-3.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-crate-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro-crate-devel.sha256sum] = "5fa324a367c93fc6e0f3850f2eae49441de382c51604da65111eefe78f908ffc"

RDEPENDS:rust-proc-macro-crate+default-devel = " \
 cargo \
 rust-proc-macro-crate-devel \
 "
RDEPENDS:rust-proc-macro-crate-devel = " \
 cargo \
 rust \
 rust-toml_edit+parse-devel \
 rust-toml_edit-devel \
 "
