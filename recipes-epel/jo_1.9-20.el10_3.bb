# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jo"
PV = "1.9"
PR = "20.el10_3"
PACKAGES = " \
 jo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jo-1.9-20.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef462526195aebf639ef6b08cc34427801eba1cd0c4c9680783398e3d31dca8d"

URI_x86_64_v2_jo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jo-1.9-20.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jo}"
SRC_URI[x86_64_v2_jo.sha256sum] = "1989afbc6506a191038d41f88e0f11f7e4988c9f99a9c772e18616ec6dcb41f9"

URI_aarch64_jo = "${EPEL_MIRROR}/aarch64/Packages/j/jo-1.9-20.el10_3.aarch64.rpm;name=aarch64_jo;unpack=0"
SRC_URI:append = " ${URI_aarch64_jo}"
SRC_URI[aarch64_jo.sha256sum] = "261d8f0219028c295ba53fe8bc38602cabc586f10869e0365c653a47bbed0c08"

RDEPENDS:jo = " \
 glibc \
 "
