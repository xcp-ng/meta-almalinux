# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipython"
PV = "8.32.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-ipython \
 python3-ipython-sphinx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ipython-8.32.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "267e063373506beaefb98e14687c6c9b057216c69621eabf859d25e076edb349"

URI_x86_64_v2_python3-ipython = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipython-8.32.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipython;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipython}"
SRC_URI[x86_64_v2_python3-ipython.sha256sum] = "5d5067d461f286a7ee2f344d1e79ea2ee31f26f1b7e6cd6e128d3acad8cc6467"

URI_x86_64_v2_python3-ipython-sphinx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipython-sphinx-8.32.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipython-sphinx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipython-sphinx}"
SRC_URI[x86_64_v2_python3-ipython-sphinx.sha256sum] = "8172749ec5a1222702418b5bc591958aba4d2ca7dd08ecbb77c1d66a9c0c3069"

URI_aarch64_python3-ipython = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipython-8.32.0-2.el10_0.noarch.rpm;name=aarch64_python3-ipython;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipython}"
SRC_URI[aarch64_python3-ipython.sha256sum] = "b525197399b6b04661bf274994658fd83968286b9c1baf50aac9caa961f8345e"

URI_aarch64_python3-ipython-sphinx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipython-sphinx-8.32.0-2.el10_0.noarch.rpm;name=aarch64_python3-ipython-sphinx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipython-sphinx}"
SRC_URI[aarch64_python3-ipython-sphinx.sha256sum] = "b366a4ad77cc6feaf7d2eb8e8cac09ad0725756971b0f572dab38a0c5aae7897"

RDEPENDS:python3-ipython = " \
 python3 \
 python3-decorator \
 python3-jedi \
 python3-matplotlib-inline \
 python3-pexpect \
 python3-prompt-toolkit \
 python3-pygments \
 python3-stack-data \
 python3-traitlets \
 texlive-amscls \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-tools \
 "
RDEPENDS:python3-ipython-sphinx = " \
 python3 \
 python3-ipython \
 python3-sphinx \
 "
