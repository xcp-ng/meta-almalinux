# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librttopo"
PV = "1.1.0"
PR = "18.el10_1"
PACKAGES = " \
 librttopo \
 librttopo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/librttopo-1.1.0-18.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b1483f639c78058bbd028607d4c761fbbf2acb114fcb4f4d547487cb2a3effa"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - librttopo: libgeos_c.so.1()(64bit)

URI_x86_64_v2_librttopo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librttopo-1.1.0-18.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librttopo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librttopo}"
SRC_URI[x86_64_v2_librttopo.sha256sum] = "63c8447ee9f9c49e4a1207d0f2ca0d7fe630ad90cab2a8770cd1118aecc9b8ae"

URI_x86_64_v2_librttopo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librttopo-devel-1.1.0-18.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librttopo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librttopo-devel}"
SRC_URI[x86_64_v2_librttopo-devel.sha256sum] = "e54ea76df6766729dd1b510ad6cf238bd9b6a8a419f0337854c5c603c356a01b"

URI_aarch64_librttopo = "${EPEL_MIRROR}/aarch64/Packages/l/librttopo-1.1.0-18.el10_1.aarch64.rpm;name=aarch64_librttopo;unpack=0"
SRC_URI:append = " ${URI_aarch64_librttopo}"
SRC_URI[aarch64_librttopo.sha256sum] = "831595db1ffd2f902a9a1b6ab46ad0a8d6da7f9dc2e056b7d5424d22e2e9f5f5"

URI_aarch64_librttopo-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librttopo-devel-1.1.0-18.el10_1.aarch64.rpm;name=aarch64_librttopo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librttopo-devel}"
SRC_URI[aarch64_librttopo-devel.sha256sum] = "1aaea61e652dbf0f891abd94acc8bcba85e53395257379b0df5b3c7fd43431f0"

RDEPENDS:librttopo:x86_64_v2 = " \
 glibc \
"
RDEPENDS:librttopo:aarch64 = " \
 geos \
 glibc \
"
RDEPENDS:librttopo-devel = " \
 librttopo \
 pkgconf-pkg-config \
 "
