# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Tk-Getopt"
PV = "0.52"
PR = "1.el10_0"
PACKAGES = " \
 perl-Tk-Getopt \
 perl-Tk-Getopt-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Tk-Getopt-0.52-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d33343a6e86523b0cf0b8a2ecec89aa61d262ae347cda74ce84305f70e915b5"

URI_x86_64_v2_perl-Tk-Getopt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tk-Getopt-0.52-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tk-Getopt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tk-Getopt}"
SRC_URI[x86_64_v2_perl-Tk-Getopt.sha256sum] = "9662db882b163655fc5150e32d1dc7acbe4631c76968fa29fbd79f3538d367b5"

URI_x86_64_v2_perl-Tk-Getopt-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tk-Getopt-tests-0.52-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tk-Getopt-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tk-Getopt-tests}"
SRC_URI[x86_64_v2_perl-Tk-Getopt-tests.sha256sum] = "d87a09855928bc69f342a1ab8cf57475d77db8ac1289c77825196b67d479ef62"

URI_aarch64_perl-Tk-Getopt = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tk-Getopt-0.52-1.el10_0.noarch.rpm;name=aarch64_perl-Tk-Getopt;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tk-Getopt}"
SRC_URI[aarch64_perl-Tk-Getopt.sha256sum] = "981401568831c210bd6aed78b56af232b6d4ca9023d8375866e4988be092ea8c"

URI_aarch64_perl-Tk-Getopt-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tk-Getopt-tests-0.52-1.el10_0.noarch.rpm;name=aarch64_perl-Tk-Getopt-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tk-Getopt-tests}"
SRC_URI[aarch64_perl-Tk-Getopt-tests.sha256sum] = "616c16c5fc63ccc4fa0226ef539404321bdd9c0ec73d80e76c0bb7a29f9eea5c"

RDEPENDS:perl-Tk-Getopt = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Safe \
 perl-Tk \
 perl-constant \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Tk-Getopt-tests = " \
 bash \
 perl-File-Temp \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Tk \
 perl-Tk-Getopt \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
