# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-platformio"
PV = "6.1.18"
PR = "4.el10_1"
PACKAGES = " \
 platformio \
 python3-platformio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-platformio-6.1.18-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5f26bdfc38d4ed11c7f1cc8ca550058a13517231de3b7397c0d6705ebda9af9"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3-platformio: (python3.12dist(semantic-version) >= 2.10 with python3.12dist(semantic-version) < 2.11)

URI_x86_64_v2_platformio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/platformio-6.1.18-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_platformio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_platformio}"
SRC_URI[x86_64_v2_platformio.sha256sum] = "5ea2d1973c6f4aafe2f0522a4bc7d05f3ea5f2d62dcbe7d32dda49f66ea13ccc"

URI_x86_64_v2_python3-platformio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-platformio-6.1.18-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-platformio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-platformio}"
SRC_URI[x86_64_v2_python3-platformio.sha256sum] = "8e37a4cf5bc5ef8913666bfbf347a37354978da6b40fa50441ac13d3d92d2724"

URI_aarch64_platformio = "${EPEL_MIRROR}/aarch64/Packages/p/platformio-6.1.18-4.el10_1.noarch.rpm;name=aarch64_platformio;unpack=0"
SRC_URI:append = " ${URI_aarch64_platformio}"
SRC_URI[aarch64_platformio.sha256sum] = "3908d8dcebe929f2f8d8b773404edbc842474c286043a5be42df23d01ed79380"

URI_aarch64_python3-platformio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-platformio-6.1.18-4.el10_1.noarch.rpm;name=aarch64_python3-platformio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-platformio}"
SRC_URI[aarch64_python3-platformio.sha256sum] = "969be3e74dbd3f107387c97ebb9e1672cbdd709c9372709211ebb2e06075a410"

RDEPENDS:platformio = " \
 python3 \
 python3-platformio \
 systemd-udev \
 "
RDEPENDS:python3-platformio:x86_64_v2 = " \
 python3 \
 python3-ajsonrpc \
 python3-bottle \
 python3-click \
 python3-colorama \
 python3-marshmallow \
 python3-pyelftools \
 python3-pyserial \
 python3-requests \
 python3-starlette \
 python3-tabulate \
 python3-uvicorn \
 python3-wsproto \
"
RDEPENDS:python3-platformio:aarch64 = " \
 python3 \
 python3-ajsonrpc \
 python3-bottle \
 python3-click \
 python3-colorama \
 python3-marshmallow \
 python3-pyelftools \
 python3-pyserial \
 python3-requests \
 python3-semantic_version \
 python3-starlette \
 python3-tabulate \
 python3-uvicorn \
 python3-wsproto \
"
