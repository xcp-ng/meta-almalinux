# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-orion"
PV = "0.17.13"
PR = "1.el10_2"
PACKAGES = " \
 rust-orion+alloc-devel \
 rust-orion+ct-codecs-devel \
 rust-orion+default-devel \
 rust-orion+experimental-devel \
 rust-orion+getrandom-devel \
 rust-orion+safe_api-devel \
 rust-orion+serde-devel \
 rust-orion+zeroize-devel \
 rust-orion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-orion-0.17.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21a7192f4793b8db2802737155b4844e4ae9e942465e50cec97f20221801faf3"

URI_x86_64_v2_rust-orion+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+alloc-devel-0.17.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+alloc-devel}"
SRC_URI[x86_64_v2_rust-orion+alloc-devel.sha256sum] = "0834b4e926ab10a6ead81446546375796b3854f42426d45890ae17325c0b862d"

URI_x86_64_v2_rust-orion+ct-codecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+ct-codecs-devel-0.17.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+ct-codecs-devel}"
SRC_URI[x86_64_v2_rust-orion+ct-codecs-devel.sha256sum] = "5950cee2a0d967e6283bda7837b97423ed23cb5da7f299c7258379fbc3bb365f"

URI_x86_64_v2_rust-orion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+default-devel-0.17.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+default-devel}"
SRC_URI[x86_64_v2_rust-orion+default-devel.sha256sum] = "8137fe0ea09cc1a9227facb27d4413284e52218f85ba87b579c351d64b6f563f"

URI_x86_64_v2_rust-orion+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+experimental-devel-0.17.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+experimental-devel}"
SRC_URI[x86_64_v2_rust-orion+experimental-devel.sha256sum] = "eb290ee56620ca1355465a6608513c0d6ea7efaa463c9cf1b49e5c040e3ea662"

URI_x86_64_v2_rust-orion+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+getrandom-devel-0.17.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+getrandom-devel}"
SRC_URI[x86_64_v2_rust-orion+getrandom-devel.sha256sum] = "435b209c75e8c83a7847ef51b185433ebb754c344626ffdc834907ff056a965f"

URI_x86_64_v2_rust-orion+safe_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+safe_api-devel-0.17.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+safe_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+safe_api-devel}"
SRC_URI[x86_64_v2_rust-orion+safe_api-devel.sha256sum] = "232806a6a59fe044d78f8e351a104adc83a11a64368138076ce734209a792d71"

URI_x86_64_v2_rust-orion+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+serde-devel-0.17.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+serde-devel}"
SRC_URI[x86_64_v2_rust-orion+serde-devel.sha256sum] = "6c3f5163a4c674cbfe928044e263d1b1ed0dd2629ff6fa5921433a21583dd50c"

URI_x86_64_v2_rust-orion+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+zeroize-devel-0.17.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+zeroize-devel}"
SRC_URI[x86_64_v2_rust-orion+zeroize-devel.sha256sum] = "83bd9a6f7b044b93e7ff44030493cd960abb16026de2487918eeee3f41d0a0b6"

URI_x86_64_v2_rust-orion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion-devel-0.17.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion-devel}"
SRC_URI[x86_64_v2_rust-orion-devel.sha256sum] = "89a4c8158b985d42eeb1f25c7f59293a5fe456d4501796ab4a3339af702593a7"

URI_aarch64_rust-orion+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+alloc-devel-0.17.13-1.el10_2.noarch.rpm;name=aarch64_rust-orion+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+alloc-devel}"
SRC_URI[aarch64_rust-orion+alloc-devel.sha256sum] = "51761c46dd43eb007f7bc854d892137b35f998383c0486c6866648ffb407fad2"

URI_aarch64_rust-orion+ct-codecs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+ct-codecs-devel-0.17.13-1.el10_2.noarch.rpm;name=aarch64_rust-orion+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+ct-codecs-devel}"
SRC_URI[aarch64_rust-orion+ct-codecs-devel.sha256sum] = "f3a81400c79f09aee9eadd586d18ed09460edcc1bcaa38700bc164e16cb72180"

URI_aarch64_rust-orion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+default-devel-0.17.13-1.el10_2.noarch.rpm;name=aarch64_rust-orion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+default-devel}"
SRC_URI[aarch64_rust-orion+default-devel.sha256sum] = "2c89600b5ac13fd65789ede5680b0fadd54fe5493c3c081b8e96c3c896a5bc74"

URI_aarch64_rust-orion+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+experimental-devel-0.17.13-1.el10_2.noarch.rpm;name=aarch64_rust-orion+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+experimental-devel}"
SRC_URI[aarch64_rust-orion+experimental-devel.sha256sum] = "8a233ad4a8aedbf64ad67388d7ad41a4394a5faad484052f3b4a40e2c68e2863"

URI_aarch64_rust-orion+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+getrandom-devel-0.17.13-1.el10_2.noarch.rpm;name=aarch64_rust-orion+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+getrandom-devel}"
SRC_URI[aarch64_rust-orion+getrandom-devel.sha256sum] = "df4adb7811df73321c088f47e828bca6c6acd1e892974fa552ff004511e07375"

URI_aarch64_rust-orion+safe_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+safe_api-devel-0.17.13-1.el10_2.noarch.rpm;name=aarch64_rust-orion+safe_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+safe_api-devel}"
SRC_URI[aarch64_rust-orion+safe_api-devel.sha256sum] = "3f9f2321ea44b3e548404b46c29e7ab865cbab2d4661d4f9a72de6adb053c6bf"

URI_aarch64_rust-orion+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+serde-devel-0.17.13-1.el10_2.noarch.rpm;name=aarch64_rust-orion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+serde-devel}"
SRC_URI[aarch64_rust-orion+serde-devel.sha256sum] = "a902f44d6cb89435d8ef886ed75e16ca4391b230ba6e9f7c77c36c79e5910cc4"

URI_aarch64_rust-orion+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+zeroize-devel-0.17.13-1.el10_2.noarch.rpm;name=aarch64_rust-orion+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+zeroize-devel}"
SRC_URI[aarch64_rust-orion+zeroize-devel.sha256sum] = "86ccc25c152337686e9fb98591c4abfd06b0c5e62ec5739d7a586146ba1e2d51"

URI_aarch64_rust-orion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion-devel-0.17.13-1.el10_2.noarch.rpm;name=aarch64_rust-orion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion-devel}"
SRC_URI[aarch64_rust-orion-devel.sha256sum] = "682ce8e4d35cb93c6b6b1c7d35a25680733fdf9386d7816c29f91cd38dc17a1b"

RDEPENDS:rust-orion+alloc-devel = " \
 cargo \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+ct-codecs-devel = " \
 cargo \
 rust-ct-codecs+default-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+default-devel = " \
 cargo \
 rust-orion+safe_api-devel \
 rust-orion+zeroize-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+experimental-devel = " \
 cargo \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+safe_api-devel = " \
 cargo \
 rust-orion+ct-codecs-devel \
 rust-orion+getrandom-devel \
 rust-orion-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-orion+serde-devel = " \
 cargo \
 rust-orion+alloc-devel \
 rust-orion-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-orion+zeroize-devel = " \
 cargo \
 rust-orion-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-orion-devel = " \
 cargo \
 rust \
 rust-fiat-crypto-devel \
 rust-subtle-devel \
 "
