# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flake8-builtins"
PV = "3.1.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-flake8-builtins \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-flake8-builtins-3.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d55d74104a85cea4d5cb9e3d2eea21262f8aea04d4026361f21b6d35e061ddd"

URI_x86_64_v2_python3-flake8-builtins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flake8-builtins-3.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flake8-builtins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flake8-builtins}"
SRC_URI[x86_64_v2_python3-flake8-builtins.sha256sum] = "0facc1661e1bf679498493978d8bde49031059b95a436a4fdd204621886e5979"

URI_aarch64_python3-flake8-builtins = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flake8-builtins-3.1.0-1.el10_2.noarch.rpm;name=aarch64_python3-flake8-builtins;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flake8-builtins}"
SRC_URI[aarch64_python3-flake8-builtins.sha256sum] = "a377ee7a973d1931f9f764ca2b69ee0a638e39962bc6d59b00b6943fe1066df4"

RDEPENDS:python3-flake8-builtins = " \
 python3 \
 python3-flake8 \
 "
