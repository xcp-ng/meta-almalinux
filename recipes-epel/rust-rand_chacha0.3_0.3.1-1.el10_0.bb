# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_chacha0.3"
PV = "0.3.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-rand_chacha0.3+default-devel \
 rust-rand_chacha0.3+serde-devel \
 rust-rand_chacha0.3+serde1-devel \
 rust-rand_chacha0.3+simd-devel \
 rust-rand_chacha0.3+std-devel \
 rust-rand_chacha0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_chacha0.3-0.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b042e66dcf26f5ae6f51399ebbacc5ba80907d5aee16fc0de03562786da2d8e5"

URI_x86_64_v2_rust-rand_chacha0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.3+default-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.3+default-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.3+default-devel.sha256sum] = "80931fb1eb98114a442556fc87731e43ed1e90077b4cb134340e699eb47fed71"

URI_x86_64_v2_rust-rand_chacha0.3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.3+serde-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.3+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.3+serde-devel.sha256sum] = "5278847c02f90c0290819662e407eb4fc5712c1ad635876edc030fdd30895a89"

URI_x86_64_v2_rust-rand_chacha0.3+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.3+serde1-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.3+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.3+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.3+serde1-devel.sha256sum] = "ae88b6406a7d74b151464c679c9a8cd658640f678c66051683e2eb126d8d0026"

URI_x86_64_v2_rust-rand_chacha0.3+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.3+simd-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.3+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.3+simd-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.3+simd-devel.sha256sum] = "ace54ea317b030a49e380bd7c8e2de9c3adbcf0b7e9e39bc3ced751db9d18fcc"

URI_x86_64_v2_rust-rand_chacha0.3+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.3+std-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.3+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.3+std-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.3+std-devel.sha256sum] = "c4e980a017d45cc2202f3fce9b1809db18e892e9f41f9f3bc00f35401d850685"

URI_x86_64_v2_rust-rand_chacha0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.3-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.3-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.3-devel.sha256sum] = "22682d77ce1cc864721e11f47d1456e6f1a32bf19f2b71ee4225320851a59809"

URI_aarch64_rust-rand_chacha0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.3+default-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.3+default-devel}"
SRC_URI[aarch64_rust-rand_chacha0.3+default-devel.sha256sum] = "7d92eb8ffce7241af203ed6083825afcb0558c77090d34b9ff2793fd3795c370"

URI_aarch64_rust-rand_chacha0.3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.3+serde-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.3+serde-devel}"
SRC_URI[aarch64_rust-rand_chacha0.3+serde-devel.sha256sum] = "025ac884c69a55b5625bc9fb23d812e19ec47b4a7eb598412ef3623a582626dd"

URI_aarch64_rust-rand_chacha0.3+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.3+serde1-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha0.3+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.3+serde1-devel}"
SRC_URI[aarch64_rust-rand_chacha0.3+serde1-devel.sha256sum] = "1751d1fcc4c76f3902f787338c2f00c53b746610a80a347db45bb5d56318aa47"

URI_aarch64_rust-rand_chacha0.3+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.3+simd-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha0.3+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.3+simd-devel}"
SRC_URI[aarch64_rust-rand_chacha0.3+simd-devel.sha256sum] = "55d97d8169d0b47f2c74044ea2199075295f2ce0d41d13f496843945374f290f"

URI_aarch64_rust-rand_chacha0.3+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.3+std-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha0.3+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.3+std-devel}"
SRC_URI[aarch64_rust-rand_chacha0.3+std-devel.sha256sum] = "6fa0d64d91d97e025bb8598b1fbde68fe99d37e27265f8714ea9a02f0b222bb6"

URI_aarch64_rust-rand_chacha0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.3-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.3-devel}"
SRC_URI[aarch64_rust-rand_chacha0.3-devel.sha256sum] = "dcc6ae32de28328ea3d8628f5e5a23bc5cce1bca6a960b7bc6d4bd541eba4921"

RDEPENDS:rust-rand_chacha0.3+default-devel = " \
 cargo \
 rust-rand_chacha0.3+std-devel \
 rust-rand_chacha0.3-devel \
 "
RDEPENDS:rust-rand_chacha0.3+serde-devel = " \
 cargo \
 rust-rand_chacha0.3-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_chacha0.3+serde1-devel = " \
 cargo \
 rust-rand_chacha0.3+serde-devel \
 rust-rand_chacha0.3-devel \
 "
RDEPENDS:rust-rand_chacha0.3+simd-devel = " \
 cargo \
 rust-rand_chacha0.3-devel \
 "
RDEPENDS:rust-rand_chacha0.3+std-devel = " \
 cargo \
 rust-ppv-lite86+std-devel \
 rust-rand_chacha0.3-devel \
 "
RDEPENDS:rust-rand_chacha0.3-devel = " \
 cargo \
 rust-ppv-lite86+simd-devel \
 rust-ppv-lite86-devel \
 rust-rand_core0.6+default-devel \
 "
