# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keychain"
PV = "3.0.2"
PR = "1.el10_3"
PACKAGES = " \
 keychain \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keychain-3.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8dd91235b5b6446f551338256e3393a1510c837b21ec149293f8c3dc5bdd3a9"

URI_x86_64_v2_keychain = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keychain-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_keychain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keychain}"
SRC_URI[x86_64_v2_keychain.sha256sum] = "ece2fd0f08fcc2060a38389fd21d36db66a62208dd113e21a113fa88b117439b"

URI_aarch64_keychain = "${EPEL_MIRROR}/aarch64/Packages/k/keychain-3.0.2-1.el10_3.noarch.rpm;name=aarch64_keychain;unpack=0"
SRC_URI:append = " ${URI_aarch64_keychain}"
SRC_URI[aarch64_keychain.sha256sum] = "c70d422ea028b9c76518e2bf2bc22e639ffb4d72ba0c786b3bf938751d5ed2ae"

RDEPENDS:keychain = " \
 python3 \
 "
