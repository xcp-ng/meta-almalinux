# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lru0.13"
PV = "0.13.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-lru0.13+default-devel \
 rust-lru0.13+hashbrown-devel \
 rust-lru0.13-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lru0.13-0.13.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bb6adbbeafd214fa235ed7d458ccf96b09a0979e363b74181d91c81c7cc0b71"

URI_x86_64_v2_rust-lru0.13+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru0.13+default-devel-0.13.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru0.13+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru0.13+default-devel}"
SRC_URI[x86_64_v2_rust-lru0.13+default-devel.sha256sum] = "9271856908efe67b7e0150cfb84328a90082f2b325fc707827e0fd5d6c7230eb"

URI_x86_64_v2_rust-lru0.13+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru0.13+hashbrown-devel-0.13.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru0.13+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru0.13+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-lru0.13+hashbrown-devel.sha256sum] = "f03139a68dacf81ad6d1783a5d9540cc64fa0d3de8c8c6946861d04997227d0a"

URI_x86_64_v2_rust-lru0.13-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru0.13-devel-0.13.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru0.13-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru0.13-devel}"
SRC_URI[x86_64_v2_rust-lru0.13-devel.sha256sum] = "cafd924063050f62115a17bfeae1d8c84ae88634e7bcb2cc53f879b35197e020"

URI_aarch64_rust-lru0.13+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru0.13+default-devel-0.13.0-1.el10_1.noarch.rpm;name=aarch64_rust-lru0.13+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru0.13+default-devel}"
SRC_URI[aarch64_rust-lru0.13+default-devel.sha256sum] = "98a87bc8f85b6bc2ccee1c5d61cef1a2a4f812c404fac513dd1e9b5123acddc2"

URI_aarch64_rust-lru0.13+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru0.13+hashbrown-devel-0.13.0-1.el10_1.noarch.rpm;name=aarch64_rust-lru0.13+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru0.13+hashbrown-devel}"
SRC_URI[aarch64_rust-lru0.13+hashbrown-devel.sha256sum] = "4f5feb4a30743ffb38d2117f77368c2223da0ce09603da18632322397a1c3e26"

URI_aarch64_rust-lru0.13-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru0.13-devel-0.13.0-1.el10_1.noarch.rpm;name=aarch64_rust-lru0.13-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru0.13-devel}"
SRC_URI[aarch64_rust-lru0.13-devel.sha256sum] = "83fe60520938b67a4bb3f78bbe90b6fdfbf71ee4e04fc1b00dcc347ea5b6cb7e"

RDEPENDS:rust-lru0.13+default-devel = " \
 cargo \
 rust-lru0.13+hashbrown-devel \
 rust-lru0.13-devel \
 "
RDEPENDS:rust-lru0.13+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.15+default-devel \
 rust-lru0.13-devel \
 "
RDEPENDS:rust-lru0.13-devel = " \
 cargo \
 "
