# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jna"
PV = "5.14.0"
PR = "7.el10"
PACKAGES = " \
 jna \
 jna-contrib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jna-5.14.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b35212a01be0438b2e126c09ae3b7bb7111aaa3da44c80065277f58697057cd"

URI_x86_64_v2_jna = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jna-5.14.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_jna;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jna}"
SRC_URI[x86_64_v2_jna.sha256sum] = "eb0f5566e3160aab10b282ab84e38abfeb21e50872a5a3a6507e3ccd2b9028ce"

URI_x86_64_v2_jna-contrib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jna-contrib-5.14.0-7.el10.noarch.rpm;name=x86_64_v2_jna-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jna-contrib}"
SRC_URI[x86_64_v2_jna-contrib.sha256sum] = "07baec2c051cea09bbb6d9e49e84062c0a2e1bfc34a91f6e8fc4ab7e68316cef"

URI_aarch64_jna = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jna-5.14.0-7.el10.aarch64.rpm;name=aarch64_jna;unpack=0"
SRC_URI:append = " ${URI_aarch64_jna}"
SRC_URI[aarch64_jna.sha256sum] = "a608b1603458b9d03ae867adf566a47f5310c603eebcdf8dfb6191ae68cddb92"

URI_aarch64_jna-contrib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jna-contrib-5.14.0-7.el10.noarch.rpm;name=aarch64_jna-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_jna-contrib}"
SRC_URI[aarch64_jna-contrib.sha256sum] = "07baec2c051cea09bbb6d9e49e84062c0a2e1bfc34a91f6e8fc4ab7e68316cef"

RDEPENDS:jna = " \
 glibc \
 javapackages-filesystem \
 libffi \
 "
RDEPENDS:jna-contrib = " \
 javapackages-filesystem \
 jna \
 "
