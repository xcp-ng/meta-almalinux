# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf-plugins-core"
PV = "4.7.0"
PR = "9.el10"
PACKAGES = " \
 dnf-plugins-core \
 python3-dnf-plugin-leaves \
 python3-dnf-plugin-modulesync \
 python3-dnf-plugin-post-transaction-actions \
 python3-dnf-plugin-pre-transaction-actions \
 python3-dnf-plugin-show-leaves \
 python3-dnf-plugin-versionlock \
 python3-dnf-plugins-core \
 yum-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dnf-plugins-core-4.7.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45dacc07c3ad6380ad3a147baea6a8bb40f74bdcda27ace7a2387a0a2c7e8af1"

URI_x86_64_v2_dnf-plugins-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-plugins-core-4.7.0-9.el10.noarch.rpm;name=x86_64_v2_dnf-plugins-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-plugins-core}"
SRC_URI[x86_64_v2_dnf-plugins-core.sha256sum] = "137d5850d8bebfdf8d31d63c4630458900271e770ca370384b7fed63a56f44d8"

URI_x86_64_v2_python3-dnf-plugin-leaves = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dnf-plugin-leaves-4.7.0-9.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-leaves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-leaves}"
SRC_URI[x86_64_v2_python3-dnf-plugin-leaves.sha256sum] = "f952c3bd701d62d55ab78f4f300c665f8d8c2f624edd1d1f656d7eed6a609079"

URI_x86_64_v2_python3-dnf-plugin-modulesync = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dnf-plugin-modulesync-4.7.0-9.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-modulesync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-modulesync}"
SRC_URI[x86_64_v2_python3-dnf-plugin-modulesync.sha256sum] = "1570cba6e206a86f4333c6d5e9dbe59a9370cfa1b8bb916bfc1619f18c1f12c0"

URI_x86_64_v2_python3-dnf-plugin-post-transaction-actions = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugin-post-transaction-actions-4.7.0-9.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-post-transaction-actions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-post-transaction-actions}"
SRC_URI[x86_64_v2_python3-dnf-plugin-post-transaction-actions.sha256sum] = "d6f7f7802dd455e310dc09afbe784ec89895a7c149876c1713dba14836177ce0"

URI_x86_64_v2_python3-dnf-plugin-pre-transaction-actions = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugin-pre-transaction-actions-4.7.0-9.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-pre-transaction-actions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-pre-transaction-actions}"
SRC_URI[x86_64_v2_python3-dnf-plugin-pre-transaction-actions.sha256sum] = "d713cb1a41651419e4cb59440d304062806bd27f0eb1837c6a55e1ab30aa5999"

URI_x86_64_v2_python3-dnf-plugin-show-leaves = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dnf-plugin-show-leaves-4.7.0-9.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-show-leaves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-show-leaves}"
SRC_URI[x86_64_v2_python3-dnf-plugin-show-leaves.sha256sum] = "741ee37971d87fc3b2eb9625bd6d1939ae47e82b683fd97620f31faedfe0a737"

URI_x86_64_v2_python3-dnf-plugin-versionlock = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugin-versionlock-4.7.0-9.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-versionlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-versionlock}"
SRC_URI[x86_64_v2_python3-dnf-plugin-versionlock.sha256sum] = "0f3fa592a4b10d814647f48ac87665911e42ac13b0929328217047549bf8f4b8"

URI_x86_64_v2_python3-dnf-plugins-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugins-core-4.7.0-9.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugins-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugins-core}"
SRC_URI[x86_64_v2_python3-dnf-plugins-core.sha256sum] = "c90a85c3a046f10e85be600dd3315161111ea6cac0d5ee51b7297be1569f43c0"

URI_x86_64_v2_yum-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/yum-utils-4.7.0-9.el10.noarch.rpm;name=x86_64_v2_yum-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yum-utils}"
SRC_URI[x86_64_v2_yum-utils.sha256sum] = "829f61d778d7f31d9246db4e35bdd8a6d05840c1305d7c31fcc34bd831891f1a"

URI_aarch64_dnf-plugins-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-plugins-core-4.7.0-9.el10.noarch.rpm;name=aarch64_dnf-plugins-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-plugins-core}"
SRC_URI[aarch64_dnf-plugins-core.sha256sum] = "137d5850d8bebfdf8d31d63c4630458900271e770ca370384b7fed63a56f44d8"

URI_aarch64_python3-dnf-plugin-leaves = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dnf-plugin-leaves-4.7.0-9.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-leaves;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-leaves}"
SRC_URI[aarch64_python3-dnf-plugin-leaves.sha256sum] = "f952c3bd701d62d55ab78f4f300c665f8d8c2f624edd1d1f656d7eed6a609079"

URI_aarch64_python3-dnf-plugin-modulesync = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dnf-plugin-modulesync-4.7.0-9.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-modulesync;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-modulesync}"
SRC_URI[aarch64_python3-dnf-plugin-modulesync.sha256sum] = "1570cba6e206a86f4333c6d5e9dbe59a9370cfa1b8bb916bfc1619f18c1f12c0"

URI_aarch64_python3-dnf-plugin-post-transaction-actions = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugin-post-transaction-actions-4.7.0-9.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-post-transaction-actions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-post-transaction-actions}"
SRC_URI[aarch64_python3-dnf-plugin-post-transaction-actions.sha256sum] = "d6f7f7802dd455e310dc09afbe784ec89895a7c149876c1713dba14836177ce0"

URI_aarch64_python3-dnf-plugin-pre-transaction-actions = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugin-pre-transaction-actions-4.7.0-9.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-pre-transaction-actions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-pre-transaction-actions}"
SRC_URI[aarch64_python3-dnf-plugin-pre-transaction-actions.sha256sum] = "d713cb1a41651419e4cb59440d304062806bd27f0eb1837c6a55e1ab30aa5999"

URI_aarch64_python3-dnf-plugin-show-leaves = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dnf-plugin-show-leaves-4.7.0-9.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-show-leaves;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-show-leaves}"
SRC_URI[aarch64_python3-dnf-plugin-show-leaves.sha256sum] = "741ee37971d87fc3b2eb9625bd6d1939ae47e82b683fd97620f31faedfe0a737"

URI_aarch64_python3-dnf-plugin-versionlock = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugin-versionlock-4.7.0-9.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-versionlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-versionlock}"
SRC_URI[aarch64_python3-dnf-plugin-versionlock.sha256sum] = "0f3fa592a4b10d814647f48ac87665911e42ac13b0929328217047549bf8f4b8"

URI_aarch64_python3-dnf-plugins-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugins-core-4.7.0-9.el10.noarch.rpm;name=aarch64_python3-dnf-plugins-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugins-core}"
SRC_URI[aarch64_python3-dnf-plugins-core.sha256sum] = "c90a85c3a046f10e85be600dd3315161111ea6cac0d5ee51b7297be1569f43c0"

URI_aarch64_yum-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/yum-utils-4.7.0-9.el10.noarch.rpm;name=aarch64_yum-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_yum-utils}"
SRC_URI[aarch64_yum-utils.sha256sum] = "829f61d778d7f31d9246db4e35bdd8a6d05840c1305d7c31fcc34bd831891f1a"

RDEPENDS:dnf-plugins-core = " \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-leaves = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-modulesync = " \
 createrepo_c \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-post-transaction-actions = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-pre-transaction-actions = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-show-leaves = " \
 python3 \
 python3-dnf-plugin-leaves \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-versionlock = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugins-core = " \
 python3 \
 python3-dateutil \
 python3-dbus \
 python3-dnf \
 python3-hawkey \
 python3-systemd \
 "
RDEPENDS:yum-utils = " \
 dnf-plugins-core \
 python3 \
 python3-dnf \
 "
