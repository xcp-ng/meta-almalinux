# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clearscreen"
PV = "4.0.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-clearscreen+default-devel \
 rust-clearscreen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clearscreen-4.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95702ef4be257a70d3ffe499b49673d435aa1aa355424d4b8d851572d1738154"

URI_x86_64_v2_rust-clearscreen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clearscreen+default-devel-4.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clearscreen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clearscreen+default-devel}"
SRC_URI[x86_64_v2_rust-clearscreen+default-devel.sha256sum] = "4cf5f2b98b44953b91673c9b2ea1d2be0e88813bff83e5c56616f8736b85b7a0"

URI_x86_64_v2_rust-clearscreen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clearscreen-devel-4.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clearscreen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clearscreen-devel}"
SRC_URI[x86_64_v2_rust-clearscreen-devel.sha256sum] = "c2e2fec5792e1eae3dbc0af5327b208e1a6e0c77c7b9c6f80fac3b88c1655997"

URI_aarch64_rust-clearscreen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clearscreen+default-devel-4.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-clearscreen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clearscreen+default-devel}"
SRC_URI[aarch64_rust-clearscreen+default-devel.sha256sum] = "473a51e0f1e276bacd48d5514a60f9b03422508c0274fbdc02404d267d919c2c"

URI_aarch64_rust-clearscreen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clearscreen-devel-4.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-clearscreen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clearscreen-devel}"
SRC_URI[aarch64_rust-clearscreen-devel.sha256sum] = "6dd162ff276e03ca45f3ffeaefea26ed97d2f056e5bb12a749232b65efb94895"

RDEPENDS:rust-clearscreen+default-devel = " \
 cargo \
 rust-clearscreen-devel \
 "
RDEPENDS:rust-clearscreen-devel = " \
 cargo \
 rust \
 rust-nix+fs-devel \
 rust-nix+term-devel \
 rust-nix-devel \
 rust-terminfo+default-devel \
 rust-thiserror+default-devel \
 rust-which+default-devel \
 "
