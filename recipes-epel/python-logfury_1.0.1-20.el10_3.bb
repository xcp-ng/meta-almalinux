# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-logfury"
PV = "1.0.1"
PR = "20.el10_3"
PACKAGES = " \
 python3-logfury \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-logfury-1.0.1-20.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "650f1ca8e0fda2de112d4ee6232863bdfa91bae8afa69e35d873fbe7421f9e8a"

URI_x86_64_v2_python3-logfury = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-logfury-1.0.1-20.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-logfury;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-logfury}"
SRC_URI[x86_64_v2_python3-logfury.sha256sum] = "1e4ed0df9fb8a85845cdf0796997c223980579c302e0e6ab22a6d564b52f4011"

URI_aarch64_python3-logfury = "${EPEL_MIRROR}/aarch64/Packages/p/python3-logfury-1.0.1-20.el10_3.noarch.rpm;name=aarch64_python3-logfury;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-logfury}"
SRC_URI[aarch64_python3-logfury.sha256sum] = "9edf6187f596861c51a56178fb0a36e4a684740ac10d23985988431fbaed3c62"

RDEPENDS:python3-logfury = " \
 python3 \
 "
