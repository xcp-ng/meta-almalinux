# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proptest-macro"
PV = "0.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-proptest-macro+default-devel \
 rust-proptest-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proptest-macro-0.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa8421c5a75b347643ed8349cb90ac7560622aa7c7cfd2b5fe8f8498a4c20150"

URI_x86_64_v2_rust-proptest-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-macro+default-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-macro+default-devel}"
SRC_URI[x86_64_v2_rust-proptest-macro+default-devel.sha256sum] = "1839e6c71040f4d484b79ef9c6a379367b7a02b5e844160b1416552d62563ac1"

URI_x86_64_v2_rust-proptest-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-macro-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-macro-devel}"
SRC_URI[x86_64_v2_rust-proptest-macro-devel.sha256sum] = "7aaa31fcdbe23807cebbf12d9f5a43a536aaec1df5622beadd53a7fc14dfa289"

URI_aarch64_rust-proptest-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-macro+default-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-macro+default-devel}"
SRC_URI[aarch64_rust-proptest-macro+default-devel.sha256sum] = "147e7f01c80c3ba380cde9a29eff3f0c3ca7d8318d3415ebb80fa5ac0f77661b"

URI_aarch64_rust-proptest-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-macro-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-macro-devel}"
SRC_URI[aarch64_rust-proptest-macro-devel.sha256sum] = "15b9cbbbf0ddbd063c8248b9fe335767dcf44dc17a534e408b1c495750cfe1fb"

RDEPENDS:rust-proptest-macro+default-devel = " \
 cargo \
 rust-proptest-macro-devel \
 "
RDEPENDS:rust-proptest-macro-devel = " \
 cargo \
 rust \
 rust-convert_case0.6+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
