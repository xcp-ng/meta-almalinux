# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-spf13-pflag"
PV = "1.0.5"
PR = "16.20220918gitd5e0c06.el10_0"
PACKAGES = " \
 golang-github-spf13-pflag-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-spf13-pflag-1.0.5-16.20220918gitd5e0c06.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50123ce89c4034b8d65cfc66b936521026bd9a4686768706ead303aa2fbc9659"

URI_aarch64_golang-github-spf13-pflag-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-spf13-pflag-devel-1.0.5-16.20220918gitd5e0c06.el10_0.noarch.rpm;name=aarch64_golang-github-spf13-pflag-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-spf13-pflag-devel}"
SRC_URI[aarch64_golang-github-spf13-pflag-devel.sha256sum] = "098091acb005457a2293accd53ad2982605df95bc7469a2da0a69281c06e2f36"

RDEPENDS:golang-github-spf13-pflag-devel = " \
 go-filesystem \
 "
