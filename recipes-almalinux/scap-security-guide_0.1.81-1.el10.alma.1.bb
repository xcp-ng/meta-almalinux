# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scap-security-guide"
PV = "0.1.81"
PR = "1.el10.alma.1"
PACKAGES = " \
 scap-security-guide \
 scap-security-guide-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/scap-security-guide-0.1.81-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95ed849e4459a639e17282b881060593cf405443d453d3d08593632a2689c92d"

URI_x86_64_v2_scap-security-guide = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scap-security-guide-0.1.81-1.el10.alma.1.noarch.rpm;name=x86_64_v2_scap-security-guide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scap-security-guide}"
SRC_URI[x86_64_v2_scap-security-guide.sha256sum] = "56b481c843ef206fd1edf5dd04927f5a2d7a3db45147d3311a4a649c1764a43f"

URI_x86_64_v2_scap-security-guide-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scap-security-guide-doc-0.1.81-1.el10.alma.1.noarch.rpm;name=x86_64_v2_scap-security-guide-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scap-security-guide-doc}"
SRC_URI[x86_64_v2_scap-security-guide-doc.sha256sum] = "a3f375af163f8e008fc45c0286efb801d750288f3d226e9806342da18560e2e7"

URI_aarch64_scap-security-guide = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scap-security-guide-0.1.81-1.el10.alma.1.noarch.rpm;name=aarch64_scap-security-guide;unpack=0"
SRC_URI:append = " ${URI_aarch64_scap-security-guide}"
SRC_URI[aarch64_scap-security-guide.sha256sum] = "56b481c843ef206fd1edf5dd04927f5a2d7a3db45147d3311a4a649c1764a43f"

URI_aarch64_scap-security-guide-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scap-security-guide-doc-0.1.81-1.el10.alma.1.noarch.rpm;name=aarch64_scap-security-guide-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scap-security-guide-doc}"
SRC_URI[aarch64_scap-security-guide-doc.sha256sum] = "a3f375af163f8e008fc45c0286efb801d750288f3d226e9806342da18560e2e7"

RDEPENDS:scap-security-guide = " \
 openscap-scanner \
 xml-common \
 "
RDEPENDS:scap-security-guide-doc = " \
 scap-security-guide \
 "
