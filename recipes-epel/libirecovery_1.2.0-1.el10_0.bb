# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libirecovery"
PV = "1.2.0"
PR = "1.el10_0"
PACKAGES = " \
 libirecovery \
 libirecovery-devel \
 libirecovery-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libirecovery-1.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "222086afa9aacd52e9ad1e23dff752a70bae952e3c36a14c0ccf2ace63c61c18"

URI_x86_64_v2_libirecovery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libirecovery-1.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libirecovery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libirecovery}"
SRC_URI[x86_64_v2_libirecovery.sha256sum] = "048b538dbb905f912571cc2b2377356f484cd4a1d8fb8b04f75326b63dc1ef32"

URI_x86_64_v2_libirecovery-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libirecovery-devel-1.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libirecovery-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libirecovery-devel}"
SRC_URI[x86_64_v2_libirecovery-devel.sha256sum] = "971bc9a41e9cb1814778c5ca9fddd5b6fcf03fefd9179a629fd7f972f814dbe5"

URI_x86_64_v2_libirecovery-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libirecovery-utils-1.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libirecovery-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libirecovery-utils}"
SRC_URI[x86_64_v2_libirecovery-utils.sha256sum] = "dd401d4f93e10a2e19111753e68ca01e452d6f300128ddf11e7b6181a3fe950b"

URI_aarch64_libirecovery = "${EPEL_MIRROR}/aarch64/Packages/l/libirecovery-1.2.0-1.el10_0.aarch64.rpm;name=aarch64_libirecovery;unpack=0"
SRC_URI:append = " ${URI_aarch64_libirecovery}"
SRC_URI[aarch64_libirecovery.sha256sum] = "9dbd30f90033c287ad44e18be3905a8110679070e89b771273b408ed7c85bd69"

URI_aarch64_libirecovery-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libirecovery-devel-1.2.0-1.el10_0.aarch64.rpm;name=aarch64_libirecovery-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libirecovery-devel}"
SRC_URI[aarch64_libirecovery-devel.sha256sum] = "1e3b791340d9d6cf437c6e2c9eaab16aa651c23c90471446edef35a261009e57"

URI_aarch64_libirecovery-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libirecovery-utils-1.2.0-1.el10_0.aarch64.rpm;name=aarch64_libirecovery-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libirecovery-utils}"
SRC_URI[aarch64_libirecovery-utils.sha256sum] = "9a87be2e13d157985f32ecf7b7690cc5a9f17a2109dbade8f1b8c89d7d85f37b"

RDEPENDS:libirecovery = " \
 glibc \
 libimobiledevice-glue \
 libplist \
 libusb1 \
 "
RDEPENDS:libirecovery-devel = " \
 libimobiledevice-glue-devel \
 libirecovery \
 libusb1-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libirecovery-utils = " \
 glibc \
 libirecovery \
 readline \
 "
