# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "subversion"
PV = "1.14.5"
PR = "3.el10"
PACKAGES = " \
 mod_dav_svn \
 python3-subversion \
 subversion \
 subversion-devel \
 subversion-gnome \
 subversion-libs \
 subversion-perl \
 subversion-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/subversion-1.14.5-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3bc6ea8e65812b5168932d50156a1328fe194ca961dbf30b8d646782dd23420a"

URI_x86_64_v2_mod_dav_svn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_dav_svn-1.14.5-3.el10.x86_64_v2.rpm;name=x86_64_v2_mod_dav_svn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_dav_svn}"
SRC_URI[x86_64_v2_mod_dav_svn.sha256sum] = "ad5a1b514057aee09a7ac67d6e54b3771e89dca47f850b40a5344e3d2b99f878"

URI_x86_64_v2_python3-subversion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-subversion-1.14.5-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-subversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-subversion}"
SRC_URI[x86_64_v2_python3-subversion.sha256sum] = "5e3c4a814548a2fd6a61b0b122b89bddf876208da4e8035cafcbf7b43773ef8f"

URI_x86_64_v2_subversion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/subversion-1.14.5-3.el10.x86_64_v2.rpm;name=x86_64_v2_subversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subversion}"
SRC_URI[x86_64_v2_subversion.sha256sum] = "bd9983d22f42e1b4ed13229ee19c109e11cd401a8d7bd5733e4b635bca678796"

URI_x86_64_v2_subversion-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/subversion-devel-1.14.5-3.el10.x86_64_v2.rpm;name=x86_64_v2_subversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subversion-devel}"
SRC_URI[x86_64_v2_subversion-devel.sha256sum] = "6530f26472c7537056251e4849c4c715cd54e8028cb2fe256bd6754428877562"

URI_x86_64_v2_subversion-gnome = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/subversion-gnome-1.14.5-3.el10.x86_64_v2.rpm;name=x86_64_v2_subversion-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subversion-gnome}"
SRC_URI[x86_64_v2_subversion-gnome.sha256sum] = "7043137ec59545d4433aede1a2e7c34e854191403b60231b5be2828b9783f7af"

URI_x86_64_v2_subversion-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/subversion-libs-1.14.5-3.el10.x86_64_v2.rpm;name=x86_64_v2_subversion-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subversion-libs}"
SRC_URI[x86_64_v2_subversion-libs.sha256sum] = "6f2eee2994dd0ba7af18ec668cc14d2eca26e7687309137d820ae8fbcd084fe2"

URI_x86_64_v2_subversion-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/subversion-perl-1.14.5-3.el10.x86_64_v2.rpm;name=x86_64_v2_subversion-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subversion-perl}"
SRC_URI[x86_64_v2_subversion-perl.sha256sum] = "2d89670d1aab63e359b550e1d268989f4fad9ad720b2f6ab06598e047848d1ac"

URI_x86_64_v2_subversion-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/subversion-tools-1.14.5-3.el10.x86_64_v2.rpm;name=x86_64_v2_subversion-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subversion-tools}"
SRC_URI[x86_64_v2_subversion-tools.sha256sum] = "57c1ff6a2f25ad7b7dae844dd4dbd377a092e3406f7a0e0ca51aceee7476eced"

URI_aarch64_mod_dav_svn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_dav_svn-1.14.5-3.el10.aarch64.rpm;name=aarch64_mod_dav_svn;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_dav_svn}"
SRC_URI[aarch64_mod_dav_svn.sha256sum] = "1651e5bfbaf7b07d87e076f2b39e94e13b1c15b9a8debbc8d70b323380d374c3"

URI_aarch64_python3-subversion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-subversion-1.14.5-3.el10.aarch64.rpm;name=aarch64_python3-subversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-subversion}"
SRC_URI[aarch64_python3-subversion.sha256sum] = "1115bae627dde12b7e1071ecb9a81e2dd35130dcc1ba76619c980548720416da"

URI_aarch64_subversion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/subversion-1.14.5-3.el10.aarch64.rpm;name=aarch64_subversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_subversion}"
SRC_URI[aarch64_subversion.sha256sum] = "df329585c19ebec83bac810bc34b20c5105718db1bb96d92fd75c7524dab950a"

URI_aarch64_subversion-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/subversion-devel-1.14.5-3.el10.aarch64.rpm;name=aarch64_subversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_subversion-devel}"
SRC_URI[aarch64_subversion-devel.sha256sum] = "559eedff85696986a622910c0eecacc8e5a8f385f8f373881d3d9d2a7ffd6d96"

URI_aarch64_subversion-gnome = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/subversion-gnome-1.14.5-3.el10.aarch64.rpm;name=aarch64_subversion-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_subversion-gnome}"
SRC_URI[aarch64_subversion-gnome.sha256sum] = "1db7be80057781f8934a9d3c12348bf74e2656699b357d6998799424a33dfc05"

URI_aarch64_subversion-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/subversion-libs-1.14.5-3.el10.aarch64.rpm;name=aarch64_subversion-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_subversion-libs}"
SRC_URI[aarch64_subversion-libs.sha256sum] = "6a29bdd97f5a0ac52b197fa890dad29ddeb4ae0066934312cc5d50c3ef813ca2"

URI_aarch64_subversion-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/subversion-perl-1.14.5-3.el10.aarch64.rpm;name=aarch64_subversion-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_subversion-perl}"
SRC_URI[aarch64_subversion-perl.sha256sum] = "6a43f1646c030c7a4b1bd804b7c96d1490dc2290f25d6df6c13dabd61b7d5c49"

URI_aarch64_subversion-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/subversion-tools-1.14.5-3.el10.aarch64.rpm;name=aarch64_subversion-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_subversion-tools}"
SRC_URI[aarch64_subversion-tools.sha256sum] = "fb5a0e586c045920142e6c76c9a4ab00bca96adc1d226a03563bd556ee38ff78"

RDEPENDS:mod_dav_svn = " \
 apr \
 apr-util \
 expat \
 file-libs \
 glibc \
 httpd-core \
 libxcrypt \
 lz4-libs \
 sqlite-libs \
 subversion-libs \
 utf8proc \
 zlib-ng-compat \
 "
RDEPENDS:python3-subversion = " \
 apr \
 apr-util \
 cyrus-sasl-lib \
 expat \
 file-libs \
 glibc \
 libserf \
 libxcrypt \
 lz4-libs \
 python3 \
 sqlite-libs \
 subversion-libs \
 utf8proc \
 zlib-ng-compat \
 "
RDEPENDS:subversion = " \
 apr \
 apr-util \
 bash \
 glibc \
 subversion-libs \
 systemd \
 "
RDEPENDS:subversion-devel = " \
 apr-devel \
 apr-util-devel \
 libsecret-devel \
 pkgconf-pkg-config \
 sqlite-devel \
 subversion-devel \
 subversion-libs \
 "
RDEPENDS:subversion-gnome = " \
 apr \
 apr-util \
 expat \
 file-libs \
 glib2 \
 glibc \
 libsecret \
 libxcrypt \
 lz4-libs \
 sqlite-libs \
 subversion-libs \
 utf8proc \
 zlib-ng-compat \
 "
RDEPENDS:subversion-libs = " \
 apr \
 apr-util \
 cyrus-sasl-lib \
 expat \
 file-libs \
 glibc \
 libserf \
 libxcrypt \
 lz4-libs \
 sqlite-libs \
 utf8proc \
 zlib-ng-compat \
 "
RDEPENDS:subversion-perl = " \
 apr \
 apr-util \
 expat \
 file-libs \
 glibc \
 libxcrypt \
 lz4-libs \
 perl-Carp \
 perl-DynaLoader \
 perl-File-Temp \
 perl-IO \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-libs \
 perl-overload \
 sqlite-libs \
 subversion-libs \
 utf8proc \
 zlib-ng-compat \
 "
RDEPENDS:subversion-tools = " \
 apr \
 bash \
 glibc \
 subversion-libs \
 "
