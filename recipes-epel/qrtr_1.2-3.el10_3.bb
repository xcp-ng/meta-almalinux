# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qrtr"
PV = "1.2"
PR = "3.el10_3"
PACKAGES = " \
 qrtr \
 qrtr-devel \
 qrtr-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qrtr-1.2-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "def5a819c8f63e86012ce34553cb96a135c87f4b4600d039eaf3cef30c5cffb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qrtr-1.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qrtr;unpack=0"
SRC_URI[x86_64_v2_qrtr.sha256sum] = "f8fa68a4392d87ec6790345927015088a6e8fd7122b0539340b4c926200a0ae3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qrtr-devel-1.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qrtr-devel;unpack=0"
SRC_URI[x86_64_v2_qrtr-devel.sha256sum] = "39dd76338239bb2be6e04c02f2bf96ea774157f3a1a7dd4c32f0353542431bb3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qrtr-libs-1.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qrtr-libs;unpack=0"
SRC_URI[x86_64_v2_qrtr-libs.sha256sum] = "9ae49c1d15027dd006981c201bacced73fabb74adf8ef777b5c307e51ec401e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qrtr-1.2-3.el10_3.aarch64.rpm;name=aarch64_qrtr;unpack=0"
SRC_URI[aarch64_qrtr.sha256sum] = "40b9baa246976dea5ed13926b8fe33f3ffb4ba55d46783eef8186b7b325f63e3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qrtr-devel-1.2-3.el10_3.aarch64.rpm;name=aarch64_qrtr-devel;unpack=0"
SRC_URI[aarch64_qrtr-devel.sha256sum] = "6b010d1b44ab460918b340a8fa0f9565b28065cad47d5febad0fc1bf8a0c187a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qrtr-libs-1.2-3.el10_3.aarch64.rpm;name=aarch64_qrtr-libs;unpack=0"
SRC_URI[aarch64_qrtr-libs.sha256sum] = "1df5ac87bdddee2c105039e113ec7b6436b4f08ee0b17ef99cbb4fac6922cfce"

RDEPENDS:qrtr = " \
 glibc \
 qrtr-libs \
 "
RDEPENDS:qrtr-devel = " \
 pkgconf-pkg-config \
 qrtr-libs \
 "
RDEPENDS:qrtr-libs = " \
 glibc \
 "
