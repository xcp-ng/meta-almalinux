# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "device-mapper-multipath"
PV = "0.9.9"
PR = "18.el10"
PACKAGES = " \
 device-mapper-multipath \
 device-mapper-multipath-devel \
 device-mapper-multipath-libs \
 kpartx \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/device-mapper-multipath-0.9.9-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a40ae720b6624e68f661c7710067ee779864793f46555ad293d2f9335282e29"

URI_x86_64_v2_device-mapper-multipath = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-multipath-0.9.9-18.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-multipath}"
SRC_URI[x86_64_v2_device-mapper-multipath.sha256sum] = "cb4d633e1debe3652a9bdccc5cdedc4f5f2b74611b59281dd50a027c9ab129c0"

URI_x86_64_v2_device-mapper-multipath-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/device-mapper-multipath-devel-0.9.9-18.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-multipath-devel}"
SRC_URI[x86_64_v2_device-mapper-multipath-devel.sha256sum] = "43b49f5418adf6a5264dbd516ad82f74ee76a9b2248bf635f7cfc6ddba6b67b0"

URI_x86_64_v2_device-mapper-multipath-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-multipath-libs-0.9.9-18.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-multipath-libs}"
SRC_URI[x86_64_v2_device-mapper-multipath-libs.sha256sum] = "f11958343a838d662dbd55391bc6977bb00bb37ef81e7a0c8782aea9033568c5"

URI_x86_64_v2_kpartx = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kpartx-0.9.9-18.el10.x86_64_v2.rpm;name=x86_64_v2_kpartx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpartx}"
SRC_URI[x86_64_v2_kpartx.sha256sum] = "7b083740ee4d5f533a554913204da2af5e93039a2dcd1674b0c00787491bc80b"

URI_aarch64_device-mapper-multipath = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-multipath-0.9.9-18.el10.aarch64.rpm;name=aarch64_device-mapper-multipath;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-multipath}"
SRC_URI[aarch64_device-mapper-multipath.sha256sum] = "ae2020ca6a42db76dbf837b0ec9803daddade47c4efe1ec9dc3a50928f80e64c"

URI_aarch64_device-mapper-multipath-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/device-mapper-multipath-devel-0.9.9-18.el10.aarch64.rpm;name=aarch64_device-mapper-multipath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-multipath-devel}"
SRC_URI[aarch64_device-mapper-multipath-devel.sha256sum] = "933ba6125653b1febbd82c9874ae21ace2c40488c881e206fc5470a79875e2c3"

URI_aarch64_device-mapper-multipath-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-multipath-libs-0.9.9-18.el10.aarch64.rpm;name=aarch64_device-mapper-multipath-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-multipath-libs}"
SRC_URI[aarch64_device-mapper-multipath-libs.sha256sum] = "339975cc8069bf937d77a60dfa79eb2a366acfee9237f88231402edbc6fce9f7"

URI_aarch64_kpartx = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kpartx-0.9.9-18.el10.aarch64.rpm;name=aarch64_kpartx;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpartx}"
SRC_URI[aarch64_kpartx.sha256sum] = "581b6ef634f6d747be26653cfbbdb9c5b4d3f7f616fe227f92e0605166ba12f8"

RDEPENDS:device-mapper-multipath = " \
 bash \
 device-mapper \
 device-mapper-libs \
 device-mapper-multipath-libs \
 glibc \
 kpartx \
 libgcc \
 libmount \
 readline \
 systemd \
 systemd-libs \
 userspace-rcu \
 "
RDEPENDS:device-mapper-multipath-devel = " \
 device-mapper-multipath \
 device-mapper-multipath-libs \
 "
RDEPENDS:device-mapper-multipath-libs = " \
 device-mapper-libs \
 glibc \
 libaio \
 libgcc \
 libmount \
 systemd-libs \
 userspace-rcu \
 "
RDEPENDS:kpartx = " \
 bash \
 device-mapper-libs \
 glibc \
 "
