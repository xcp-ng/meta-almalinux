# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-panic"
PV = "0.4.0.1"
PR = "6.el10_0"
PACKAGES = " \
 ghc-panic \
 ghc-panic-devel \
 ghc-panic-doc \
 ghc-panic-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-panic-0.4.0.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49bc3ccaae45287c9c01d07b3cdd3a073065c3f2dd46ceb802281f01222c95c8"

URI_x86_64_v2_ghc-panic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-panic-0.4.0.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-panic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-panic}"
SRC_URI[x86_64_v2_ghc-panic.sha256sum] = "9e57dc462a4af6639c977e9b6d1d0547fcedaa4347e38d381e02b2616b0f6e7e"

URI_x86_64_v2_ghc-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-panic-devel-0.4.0.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-panic-devel}"
SRC_URI[x86_64_v2_ghc-panic-devel.sha256sum] = "35f90cd9e7996f516aac9dde0c374d1463486200cc3cae44c6c2e8f00688be3d"

URI_x86_64_v2_ghc-panic-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-panic-doc-0.4.0.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-panic-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-panic-doc}"
SRC_URI[x86_64_v2_ghc-panic-doc.sha256sum] = "32b395c835c7e819578f597224f369b98174bbff499da6b1b4d63d0c8977b3d2"

URI_x86_64_v2_ghc-panic-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-panic-prof-0.4.0.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-panic-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-panic-prof}"
SRC_URI[x86_64_v2_ghc-panic-prof.sha256sum] = "cfba4e89835631dd99ea4c0516b91f2a6c3cb1ff61d22895107bab6dc4989228"

URI_aarch64_ghc-panic = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-panic-0.4.0.1-6.el10_0.aarch64.rpm;name=aarch64_ghc-panic;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-panic}"
SRC_URI[aarch64_ghc-panic.sha256sum] = "13a688cbc8019f874e4e2cce9ff9ece9455d60cb3cce4995121276fd7870bddc"

URI_aarch64_ghc-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-panic-devel-0.4.0.1-6.el10_0.aarch64.rpm;name=aarch64_ghc-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-panic-devel}"
SRC_URI[aarch64_ghc-panic-devel.sha256sum] = "6d7139b2033e77ea4b5409874211284f409df2e31a3efa340596f21f02549724"

URI_aarch64_ghc-panic-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-panic-doc-0.4.0.1-6.el10_0.noarch.rpm;name=aarch64_ghc-panic-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-panic-doc}"
SRC_URI[aarch64_ghc-panic-doc.sha256sum] = "d868d97b28cec7f27f12f962dee4049aa343d9e0e6356a26f75f3032fb232078"

URI_aarch64_ghc-panic-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-panic-prof-0.4.0.1-6.el10_0.aarch64.rpm;name=aarch64_ghc-panic-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-panic-prof}"
SRC_URI[aarch64_ghc-panic-prof.sha256sum] = "0d61ae2e1ca977532e5577db73ec3c9365afe41c773c7e980916664208280e7a"

RDEPENDS:ghc-panic = " \
 ghc-array \
 ghc-base \
 ghc-base-compat \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-gitrev \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-panic-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-gitrev-devel \
 ghc-panic \
 ghc-template-haskell-devel \
 "
RDEPENDS:ghc-panic-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-panic-prof = " \
 ghc-base-prof \
 ghc-gitrev-prof \
 ghc-panic-devel \
 ghc-template-haskell-prof \
 "
