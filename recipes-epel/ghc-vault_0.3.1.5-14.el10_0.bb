# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-vault"
PV = "0.3.1.5"
PR = "14.el10_0"
PACKAGES = " \
 ghc-vault \
 ghc-vault-devel \
 ghc-vault-doc \
 ghc-vault-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-vault-0.3.1.5-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d48446cd7f62e3d36236c00a29f896bf5593824871715b98857bce773bff860a"

URI_x86_64_v2_ghc-vault = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vault-0.3.1.5-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vault;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vault}"
SRC_URI[x86_64_v2_ghc-vault.sha256sum] = "827e5a8f5aaab855f0df3553e4f1936bcdd0f95d6d84aacb1e7a5e0e4e20f654"

URI_x86_64_v2_ghc-vault-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vault-devel-0.3.1.5-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vault-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vault-devel}"
SRC_URI[x86_64_v2_ghc-vault-devel.sha256sum] = "872884e13dc09866a48d7939f07cb89719b92bc5ebd9026c395aa7c836d27f42"

URI_x86_64_v2_ghc-vault-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vault-doc-0.3.1.5-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-vault-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vault-doc}"
SRC_URI[x86_64_v2_ghc-vault-doc.sha256sum] = "479654ee73e4e2d03076205da9b88c3a2c3fdf1cc049b66046cc8138070c9d0d"

URI_x86_64_v2_ghc-vault-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vault-prof-0.3.1.5-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vault-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vault-prof}"
SRC_URI[x86_64_v2_ghc-vault-prof.sha256sum] = "629334ebfaf3e57ecd7be9250be86707d6bfa6ce54315f2fdff80bbc86a80e61"

URI_aarch64_ghc-vault = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vault-0.3.1.5-14.el10_0.aarch64.rpm;name=aarch64_ghc-vault;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vault}"
SRC_URI[aarch64_ghc-vault.sha256sum] = "c25d763c79e0c5a7927ebeacbe3efe760eff32315eb59eee5027e7608807989d"

URI_aarch64_ghc-vault-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vault-devel-0.3.1.5-14.el10_0.aarch64.rpm;name=aarch64_ghc-vault-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vault-devel}"
SRC_URI[aarch64_ghc-vault-devel.sha256sum] = "3fa8fae5a7f4af09bfca0632d5d364e7d999df9c5788b943464696827990f7ed"

URI_aarch64_ghc-vault-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vault-doc-0.3.1.5-14.el10_0.noarch.rpm;name=aarch64_ghc-vault-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vault-doc}"
SRC_URI[aarch64_ghc-vault-doc.sha256sum] = "3fa731b1f75f5d33b80b8a511963bb4284f56e423a64d925f9fe02e25ca74545"

URI_aarch64_ghc-vault-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vault-prof-0.3.1.5-14.el10_0.aarch64.rpm;name=aarch64_ghc-vault-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vault-prof}"
SRC_URI[aarch64_ghc-vault-prof.sha256sum] = "917c6dd8d30bbc6e6b1c5ec0e95a990b573f55692d7b1c2a7e1e68c30f0cb893"

RDEPENDS:ghc-vault = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-unordered-containers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-vault-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-hashable-devel \
 ghc-unordered-containers-devel \
 ghc-vault \
 "
RDEPENDS:ghc-vault-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-vault-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-hashable-prof \
 ghc-unordered-containers-prof \
 ghc-vault-devel \
 "
