# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gsettings-desktop-schemas"
PV = "47.1"
PR = "4.el10"
PACKAGES = " \
 gsettings-desktop-schemas \
 gsettings-desktop-schemas-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gsettings-desktop-schemas-47.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f0a61f5b7012ba0f8f0ba9c764fa9869dac020b77332f9cdb4fd6e958cb96c6f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gsettings-desktop-schemas-47.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_gsettings-desktop-schemas;unpack=0"
SRC_URI[x86_64_v2_gsettings-desktop-schemas.sha256sum] = "ed554b10f16d295ee97c7c50ff3aa5ffef8de5bf17fc7279577fcd8202dddf33"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gsettings-desktop-schemas-devel-47.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_gsettings-desktop-schemas-devel;unpack=0"
SRC_URI[x86_64_v2_gsettings-desktop-schemas-devel.sha256sum] = "bcf2f67dff7536df05c74030786bb7eaeef6fa174746b73ace871efb3f71557f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gsettings-desktop-schemas-47.1-4.el10.aarch64.rpm;name=aarch64_gsettings-desktop-schemas;unpack=0"
SRC_URI[aarch64_gsettings-desktop-schemas.sha256sum] = "86f9b97e01333d5931bb67b9f8b4a6955311901a3d4248cd12de428009538451"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gsettings-desktop-schemas-devel-47.1-4.el10.aarch64.rpm;name=aarch64_gsettings-desktop-schemas-devel;unpack=0"
SRC_URI[aarch64_gsettings-desktop-schemas-devel.sha256sum] = "45c1917ea65c3dfbded12feb1616545d70d35d579b859a2ac46747bdea674207"

RDEPENDS:gsettings-desktop-schemas = " \
 glib2 \
 "
RDEPENDS:gsettings-desktop-schemas-devel = " \
 gsettings-desktop-schemas \
 pkgconf-pkg-config \
 "
