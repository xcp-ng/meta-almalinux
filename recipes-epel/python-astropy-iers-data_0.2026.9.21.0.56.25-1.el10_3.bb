# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-astropy-iers-data"
PV = "0.2026.9.21.0.56.25"
PR = "1.el10_3"
PACKAGES = " \
 python3-astropy-iers-data \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-astropy-iers-data-0.2026.9.21.0.56.25-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5dd4977d9276198276bfbe9993a1d2b5aaeda7aac7d66a9c9beb39a90cbfd5b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-astropy-iers-data-0.2026.9.21.0.56.25-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-astropy-iers-data;unpack=0"
SRC_URI[x86_64_v2_python3-astropy-iers-data.sha256sum] = "46fd0bcaa1dced9321bfe2487658f8883678a2063a9e2400170342990ff73648"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-astropy-iers-data-0.2026.9.21.0.56.25-1.el10_3.noarch.rpm;name=aarch64_python3-astropy-iers-data;unpack=0"
SRC_URI[aarch64_python3-astropy-iers-data.sha256sum] = "0c2a169d732597669c694485d3a2d987795a5e2d1b06e06a3bc33d1ecd0dc3b0"

RDEPENDS:python3-astropy-iers-data = " \
 python3 \
 "
