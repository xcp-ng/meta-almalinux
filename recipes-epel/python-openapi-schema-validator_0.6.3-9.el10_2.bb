# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openapi-schema-validator"
PV = "0.6.3"
PR = "9.el10_2"
PACKAGES = " \
 python3-openapi-schema-validator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openapi-schema-validator-0.6.3-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc4de6e60b9374da0743ded59ee6164c23d38ebaa0bc8dc5893c2d8dfcb81693"

URI_x86_64_v2_python3-openapi-schema-validator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-schema-validator-0.6.3-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-schema-validator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-schema-validator}"
SRC_URI[x86_64_v2_python3-openapi-schema-validator.sha256sum] = "ad3898d0f6009283003f7fc8348b86906cf719d123fd0dce1e8e4a0896d9ad54"

URI_aarch64_python3-openapi-schema-validator = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-schema-validator-0.6.3-9.el10_2.noarch.rpm;name=aarch64_python3-openapi-schema-validator;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-schema-validator}"
SRC_URI[aarch64_python3-openapi-schema-validator.sha256sum] = "b9d17d3c955b1b46b9b784c6e21c2636bcb51d8f84edda066ab191b280f90f7e"

RDEPENDS:python3-openapi-schema-validator = " \
 python3 \
 python3-jsonschema \
 python3-jsonschema-specifications \
 python3-rfc3339-validator \
 "
