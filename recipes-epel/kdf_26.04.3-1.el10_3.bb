# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdf"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdf-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "015d6958e2ba3ec1fa9952722ef0715e7bd3d906c0a24d008a7243ce9b674e7e"

URI_x86_64_v2_kdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdf-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdf}"
SRC_URI[x86_64_v2_kdf.sha256sum] = "26ddce412ef546f38806c8c1d2298c683370fa9f0e381a378fdb72f02a6eee78"

URI_aarch64_kdf = "${EPEL_MIRROR}/aarch64/Packages/k/kdf-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdf}"
SRC_URI[aarch64_kdf.sha256sum] = "f361f2e4516aa3100894916f60095333ef1980c6d424ccf81cfab013f2817cf0"

RDEPENDS:kdf = " \
 glibc \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
