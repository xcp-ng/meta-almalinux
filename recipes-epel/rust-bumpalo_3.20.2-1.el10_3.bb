# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bumpalo"
PV = "3.20.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-bumpalo+allocator-api2-devel \
 rust-bumpalo+allocator_api-devel \
 rust-bumpalo+boxed-devel \
 rust-bumpalo+collections-devel \
 rust-bumpalo+default-devel \
 rust-bumpalo+serde-devel \
 rust-bumpalo+std-devel \
 rust-bumpalo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bumpalo-3.20.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a17fa47eef8225b204a4687dd79cc5bacc7723b4893877023d429eac27ad321b"

URI_x86_64_v2_rust-bumpalo+allocator-api2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+allocator-api2-devel-3.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+allocator-api2-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+allocator-api2-devel.sha256sum] = "d26e397e4e666ca121743733af470a59bce0400103d3b70fb7e1021bbbf42782"

URI_x86_64_v2_rust-bumpalo+allocator_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+allocator_api-devel-3.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+allocator_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+allocator_api-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+allocator_api-devel.sha256sum] = "07c243794ad038f478390a74a7d36e0bfbf060dc5d48f4c0f51988cc72030b27"

URI_x86_64_v2_rust-bumpalo+boxed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+boxed-devel-3.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+boxed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+boxed-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+boxed-devel.sha256sum] = "0a6fafd09debad0108478980c8ddbaa0ae68917b0ab3b66a8cab96c4d741fd1a"

URI_x86_64_v2_rust-bumpalo+collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+collections-devel-3.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+collections-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+collections-devel.sha256sum] = "f0622616e144ce59029b3182c9b40486074508b329840da58a78c32892e582a3"

URI_x86_64_v2_rust-bumpalo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+default-devel-3.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+default-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+default-devel.sha256sum] = "8d7c0dd2a0f8415e37ae10abfa657c4b4da40bf8c51866f25686b92306b53400"

URI_x86_64_v2_rust-bumpalo+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+serde-devel-3.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+serde-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+serde-devel.sha256sum] = "05bf7277eb91aa2144d9792470c5691419fe0e703b8b796793a07c374a9b2c22"

URI_x86_64_v2_rust-bumpalo+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+std-devel-3.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+std-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+std-devel.sha256sum] = "42468a7db9259b3749e661c06f8365d53b6e1a3a977f58f206d2d1ec4458e782"

URI_x86_64_v2_rust-bumpalo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo-devel-3.20.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo-devel}"
SRC_URI[x86_64_v2_rust-bumpalo-devel.sha256sum] = "8d9984cd40498281832d66bc299ff9e4e0dd6636ceb2975284770e26ddc5d165"

URI_aarch64_rust-bumpalo+allocator-api2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+allocator-api2-devel-3.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-bumpalo+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+allocator-api2-devel}"
SRC_URI[aarch64_rust-bumpalo+allocator-api2-devel.sha256sum] = "2a83574e00156beef82bc1a64fd26deab6774d812805ccd573b7046f4963c3ab"

URI_aarch64_rust-bumpalo+allocator_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+allocator_api-devel-3.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-bumpalo+allocator_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+allocator_api-devel}"
SRC_URI[aarch64_rust-bumpalo+allocator_api-devel.sha256sum] = "5a336a3794bb9719ae6d0718f7aff5a1b17a87bbe462811afb021d7b113f3a05"

URI_aarch64_rust-bumpalo+boxed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+boxed-devel-3.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-bumpalo+boxed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+boxed-devel}"
SRC_URI[aarch64_rust-bumpalo+boxed-devel.sha256sum] = "68ab0c3ce38b5ffe6d8d78cd9af92fd59d41d950ff173c96e080247576934cf0"

URI_aarch64_rust-bumpalo+collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+collections-devel-3.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-bumpalo+collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+collections-devel}"
SRC_URI[aarch64_rust-bumpalo+collections-devel.sha256sum] = "4ab2f79f8e76b5f63d9c46298b1cd909492773193e7a4ed04b014c5952ec750b"

URI_aarch64_rust-bumpalo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+default-devel-3.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-bumpalo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+default-devel}"
SRC_URI[aarch64_rust-bumpalo+default-devel.sha256sum] = "5842974075118e7d5867200a1ae344464821e645a0984d0dc786f363db80b79d"

URI_aarch64_rust-bumpalo+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+serde-devel-3.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-bumpalo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+serde-devel}"
SRC_URI[aarch64_rust-bumpalo+serde-devel.sha256sum] = "475a2b3ced91a1c29eda9a5bc496884d5add753fc221fa89ed3eae49e897c27f"

URI_aarch64_rust-bumpalo+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+std-devel-3.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-bumpalo+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+std-devel}"
SRC_URI[aarch64_rust-bumpalo+std-devel.sha256sum] = "d617cba3d39536a3e69dad39fb0a0ce859df9af0b92b1392a24387bb2ae4133d"

URI_aarch64_rust-bumpalo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo-devel-3.20.2-1.el10_3.noarch.rpm;name=aarch64_rust-bumpalo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo-devel}"
SRC_URI[aarch64_rust-bumpalo-devel.sha256sum] = "4999354869af5a023a1e92559bb174aaeb6525602e44fd0da583c300495cfb51"

RDEPENDS:rust-bumpalo+allocator-api2-devel = " \
 cargo \
 rust-allocator-api2-devel \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+allocator_api-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+boxed-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+collections-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+default-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+serde-devel = " \
 cargo \
 rust-bumpalo-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-bumpalo+std-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo-devel = " \
 cargo \
 rust \
 "
