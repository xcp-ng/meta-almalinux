# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ongres-scram"
PV = "2.1"
PR = "17.el10"
PACKAGES = " \
 ongres-scram \
 ongres-scram-client \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ongres-scram-2.1-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be0756cd1bee0bc8870a083827c0c1a75852da03e66107e00e0cd487160ca970"

URI_x86_64_v2_ongres-scram = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ongres-scram-2.1-17.el10.noarch.rpm;name=x86_64_v2_ongres-scram;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ongres-scram}"
SRC_URI[x86_64_v2_ongres-scram.sha256sum] = "e4ff13a79af57943125ea128e4837a011d64d07289f170b6eb5b8a529a736c08"

URI_x86_64_v2_ongres-scram-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ongres-scram-client-2.1-17.el10.noarch.rpm;name=x86_64_v2_ongres-scram-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ongres-scram-client}"
SRC_URI[x86_64_v2_ongres-scram-client.sha256sum] = "fdcb361369420d31a0a978db78e407c1380539f7e96489e551132974a67accb4"

URI_aarch64_ongres-scram = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ongres-scram-2.1-17.el10.noarch.rpm;name=aarch64_ongres-scram;unpack=0"
SRC_URI:append = " ${URI_aarch64_ongres-scram}"
SRC_URI[aarch64_ongres-scram.sha256sum] = "e4ff13a79af57943125ea128e4837a011d64d07289f170b6eb5b8a529a736c08"

URI_aarch64_ongres-scram-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ongres-scram-client-2.1-17.el10.noarch.rpm;name=aarch64_ongres-scram-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_ongres-scram-client}"
SRC_URI[aarch64_ongres-scram-client.sha256sum] = "fdcb361369420d31a0a978db78e407c1380539f7e96489e551132974a67accb4"

RDEPENDS:ongres-scram = " \
 javapackages-filesystem \
 ongres-stringprep \
 "
RDEPENDS:ongres-scram-client = " \
 javapackages-filesystem \
 ongres-scram \
 "
