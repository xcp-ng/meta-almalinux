# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursive0.20"
PV = "0.20.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-cursive0.20+crossterm-backend-devel \
 rust-cursive0.20+crossterm-devel \
 rust-cursive0.20+default-devel \
 rust-cursive0.20+doc-cfg-devel \
 rust-cursive0.20+maplit-devel \
 rust-cursive0.20+term_size-devel \
 rust-cursive0.20+termion-backend-devel \
 rust-cursive0.20+termion-devel \
 rust-cursive0.20+toml-devel \
 rust-cursive0.20+unstable_scroll-devel \
 rust-cursive0.20-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursive0.20-0.20.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3eb9dc9ff2bb374a0a348ddd316e7f2cfdadeff4e1770930064a6cc53e769b60"

URI_x86_64_v2_rust-cursive0.20+crossterm-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+crossterm-backend-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+crossterm-backend-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+crossterm-backend-devel.sha256sum] = "9831a3f0545386219896f08492c4da5f8384b0b64d04a27ac91c288bc2ec2174"

URI_x86_64_v2_rust-cursive0.20+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+crossterm-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+crossterm-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+crossterm-devel.sha256sum] = "ffba4384fc2902961abcd757bc937ad30f50134afcc7971bad8db49a5d1333da"

URI_x86_64_v2_rust-cursive0.20+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+default-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+default-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+default-devel.sha256sum] = "c7a3543fe10ad0fc3919f26955a60f6fea721baa42c5fe8eeb5a3b246f7392e8"

URI_x86_64_v2_rust-cursive0.20+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+doc-cfg-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+doc-cfg-devel.sha256sum] = "bb76e752710fdc321a06236e0e6bbd460a5076967a9bebdbd50db06af9f4c1f9"

URI_x86_64_v2_rust-cursive0.20+maplit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+maplit-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+maplit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+maplit-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+maplit-devel.sha256sum] = "f6e10f823480bc1dca2a465c971f943935403b9c1239bc78f10173d280517765"

URI_x86_64_v2_rust-cursive0.20+term_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+term_size-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+term_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+term_size-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+term_size-devel.sha256sum] = "a9a34554443b4b5b77845ae8d87a9c1e83b8ef0c16ace1ab58043a20b585997a"

URI_x86_64_v2_rust-cursive0.20+termion-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+termion-backend-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+termion-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+termion-backend-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+termion-backend-devel.sha256sum] = "af33c75a9b9925b2f49a6a1b7b9f9f6441fa51762e409b50c615942e8de62c8f"

URI_x86_64_v2_rust-cursive0.20+termion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+termion-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+termion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+termion-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+termion-devel.sha256sum] = "8676ebad933bd415813c7985637ff068b96610a462021336e04a7f02bd666cdf"

URI_x86_64_v2_rust-cursive0.20+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+toml-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+toml-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+toml-devel.sha256sum] = "971f2dd598c2dfa755454583370b875aeab22240475e4f4e9aa7eb8c482bcf5d"

URI_x86_64_v2_rust-cursive0.20+unstable_scroll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+unstable_scroll-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+unstable_scroll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+unstable_scroll-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+unstable_scroll-devel.sha256sum] = "27c7451022f17839b4394ba33eef1ed735d9044b24548bc62a90a7fc60bcc6fe"

URI_x86_64_v2_rust-cursive0.20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20-devel.sha256sum] = "e12e08f0ae5f7194f8c48fe2f5b2fe3f1736e1f1a17ee67871ecf21dc91b3a2b"

URI_aarch64_rust-cursive0.20+crossterm-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+crossterm-backend-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-cursive0.20+crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+crossterm-backend-devel}"
SRC_URI[aarch64_rust-cursive0.20+crossterm-backend-devel.sha256sum] = "5ce7a1f6fc2576ba8ea79b3c8907ee5e3dea714119c2112f0657f268c14bd395"

URI_aarch64_rust-cursive0.20+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+crossterm-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-cursive0.20+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+crossterm-devel}"
SRC_URI[aarch64_rust-cursive0.20+crossterm-devel.sha256sum] = "7c95774a7207bd10238d22fb55062635977c2ebefb31f38e8c3c34b59338a347"

URI_aarch64_rust-cursive0.20+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+default-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-cursive0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+default-devel}"
SRC_URI[aarch64_rust-cursive0.20+default-devel.sha256sum] = "38be6c211ad72c2d3ed8dc5f8c83935a25658602ec427689a782a3a9a951a2a1"

URI_aarch64_rust-cursive0.20+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+doc-cfg-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-cursive0.20+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+doc-cfg-devel}"
SRC_URI[aarch64_rust-cursive0.20+doc-cfg-devel.sha256sum] = "2de0a7b1fb39606e1fb56500b10d0b9c2f7d063e56c64c31117afa9f0daa1663"

URI_aarch64_rust-cursive0.20+maplit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+maplit-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-cursive0.20+maplit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+maplit-devel}"
SRC_URI[aarch64_rust-cursive0.20+maplit-devel.sha256sum] = "f8ee212408400829f306f7d57784d92f8853f44823630e9c46e21154f44c5ca9"

URI_aarch64_rust-cursive0.20+term_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+term_size-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-cursive0.20+term_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+term_size-devel}"
SRC_URI[aarch64_rust-cursive0.20+term_size-devel.sha256sum] = "fd5575aa7179990c17d8805b21fbb6bf2c594a557fdc7d227769acfef9cf9ccc"

URI_aarch64_rust-cursive0.20+termion-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+termion-backend-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-cursive0.20+termion-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+termion-backend-devel}"
SRC_URI[aarch64_rust-cursive0.20+termion-backend-devel.sha256sum] = "be12386daf1c72723daf74e1e307adeadf948c5004d6e29e43ab66413cdd1733"

URI_aarch64_rust-cursive0.20+termion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+termion-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-cursive0.20+termion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+termion-devel}"
SRC_URI[aarch64_rust-cursive0.20+termion-devel.sha256sum] = "ce6eeb155afc0d7e8f8f7e66de38016598dfaba36ab029f2d06b2fb054876297"

URI_aarch64_rust-cursive0.20+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+toml-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-cursive0.20+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+toml-devel}"
SRC_URI[aarch64_rust-cursive0.20+toml-devel.sha256sum] = "216623cf1ac676396718c8c78cc9eca09379694c1a1127c0493446e94bf8922f"

URI_aarch64_rust-cursive0.20+unstable_scroll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+unstable_scroll-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-cursive0.20+unstable_scroll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+unstable_scroll-devel}"
SRC_URI[aarch64_rust-cursive0.20+unstable_scroll-devel.sha256sum] = "6bf61a7ec3f0e3885739183fc4549e1cca19b23225826dfa7e616b6070ee51bd"

URI_aarch64_rust-cursive0.20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-cursive0.20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20-devel}"
SRC_URI[aarch64_rust-cursive0.20-devel.sha256sum] = "110551da6c29285227d199b5de68ecdc02906703ba31a16c1f56f3c85256e463"

RDEPENDS:rust-cursive0.20+crossterm-backend-devel = " \
 cargo \
 rust-cursive0.20+crossterm-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+crossterm-devel = " \
 cargo \
 rust-crossterm0.25+default-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+default-devel = " \
 cargo \
 rust-cursive0.20+crossterm-backend-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+doc-cfg-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-cursive_core0.3+doc-cfg-devel \
 "
RDEPENDS:rust-cursive0.20+maplit-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-maplit+default-devel \
 "
RDEPENDS:rust-cursive0.20+term_size-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-term_size+default-devel \
 "
RDEPENDS:rust-cursive0.20+termion-backend-devel = " \
 cargo \
 rust-cursive0.20+termion-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+termion-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-termion+default-devel \
 "
RDEPENDS:rust-cursive0.20+toml-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-cursive_core0.3+toml-devel \
 "
RDEPENDS:rust-cursive0.20+unstable_scroll-devel = " \
 cargo \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20-devel = " \
 cargo \
 rust-ahash+default-devel \
 rust-cfg-if+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-cursive_core0.3+default-devel \
 rust-lazy_static+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-signal-hook+default-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width0.1+default-devel \
 "
