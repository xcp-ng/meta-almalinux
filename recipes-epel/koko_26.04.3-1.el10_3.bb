# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koko"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 koko \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/koko-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bab66ef3df3e5cd977486b8bf8e23efef5d2247aef7ca733f89fa2b3dc40df90"

URI_x86_64_v2_koko = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koko-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_koko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koko}"
SRC_URI[x86_64_v2_koko.sha256sum] = "65f3701fa1564427353d2c24b8d793e7d90d97a8bb2342b60a1fa2f98c858f3a"

URI_aarch64_koko = "${EPEL_MIRROR}/aarch64/Packages/k/koko-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_koko;unpack=0"
SRC_URI:append = " ${URI_aarch64_koko}"
SRC_URI[aarch64_koko.sha256sum] = "5034e31f28fedcd52d1300a6a6fc099fed95c946430361dbcfc966042984204a"

RDEPENDS:koko = " \
 exiv2-libs \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kwindowsystem \
 kf6-purpose \
 kquickimageeditor-qt6 \
 libgcc \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qt6-qtsvg \
 "
