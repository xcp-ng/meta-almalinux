# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtk3"
PV = "3.24.43"
PR = "5.el10"
PACKAGES = " \
 gtk-update-icon-cache \
 gtk3 \
 gtk3-devel \
 gtk3-devel-docs \
 gtk3-immodule-xim \
 gtk3-immodules \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gtk3-3.24.43-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3044d289310ccb0542d360df94c6f5c604b15bb64425bcafc0e12b2f3193fa24"

URI_x86_64_v2_gtk-update-icon-cache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk-update-icon-cache-3.24.43-5.el10.x86_64_v2.rpm;name=x86_64_v2_gtk-update-icon-cache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk-update-icon-cache}"
SRC_URI[x86_64_v2_gtk-update-icon-cache.sha256sum] = "f20b54080cc827b56813cee770f4ee0e7626e80cfd42ea8baf4ab7b9d73053dd"

URI_x86_64_v2_gtk3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk3-3.24.43-5.el10.x86_64_v2.rpm;name=x86_64_v2_gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk3}"
SRC_URI[x86_64_v2_gtk3.sha256sum] = "2e2b7bd028c9b6d45f5f35d2b7aa87a407922ba049817b98c69d918e392d9241"

URI_x86_64_v2_gtk3-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk3-devel-3.24.43-5.el10.x86_64_v2.rpm;name=x86_64_v2_gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk3-devel}"
SRC_URI[x86_64_v2_gtk3-devel.sha256sum] = "2f86b853b1931bb1dc117c3f918b7f55a8771e34997fd7623509c8daa615314f"

URI_x86_64_v2_gtk3-devel-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtk3-devel-docs-3.24.43-5.el10.x86_64_v2.rpm;name=x86_64_v2_gtk3-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk3-devel-docs}"
SRC_URI[x86_64_v2_gtk3-devel-docs.sha256sum] = "f666e2db450e6560e46ab5d4eb9bb9acec216004782919a0cc008cc8a41d2b24"

URI_x86_64_v2_gtk3-immodule-xim = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk3-immodule-xim-3.24.43-5.el10.x86_64_v2.rpm;name=x86_64_v2_gtk3-immodule-xim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk3-immodule-xim}"
SRC_URI[x86_64_v2_gtk3-immodule-xim.sha256sum] = "c0a58865e437ab73f9725568102c67b5d5bf575384d82c3d350e40399c4d8c89"

URI_x86_64_v2_gtk3-immodules = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk3-immodules-3.24.43-5.el10.x86_64_v2.rpm;name=x86_64_v2_gtk3-immodules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk3-immodules}"
SRC_URI[x86_64_v2_gtk3-immodules.sha256sum] = "06571159902ed69c84083136f649a5c2f3ad740289eef1b2ca6f55bb9d9a16a6"

URI_aarch64_gtk-update-icon-cache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk-update-icon-cache-3.24.43-5.el10.aarch64.rpm;name=aarch64_gtk-update-icon-cache;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk-update-icon-cache}"
SRC_URI[aarch64_gtk-update-icon-cache.sha256sum] = "18276ae8d7bbe5eb1f64ab0cc1971faf0df10aeecdabf95fb27f92696028d58d"

URI_aarch64_gtk3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk3-3.24.43-5.el10.aarch64.rpm;name=aarch64_gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk3}"
SRC_URI[aarch64_gtk3.sha256sum] = "3ca4943509bb432cb96b518a18c3c89c4ebe99e74eb0b8e693261459236a2423"

URI_aarch64_gtk3-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk3-devel-3.24.43-5.el10.aarch64.rpm;name=aarch64_gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk3-devel}"
SRC_URI[aarch64_gtk3-devel.sha256sum] = "69c3768d942b86cc24464b6f4747ec34a8ed20db3ed6dd58f6870ed46a2c96b2"

URI_aarch64_gtk3-devel-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtk3-devel-docs-3.24.43-5.el10.aarch64.rpm;name=aarch64_gtk3-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk3-devel-docs}"
SRC_URI[aarch64_gtk3-devel-docs.sha256sum] = "7909b3b4bb29fda0aa595eef83f67b273de6528b9a1dfd8384fd769831ed29dd"

URI_aarch64_gtk3-immodule-xim = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk3-immodule-xim-3.24.43-5.el10.aarch64.rpm;name=aarch64_gtk3-immodule-xim;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk3-immodule-xim}"
SRC_URI[aarch64_gtk3-immodule-xim.sha256sum] = "6f9fe7f560d2e73c396c9454dba22763bd7839b0b0d6ecf35adc536ff8b21855"

URI_aarch64_gtk3-immodules = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk3-immodules-3.24.43-5.el10.aarch64.rpm;name=aarch64_gtk3-immodules;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk3-immodules}"
SRC_URI[aarch64_gtk3-immodules.sha256sum] = "3c04cf8f44c191e5435a7a9cff8f6d42369022998edc896c73ca2d816d0b4d82"

RDEPENDS:gtk-update-icon-cache = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 "
RDEPENDS:gtk3 = " \
 adwaita-icon-theme \
 at-spi2-atk \
 atk \
 bash \
 cairo \
 cairo-gobject \
 colord-libs \
 cups-libs \
 fontconfig \
 fribidi \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules \
 glib2 \
 glibc \
 gtk-update-icon-cache \
 harfbuzz \
 hicolor-icon-theme \
 libX11 \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libepoxy \
 libtracker-sparql \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxkbcommon \
 pango \
 "
RDEPENDS:gtk3-devel = " \
 at-spi2-atk-devel \
 atk \
 atk-devel \
 cairo \
 cairo-devel \
 cairo-gobject-devel \
 fontconfig-devel \
 fribidi-devel \
 gdk-pixbuf2 \
 gdk-pixbuf2-devel \
 glib2 \
 glib2-devel \
 glibc \
 gtk3 \
 gtk3-devel \
 harfbuzz \
 libX11-devel \
 libXcomposite-devel \
 libXcursor-devel \
 libXdamage-devel \
 libXext-devel \
 libXfixes-devel \
 libXi-devel \
 libXinerama-devel \
 libXrandr-devel \
 libepoxy \
 libepoxy-devel \
 libxkbcommon-devel \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 wayland-devel \
 "
RDEPENDS:gtk3-devel-docs = " \
 gtk3 \
 "
RDEPENDS:gtk3-immodule-xim = " \
 glib2 \
 glibc \
 gtk3 \
 libX11 \
 pango \
 "
RDEPENDS:gtk3-immodules = " \
 glib2 \
 glibc \
 gtk3 \
 pango \
 "
