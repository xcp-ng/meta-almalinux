# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-supports-hyperlinks"
PV = "3.1.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-supports-hyperlinks+default-devel \
 rust-supports-hyperlinks-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-supports-hyperlinks-3.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37e9d8c82d96e99e21a2d6841e14ccc80cb8195706c6e441d097b9cc8db6501e"

URI_x86_64_v2_rust-supports-hyperlinks+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-supports-hyperlinks+default-devel-3.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-supports-hyperlinks+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-supports-hyperlinks+default-devel}"
SRC_URI[x86_64_v2_rust-supports-hyperlinks+default-devel.sha256sum] = "4d8b7f6c21b5160dfc20364fe013e57866ce0491e9278a2c40d518d77aa79e8e"

URI_x86_64_v2_rust-supports-hyperlinks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-supports-hyperlinks-devel-3.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-supports-hyperlinks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-supports-hyperlinks-devel}"
SRC_URI[x86_64_v2_rust-supports-hyperlinks-devel.sha256sum] = "29edd7242707bee845551bb6b0087160ce1853bc8f36f90e0285657246398d34"

URI_aarch64_rust-supports-hyperlinks+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-supports-hyperlinks+default-devel-3.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-supports-hyperlinks+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-supports-hyperlinks+default-devel}"
SRC_URI[aarch64_rust-supports-hyperlinks+default-devel.sha256sum] = "d3c3df2a7b9787e7b45013ec8ac20e8478d8500960b3def09d54837ca9e651a9"

URI_aarch64_rust-supports-hyperlinks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-supports-hyperlinks-devel-3.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-supports-hyperlinks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-supports-hyperlinks-devel}"
SRC_URI[aarch64_rust-supports-hyperlinks-devel.sha256sum] = "72359ace8865dd410e38a6b30aa335c32c0adfbc03fd618bf964f4538ac3de25"

RDEPENDS:rust-supports-hyperlinks+default-devel = " \
 cargo \
 rust-supports-hyperlinks-devel \
 "
RDEPENDS:rust-supports-hyperlinks-devel = " \
 cargo \
 rust \
 "
