# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtsensors"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtsensors \
 qt5-qtsensors-devel \
 qt5-qtsensors-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtsensors-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "709fc50f0bebcdd434f018bea7de1962fa6eabfce1b4fa372ab3f8373f9712f8"

URI_x86_64_v2_qt5-qtsensors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsensors-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsensors}"
SRC_URI[x86_64_v2_qt5-qtsensors.sha256sum] = "abc9705fcdcffbb26510dd1a6fa6c081a0d73bfe5f5416af81d6d0de0c8259a4"

URI_x86_64_v2_qt5-qtsensors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsensors-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsensors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsensors-devel}"
SRC_URI[x86_64_v2_qt5-qtsensors-devel.sha256sum] = "69ca89dbe2dd846089391cf1df6c2942e030a10ef062d54f2d07db79d4d69143"

URI_x86_64_v2_qt5-qtsensors-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsensors-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsensors-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsensors-examples}"
SRC_URI[x86_64_v2_qt5-qtsensors-examples.sha256sum] = "bcd341f7820babe0ede5accd32e175d3d3f94562267e46ce8aca0c6c22d21561"

URI_aarch64_qt5-qtsensors = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsensors-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtsensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsensors}"
SRC_URI[aarch64_qt5-qtsensors.sha256sum] = "1ff06652e6c8270121c6a89ec1dbe8d698cb57b82cdef3b9688ba7fb2daecb5b"

URI_aarch64_qt5-qtsensors-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsensors-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtsensors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsensors-devel}"
SRC_URI[aarch64_qt5-qtsensors-devel.sha256sum] = "b91943a56fa410f3360dc960f3ff5ebc057765b2b62343c699b0c3cb2598582e"

URI_aarch64_qt5-qtsensors-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsensors-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtsensors-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsensors-examples}"
SRC_URI[aarch64_qt5-qtsensors-examples.sha256sum] = "a7b1b9b3cb02018d205dceade6d8a060d6ac80fcec8448428eeb334770ad5f07"

RDEPENDS:qt5-qtsensors = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtsensors-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtsensors \
 "
RDEPENDS:qt5-qtsensors-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtsensors \
 "
