# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-os_str_bytes"
PV = "7.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-os_str_bytes+checked_conversions-devel \
 rust-os_str_bytes+conversions-devel \
 rust-os_str_bytes+default-devel \
 rust-os_str_bytes+memchr-devel \
 rust-os_str_bytes+raw_os_str-devel \
 rust-os_str_bytes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-os_str_bytes-7.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edcc278fa6d5e3d0a4b4f845d37ab954e7010e6ab0f4b81c71aa461184d8a2d2"

URI_x86_64_v2_rust-os_str_bytes+checked_conversions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+checked_conversions-devel-7.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+checked_conversions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+checked_conversions-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+checked_conversions-devel.sha256sum] = "12e94d0167e80f2e5c9bd1f1bbe96181011fd2a04931d691a78b201a98951450"

URI_x86_64_v2_rust-os_str_bytes+conversions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+conversions-devel-7.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+conversions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+conversions-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+conversions-devel.sha256sum] = "cab04d0aaa732075bbbd19b7657e3cdfdfb5f25050d03ca663ce0342a25ff2de"

URI_x86_64_v2_rust-os_str_bytes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+default-devel-7.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+default-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+default-devel.sha256sum] = "6c5a4867cd5776eee8a750edca496594148d304fecfb521e480560e45de05cb4"

URI_x86_64_v2_rust-os_str_bytes+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+memchr-devel-7.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+memchr-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+memchr-devel.sha256sum] = "426bc388b81dfa423281eed04750603ef98b2fcb36ad0839412937b758c8523c"

URI_x86_64_v2_rust-os_str_bytes+raw_os_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+raw_os_str-devel-7.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+raw_os_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+raw_os_str-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+raw_os_str-devel.sha256sum] = "0d2ac58ffdd4406f0cb8675f0922098d7d2699c674588636c9f043bd6cb15ae1"

URI_x86_64_v2_rust-os_str_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes-devel-7.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes-devel.sha256sum] = "f89c11dfa34a39b6fd28512030f6cd902dcf4c240b9d1f1f5e9b38622f16047f"

URI_aarch64_rust-os_str_bytes+checked_conversions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+checked_conversions-devel-7.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-os_str_bytes+checked_conversions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+checked_conversions-devel}"
SRC_URI[aarch64_rust-os_str_bytes+checked_conversions-devel.sha256sum] = "77429dd1dccccb71c7e4a1a94671749b1787eeb146f44425d522bd8b61e413b2"

URI_aarch64_rust-os_str_bytes+conversions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+conversions-devel-7.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-os_str_bytes+conversions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+conversions-devel}"
SRC_URI[aarch64_rust-os_str_bytes+conversions-devel.sha256sum] = "f0927f37d569f8dda832d96026b508632a0204002849177971cb5cf360affb9b"

URI_aarch64_rust-os_str_bytes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+default-devel-7.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-os_str_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+default-devel}"
SRC_URI[aarch64_rust-os_str_bytes+default-devel.sha256sum] = "4a85731f54d7d1c1e2f6fce69faa0f088b847f636bfb8fbe846e8a38ca3942bd"

URI_aarch64_rust-os_str_bytes+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+memchr-devel-7.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-os_str_bytes+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+memchr-devel}"
SRC_URI[aarch64_rust-os_str_bytes+memchr-devel.sha256sum] = "355bd92e4df6b8e9c31f595041d900455db1ff4f5dd9202e5eec5494e6a73c6a"

URI_aarch64_rust-os_str_bytes+raw_os_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+raw_os_str-devel-7.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-os_str_bytes+raw_os_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+raw_os_str-devel}"
SRC_URI[aarch64_rust-os_str_bytes+raw_os_str-devel.sha256sum] = "4d72096c0438b2d1865bde7f8feaf287a31b325d565c153fe44114b49782a45f"

URI_aarch64_rust-os_str_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes-devel-7.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes-devel}"
SRC_URI[aarch64_rust-os_str_bytes-devel.sha256sum] = "ae9e20893c38b1685dfe0bab2b492b861406d241a035f91be448a5fb83eb21f1"

RDEPENDS:rust-os_str_bytes+checked_conversions-devel = " \
 cargo \
 rust-os_str_bytes+conversions-devel \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+conversions-devel = " \
 cargo \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+default-devel = " \
 cargo \
 rust-os_str_bytes+memchr-devel \
 rust-os_str_bytes+raw_os_str-devel \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+memchr-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+raw_os_str-devel = " \
 cargo \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes-devel = " \
 cargo \
 rust \
 "
