# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-term_grid"
PV = "0.1.7"
PR = "24.el10_3"
PACKAGES = " \
 rust-term_grid+default-devel \
 rust-term_grid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-term_grid-0.1.7-24.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "842a67a0d3d60d34b199f36bc29349980ac8cf7f31c63639953996382aa185d7"

URI_x86_64_v2_rust-term_grid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term_grid+default-devel-0.1.7-24.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term_grid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term_grid+default-devel}"
SRC_URI[x86_64_v2_rust-term_grid+default-devel.sha256sum] = "06b524002225e3c23a6cd7a20052bc49dfd0694c12c0f3481c1e3372d908e2a6"

URI_x86_64_v2_rust-term_grid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term_grid-devel-0.1.7-24.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term_grid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term_grid-devel}"
SRC_URI[x86_64_v2_rust-term_grid-devel.sha256sum] = "f384f21391fb683cfcbb92367aae157ce1062c05d6d2c27a562f6c69ec0bbf7b"

URI_aarch64_rust-term_grid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term_grid+default-devel-0.1.7-24.el10_3.noarch.rpm;name=aarch64_rust-term_grid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term_grid+default-devel}"
SRC_URI[aarch64_rust-term_grid+default-devel.sha256sum] = "d80d6e8c8bce0428b7939ce27f014cfa26b5746eb573ffc02aacba6f90f4271b"

URI_aarch64_rust-term_grid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term_grid-devel-0.1.7-24.el10_3.noarch.rpm;name=aarch64_rust-term_grid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term_grid-devel}"
SRC_URI[aarch64_rust-term_grid-devel.sha256sum] = "adb7efef95ebc3680744d546e8c021961bb4984b64569b1b521bcc9bf92efd65"

RDEPENDS:rust-term_grid+default-devel = " \
 cargo \
 rust-term_grid-devel \
 "
RDEPENDS:rust-term_grid-devel = " \
 cargo \
 rust-unicode-width0.1+default-devel \
 "
