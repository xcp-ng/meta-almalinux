# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xvidcore"
PV = "1.3.7"
PR = "12.el10_0"
PACKAGES = " \
 xvidcore \
 xvidcore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xvidcore-1.3.7-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99b2f71e06cf6e7df97b6c3850c478118f3ac627804823eca2f1906a2edec22c"

URI_x86_64_v2_xvidcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xvidcore-1.3.7-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xvidcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xvidcore}"
SRC_URI[x86_64_v2_xvidcore.sha256sum] = "739b59e40c60ca32fe8eb9d359dd21908c052cc28a17a668433fb0c59c61a0c3"

URI_x86_64_v2_xvidcore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xvidcore-devel-1.3.7-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xvidcore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xvidcore-devel}"
SRC_URI[x86_64_v2_xvidcore-devel.sha256sum] = "c4504e9a7cb59da8e48329929e6568e5128a5d2b0927d8b39cfbd0d1062e59a4"

URI_aarch64_xvidcore = "${EPEL_MIRROR}/aarch64/Packages/x/xvidcore-1.3.7-12.el10_0.aarch64.rpm;name=aarch64_xvidcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_xvidcore}"
SRC_URI[aarch64_xvidcore.sha256sum] = "32cf167dd3c6eed6fcd920e2844632050e76a1df4e44c8e312c439902477db54"

URI_aarch64_xvidcore-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xvidcore-devel-1.3.7-12.el10_0.aarch64.rpm;name=aarch64_xvidcore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xvidcore-devel}"
SRC_URI[aarch64_xvidcore-devel.sha256sum] = "c7ad8ae40d478d7bbf67fd4fbd9e25b0ff6dca7ffa15a8b286d60f573027b396"

RDEPENDS:xvidcore = " \
 glibc \
 "
RDEPENDS:xvidcore-devel = " \
 xvidcore \
 "
