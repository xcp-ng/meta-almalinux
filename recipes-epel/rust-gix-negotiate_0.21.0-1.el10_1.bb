# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-negotiate"
PV = "0.21.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-negotiate+default-devel \
 rust-gix-negotiate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-negotiate-0.21.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c30e5c3ee46bfe58aa366807261cd7c918bff2961bd8481dd63d58977e86b78"

URI_x86_64_v2_rust-gix-negotiate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-negotiate+default-devel-0.21.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-negotiate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-negotiate+default-devel}"
SRC_URI[x86_64_v2_rust-gix-negotiate+default-devel.sha256sum] = "0b796cf02e3b1dac0c14a72aaf2668dbe00ecee9c40d2526563603310bda1244"

URI_x86_64_v2_rust-gix-negotiate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-negotiate-devel-0.21.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-negotiate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-negotiate-devel}"
SRC_URI[x86_64_v2_rust-gix-negotiate-devel.sha256sum] = "2c2cdbd55a482c45f8b01be2b9243856b368224d70943e20cf3a3e039fc456de"

URI_aarch64_rust-gix-negotiate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-negotiate+default-devel-0.21.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-negotiate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-negotiate+default-devel}"
SRC_URI[aarch64_rust-gix-negotiate+default-devel.sha256sum] = "6c6ea5b9c254e8a614b0ccef57e3858691ff80c7ec5b2953cbecc177ee9ec9bc"

URI_aarch64_rust-gix-negotiate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-negotiate-devel-0.21.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-negotiate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-negotiate-devel}"
SRC_URI[aarch64_rust-gix-negotiate-devel.sha256sum] = "8b0be0d9457f448f2955b2f5482936216c63345abc3b809c9b1ae2000bfa7277"

RDEPENDS:rust-gix-negotiate+default-devel = " \
 cargo \
 rust-gix-negotiate-devel \
 "
RDEPENDS:rust-gix-negotiate-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
