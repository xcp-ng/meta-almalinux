# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kimageformats"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kimageformats \
 kf6-kimageformats-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kimageformats-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d06fafb19071181b0e04dc63d58f2267d902220691fb03b04d8b56f2f6105509"

URI_x86_64_v2_kf6-kimageformats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kimageformats-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kimageformats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kimageformats}"
SRC_URI[x86_64_v2_kf6-kimageformats.sha256sum] = "b011f2d5eff8fa66aef60b058216bdcaa799d7631259e7f6b54692ca96f377db"

URI_x86_64_v2_kf6-kimageformats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kimageformats-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kimageformats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kimageformats-devel}"
SRC_URI[x86_64_v2_kf6-kimageformats-devel.sha256sum] = "1dbbed3b7f6fc8f37849996ac1cf83f94ef29455e04ef59bfc34496dd982f2ad"

URI_aarch64_kf6-kimageformats = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kimageformats-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kimageformats;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kimageformats}"
SRC_URI[aarch64_kf6-kimageformats.sha256sum] = "bddd219fde64c1c49c35efd6df8b527d589fbbfcdd5e86565c70c8b871926c6f"

URI_aarch64_kf6-kimageformats-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kimageformats-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kimageformats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kimageformats-devel}"
SRC_URI[aarch64_kf6-kimageformats-devel.sha256sum] = "2b9f3d9a9cae6b9eebb8d12b1b2defac5e9c6b6f99e3549b4bc537a6f375885f"

RDEPENDS:kf6-kimageformats = " \
 LibRaw \
 glibc \
 imath \
 jxrlib \
 kf6-filesystem \
 kf6-karchive \
 libavif \
 libgcc \
 libheif \
 libjxl \
 libstdc++ \
 openexr-libs \
 openjpeg2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kimageformats-devel = " \
 cmake-filesystem \
 kf6-kimageformats \
 "
