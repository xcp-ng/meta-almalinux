# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "deskflow"
PV = "1.22.0"
PR = "1.el10_0"
PACKAGES = " \
 deskflow \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/deskflow-1.22.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6aa39bc3d3637c2cffe8fec0708c3a17313611aea38058cff5cc31f183a33a2b"

URI_x86_64_v2_deskflow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/deskflow-1.22.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_deskflow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_deskflow}"
SRC_URI[x86_64_v2_deskflow.sha256sum] = "f548763a68c8c78b50842216292d374cb8f164d7a3cd0046df8c48b65136b553"

URI_aarch64_deskflow = "${EPEL_MIRROR}/aarch64/Packages/d/deskflow-1.22.0-1.el10_0.aarch64.rpm;name=aarch64_deskflow;unpack=0"
SRC_URI:append = " ${URI_aarch64_deskflow}"
SRC_URI[aarch64_deskflow.sha256sum] = "eea139df5eb922d0c96dd9219bcb17ec062c2b209f09c9da83546da5c1b77f66"

RDEPENDS:deskflow = " \
 glib2 \
 glibc \
 hicolor-icon-theme \
 libX11 \
 libXext \
 libXi \
 libXinerama \
 libXrandr \
 libXtst \
 libei \
 libgcc \
 libportal \
 libstdc++ \
 libxkbcommon \
 libxkbfile \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 tomlplusplus \
 "
