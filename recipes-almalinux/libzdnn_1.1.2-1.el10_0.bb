# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libzdnn"
PV = "1.1.2"
PR = "1.el10_0"
PACKAGES = " \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libzdnn-1.1.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2802a24236baaae09f1fd095d26172c998b43808caecdf56a1a4dde3c580d470"

