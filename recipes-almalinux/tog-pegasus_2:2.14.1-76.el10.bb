# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tog-pegasus"
PE = "2"
PV = "2.14.1"
PR = "76.el10"
PACKAGES = " \
 tog-pegasus \
 tog-pegasus-devel \
 tog-pegasus-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tog-pegasus-2.14.1-76.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1f9275018ec9d3f55904f6908c50d071e77e5e239572291312687687290b3fe1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tog-pegasus-2.14.1-76.el10.x86_64_v2.rpm;name=x86_64_v2_tog-pegasus;unpack=0"
SRC_URI[x86_64_v2_tog-pegasus.sha256sum] = "d583ccdb8858aac301c7436440867f539d7990163676586b8de308df6402fb06"
RPROVIDES:tog-pegasus:append:x86_64_v2 = " virtual/cim-server"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/tog-pegasus-devel-2.14.1-76.el10.x86_64_v2.rpm;name=x86_64_v2_tog-pegasus-devel;unpack=0"
SRC_URI[x86_64_v2_tog-pegasus-devel.sha256sum] = "caa9e6f4fd5e55dad4bee8e1a33515364c849c4288b90593f6319443987400a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tog-pegasus-libs-2.14.1-76.el10.x86_64_v2.rpm;name=x86_64_v2_tog-pegasus-libs;unpack=0"
SRC_URI[x86_64_v2_tog-pegasus-libs.sha256sum] = "cddb09607f20c067a0967d0a5a8eb250418512ac805a2590815a9ab530a4f769"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tog-pegasus-2.14.1-76.el10.aarch64.rpm;name=aarch64_tog-pegasus;unpack=0"
SRC_URI[aarch64_tog-pegasus.sha256sum] = "7d0aef5e34b22777fb080d091aaa3d3fc337b75eff0bb6c0d967e02f8c811704"
RPROVIDES:tog-pegasus:append:aarch64 = " virtual/cim-server"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/tog-pegasus-devel-2.14.1-76.el10.aarch64.rpm;name=aarch64_tog-pegasus-devel;unpack=0"
SRC_URI[aarch64_tog-pegasus-devel.sha256sum] = "735f7d626013833d836fe48c0eae09436a27aa6166c732c07e635e7b3f63f49a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tog-pegasus-libs-2.14.1-76.el10.aarch64.rpm;name=aarch64_tog-pegasus-libs;unpack=0"
SRC_URI[aarch64_tog-pegasus-libs.sha256sum] = "4f683f1998a7dfd5a854150b608699f0936c58a10cd088ac3bad9de8a7020175"

RDEPENDS:tog-pegasus = " \
 bash \
 ca-certificates \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 net-snmp-libs \
 openssl \
 policycoreutils \
 tog-pegasus-libs \
 "
RDEPENDS:tog-pegasus-devel = " \
 bash \
 tog-pegasus \
 "
RDEPENDS:tog-pegasus-libs = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 net-snmp-libs \
 openslp \
 openssl-libs \
 pam-libs \
 shadow-utils \
 "
