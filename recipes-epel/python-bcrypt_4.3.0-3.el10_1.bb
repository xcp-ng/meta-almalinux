# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-bcrypt"
PV = "4.3.0"
PR = "3.el10_1"
PACKAGES = " \
 python3-bcrypt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-bcrypt-4.3.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6537cd3f5dfa51b4c0e70bb261835be46cfaabebdf4cf037647610b0aee0d0e4"

URI_x86_64_v2_python3-bcrypt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bcrypt-4.3.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-bcrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bcrypt}"
SRC_URI[x86_64_v2_python3-bcrypt.sha256sum] = "c4c450b69b3546caeb6c4689b5023a20b699fe3adfc7fb0b746c555ee6db8b7a"

URI_aarch64_python3-bcrypt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bcrypt-4.3.0-3.el10_1.aarch64.rpm;name=aarch64_python3-bcrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bcrypt}"
SRC_URI[aarch64_python3-bcrypt.sha256sum] = "3cd800228b2ddfd8c9442eca05749148b17f000ffd1b4c7b654c3a0c772804a2"

RDEPENDS:python3-bcrypt = " \
 glibc \
 libgcc \
 python3 \
 "
