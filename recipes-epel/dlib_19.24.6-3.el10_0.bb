# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dlib"
PV = "19.24.6"
PR = "3.el10_0"
PACKAGES = " \
 dlib \
 dlib-devel \
 dlib-doc \
 python3-dlib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dlib-19.24.6-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36d580a9b4983e9f435db7549bc4fbaac3cfe82089879e91384ded622cef2360"

URI_x86_64_v2_dlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dlib-19.24.6-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dlib}"
SRC_URI[x86_64_v2_dlib.sha256sum] = "4ed2ecbedb8a1aa387ab0d4ea535dc278027c5cb1a6e0b81d9afbe0235fda9d1"

URI_x86_64_v2_dlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dlib-devel-19.24.6-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dlib-devel}"
SRC_URI[x86_64_v2_dlib-devel.sha256sum] = "7a7cf22c28ad29b2fdea8045dc1d12e8312e5fd33ddf80a0e7dc86bdc4b49b30"

URI_x86_64_v2_dlib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dlib-doc-19.24.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dlib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dlib-doc}"
SRC_URI[x86_64_v2_dlib-doc.sha256sum] = "a0d65ab26d358d758a992ada4f354ed88f469d171c9fca06002e8ec4c4571b5f"

URI_x86_64_v2_python3-dlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dlib-19.24.6-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-dlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dlib}"
SRC_URI[x86_64_v2_python3-dlib.sha256sum] = "4b071ec8b2889c4e1475b0a490505200494acad5e254522587bcd65da7860274"

URI_aarch64_dlib = "${EPEL_MIRROR}/aarch64/Packages/d/dlib-19.24.6-3.el10_0.aarch64.rpm;name=aarch64_dlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_dlib}"
SRC_URI[aarch64_dlib.sha256sum] = "51269849009cd6330e9effd778479d6a2cab0503554f12a546b1aaa516bfc754"

URI_aarch64_dlib-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dlib-devel-19.24.6-3.el10_0.aarch64.rpm;name=aarch64_dlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dlib-devel}"
SRC_URI[aarch64_dlib-devel.sha256sum] = "0824341504a74bf66ed5b284b6aae6c7f84bbb04b885f93d066f74c2b1a139de"

URI_aarch64_dlib-doc = "${EPEL_MIRROR}/aarch64/Packages/d/dlib-doc-19.24.6-3.el10_0.noarch.rpm;name=aarch64_dlib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dlib-doc}"
SRC_URI[aarch64_dlib-doc.sha256sum] = "8c7045685bb9fe07442a563385785b19c4e58674e50f553f4ec14ba7264a52d4"

URI_aarch64_python3-dlib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dlib-19.24.6-3.el10_0.aarch64.rpm;name=aarch64_python3-dlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dlib}"
SRC_URI[aarch64_python3-dlib.sha256sum] = "e82537fc092b87cd194028a935b5d9fa7733e44c4ba8e5db3729ef8c6f3e278d"

RDEPENDS:dlib = " \
 flexiblas-netlib \
 glibc \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libwebp \
 "
RDEPENDS:dlib-devel = " \
 cmake-filesystem \
 dlib \
 pkgconf-pkg-config \
 "
RDEPENDS:dlib-doc = " \
 dlib \
 "
RDEPENDS:python3-dlib = " \
 flexiblas-netlib \
 glibc \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libjxl \
 libpng \
 libstdc++ \
 libwebp \
 python3 \
 "
