# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smawk"
PV = "0.3.2"
PR = "3.el10_0"
PACKAGES = " \
 rust-smawk+default-devel \
 rust-smawk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-smawk-0.3.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aec01ce4bae729defd30ca1e33b88a892f32981d640f95820159dacceb0bb87a"

URI_x86_64_v2_rust-smawk+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smawk+default-devel-0.3.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smawk+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smawk+default-devel}"
SRC_URI[x86_64_v2_rust-smawk+default-devel.sha256sum] = "47bd46bcb3f98c1a08f708684cd2794ede8813f17e9f1055955de20ca8fa5c9b"

URI_x86_64_v2_rust-smawk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smawk-devel-0.3.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smawk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smawk-devel}"
SRC_URI[x86_64_v2_rust-smawk-devel.sha256sum] = "e9f47a1e04e5c090cffc372836192873848614ed8e424ea5fc2381ede71f4079"

URI_aarch64_rust-smawk+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smawk+default-devel-0.3.2-3.el10_0.noarch.rpm;name=aarch64_rust-smawk+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smawk+default-devel}"
SRC_URI[aarch64_rust-smawk+default-devel.sha256sum] = "4eac6ae4f57feee30a58326d57a88006eb0040a52dfc4df6ec0a7f1580de26a4"

URI_aarch64_rust-smawk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smawk-devel-0.3.2-3.el10_0.noarch.rpm;name=aarch64_rust-smawk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smawk-devel}"
SRC_URI[aarch64_rust-smawk-devel.sha256sum] = "789b339ec7886cbcbdbad01f65fa571cd5093986e1354580c6ddcee55a4bed0f"

RDEPENDS:rust-smawk+default-devel = " \
 cargo \
 rust-smawk-devel \
 "
RDEPENDS:rust-smawk-devel = " \
 cargo \
 "
