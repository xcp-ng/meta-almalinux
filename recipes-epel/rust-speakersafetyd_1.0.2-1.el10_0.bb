# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-speakersafetyd"
PV = "1.0.2"
PR = "1.el10_0"
PACKAGES = " \
 speakersafetyd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-speakersafetyd-1.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bea9b0c35821457e368c3704f22e0b56c4f457b711c5fc3367b7e001e7a7472a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/speakersafetyd-1.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_speakersafetyd;unpack=0"
SRC_URI[x86_64_v2_speakersafetyd.sha256sum] = "a312fd1c533b69ec6b22816d007504d111a9f49b48eca996a7e291b05dc7c891"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/speakersafetyd-1.0.2-1.el10_0.aarch64.rpm;name=aarch64_speakersafetyd;unpack=0"
SRC_URI[aarch64_speakersafetyd.sha256sum] = "af23af3dc52301553a9f7706e121fa9ad3585f856bbe599c92242910cd8561c3"

RDEPENDS:speakersafetyd = " \
 alsa-lib \
 bash \
 glibc \
 libgcc \
 systemd-udev \
 "
