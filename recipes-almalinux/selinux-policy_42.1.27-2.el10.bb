# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "selinux-policy"
PV = "42.1.27"
PR = "2.el10"
PACKAGES = " \
 selinux-policy \
 selinux-policy-devel \
 selinux-policy-doc \
 selinux-policy-extra \
 selinux-policy-mls \
 selinux-policy-mls-extra \
 selinux-policy-sandbox \
 selinux-policy-targeted \
 selinux-policy-targeted-extra \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/selinux-policy-42.1.27-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d3b9bd608f25b3afee76780e72cbdd8abd11e91daf3cc2ff964ee39a474179c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-42.1.27-2.el10.noarch.rpm;name=x86_64_v2_selinux-policy;unpack=0"
SRC_URI[x86_64_v2_selinux-policy.sha256sum] = "499d717474a9b9fcdc8640499804eac2ca833c1ff4c8033ed8fdc3c136db80b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/selinux-policy-devel-42.1.27-2.el10.noarch.rpm;name=x86_64_v2_selinux-policy-devel;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-devel.sha256sum] = "73c523ec36fd1386723a0d01f9ef6814a92d353cce1428392e3e2938d5ade4f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-doc-42.1.27-2.el10.noarch.rpm;name=x86_64_v2_selinux-policy-doc;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-doc.sha256sum] = "80e2d5a3402e669e7df1fb59487db267f6dcd9d498c301a1daa5baf70c54ede3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-extra-42.1.27-2.el10.noarch.rpm;name=x86_64_v2_selinux-policy-extra;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-extra.sha256sum] = "9a1c377d4f69d025d6fb1e1871188e0a55edf06b6210678d5e1f7bf3636da931"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-mls-42.1.27-2.el10.noarch.rpm;name=x86_64_v2_selinux-policy-mls;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-mls.sha256sum] = "411a5df6cfb48ec0811f1d0fb8dbef04d4a361fe6f459e1a3214a980d6bd1a2d"
RPROVIDES:selinux-policy-mls:append:x86_64_v2 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.27-2.el10 virtual/selinux-policy-any_ge_42.1.13 virtual/selinux-policy-any_ge_42.1.25 virtual/selinux-policy-any_ge_42.1.27"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-mls-extra-42.1.27-2.el10.noarch.rpm;name=x86_64_v2_selinux-policy-mls-extra;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-mls-extra.sha256sum] = "9b3176ec57efa99bb107c2fb90f6ba20e46de4bcc102f75950c674cc48f66922"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-sandbox-42.1.27-2.el10.noarch.rpm;name=x86_64_v2_selinux-policy-sandbox;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-sandbox.sha256sum] = "3bd604eae27275f4d28c73a6f4979a186d9c4017ff3dc276223f535e0002f159"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-targeted-42.1.27-2.el10.noarch.rpm;name=x86_64_v2_selinux-policy-targeted;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-targeted.sha256sum] = "7be263f9f8e65c68216f576a907afdd79df8a33068705f2fc57d26d109e85cec"
RPROVIDES:selinux-policy-targeted:append:x86_64_v2 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.27-2.el10 virtual/selinux-policy-any_ge_42.1.13 virtual/selinux-policy-any_ge_42.1.25 virtual/selinux-policy-any_ge_42.1.27"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-targeted-extra-42.1.27-2.el10.noarch.rpm;name=x86_64_v2_selinux-policy-targeted-extra;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-targeted-extra.sha256sum] = "e723da1fa9f8fc4d9968f061fc8e8448cff1b33ccaac71c9af83238bb553193c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-42.1.27-2.el10.noarch.rpm;name=aarch64_selinux-policy;unpack=0"
SRC_URI[aarch64_selinux-policy.sha256sum] = "499d717474a9b9fcdc8640499804eac2ca833c1ff4c8033ed8fdc3c136db80b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/selinux-policy-devel-42.1.27-2.el10.noarch.rpm;name=aarch64_selinux-policy-devel;unpack=0"
SRC_URI[aarch64_selinux-policy-devel.sha256sum] = "73c523ec36fd1386723a0d01f9ef6814a92d353cce1428392e3e2938d5ade4f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-doc-42.1.27-2.el10.noarch.rpm;name=aarch64_selinux-policy-doc;unpack=0"
SRC_URI[aarch64_selinux-policy-doc.sha256sum] = "80e2d5a3402e669e7df1fb59487db267f6dcd9d498c301a1daa5baf70c54ede3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-extra-42.1.27-2.el10.noarch.rpm;name=aarch64_selinux-policy-extra;unpack=0"
SRC_URI[aarch64_selinux-policy-extra.sha256sum] = "9a1c377d4f69d025d6fb1e1871188e0a55edf06b6210678d5e1f7bf3636da931"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-mls-42.1.27-2.el10.noarch.rpm;name=aarch64_selinux-policy-mls;unpack=0"
SRC_URI[aarch64_selinux-policy-mls.sha256sum] = "411a5df6cfb48ec0811f1d0fb8dbef04d4a361fe6f459e1a3214a980d6bd1a2d"
RPROVIDES:selinux-policy-mls:append:aarch64 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.27-2.el10 virtual/selinux-policy-any_ge_42.1.12 virtual/selinux-policy-any_ge_42.1.25 virtual/selinux-policy-any_ge_42.1.26"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-mls-extra-42.1.27-2.el10.noarch.rpm;name=aarch64_selinux-policy-mls-extra;unpack=0"
SRC_URI[aarch64_selinux-policy-mls-extra.sha256sum] = "9b3176ec57efa99bb107c2fb90f6ba20e46de4bcc102f75950c674cc48f66922"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-sandbox-42.1.27-2.el10.noarch.rpm;name=aarch64_selinux-policy-sandbox;unpack=0"
SRC_URI[aarch64_selinux-policy-sandbox.sha256sum] = "3bd604eae27275f4d28c73a6f4979a186d9c4017ff3dc276223f535e0002f159"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-targeted-42.1.27-2.el10.noarch.rpm;name=aarch64_selinux-policy-targeted;unpack=0"
SRC_URI[aarch64_selinux-policy-targeted.sha256sum] = "7be263f9f8e65c68216f576a907afdd79df8a33068705f2fc57d26d109e85cec"
RPROVIDES:selinux-policy-targeted:append:aarch64 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.27-2.el10 virtual/selinux-policy-any_ge_42.1.12 virtual/selinux-policy-any_ge_42.1.25 virtual/selinux-policy-any_ge_42.1.26"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-targeted-extra-42.1.27-2.el10.noarch.rpm;name=aarch64_selinux-policy-targeted-extra;unpack=0"
SRC_URI[aarch64_selinux-policy-targeted-extra.sha256sum] = "e723da1fa9f8fc4d9968f061fc8e8448cff1b33ccaac71c9af83238bb553193c"

RDEPENDS:selinux-policy = " \
 bash \
 gawk \
 policycoreutils \
 rpm-plugin-selinux \
 virtual//usr/bin/sha512sum \
 virtual/selinux-policy-any_eq_42.1.27-2.el10 \
 "
RDEPENDS:selinux-policy-devel = " \
 bash \
 checkpolicy \
 m4 \
 make \
 policycoreutils-devel \
 selinux-policy \
 "
RDEPENDS:selinux-policy-doc = " \
 selinux-policy \
 "
RDEPENDS:selinux-policy-extra = " \
 selinux-policy-mls-extra \
 selinux-policy-targeted-extra \
 "
RDEPENDS:selinux-policy-mls = " \
 bash \
 mcstrans \
 policycoreutils \
 policycoreutils-newrole \
 selinux-policy \
 virtual/coreutils \
 "
RDEPENDS:selinux-policy-mls-extra = " \
 bash \
 selinux-policy-mls \
 "
RDEPENDS:selinux-policy-sandbox = " \
 bash \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:selinux-policy-targeted = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/coreutils \
 "
RDEPENDS:selinux-policy-targeted-extra = " \
 bash \
 selinux-policy-targeted \
 "
