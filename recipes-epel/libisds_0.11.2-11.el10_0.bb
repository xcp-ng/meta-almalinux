# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libisds"
PV = "0.11.2"
PR = "11.el10_0"
PACKAGES = " \
 libisds \
 libisds-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libisds-0.11.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a370eba8c7659353d42e4bc7bf1e4a5114d5fe1ebb3b8134fa6280c7eed8132e"

URI_x86_64_v2_libisds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libisds-0.11.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libisds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libisds}"
SRC_URI[x86_64_v2_libisds.sha256sum] = "7d9c3aa238d3072e0c4c36ed923de100671254366eee7a829b96f7b93e90a757"

URI_x86_64_v2_libisds-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libisds-devel-0.11.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libisds-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libisds-devel}"
SRC_URI[x86_64_v2_libisds-devel.sha256sum] = "505024858cf763a33b8e41890c72e584c2426586c0a1a754ea894884f771ed23"

URI_aarch64_libisds = "${EPEL_MIRROR}/aarch64/Packages/l/libisds-0.11.2-11.el10_0.aarch64.rpm;name=aarch64_libisds;unpack=0"
SRC_URI:append = " ${URI_aarch64_libisds}"
SRC_URI[aarch64_libisds.sha256sum] = "11486aaee284dd35d6a338f972ff052ad14f2354c9cd25f00b8125e2dda66ef9"

URI_aarch64_libisds-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libisds-devel-0.11.2-11.el10_0.aarch64.rpm;name=aarch64_libisds-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libisds-devel}"
SRC_URI[aarch64_libisds-devel.sha256sum] = "7763d91512262b3b3c4c7f276e51eaede0c470668a2555f7bbc241c4a7da028f"

RDEPENDS:libisds = " \
 expat \
 glibc \
 gnupg2-smime \
 gpgme \
 libgcrypt \
 libgpg-error \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libisds-devel = " \
 libcurl-devel \
 libisds \
 libxml2-devel \
 pkgconf-pkg-config \
 "
