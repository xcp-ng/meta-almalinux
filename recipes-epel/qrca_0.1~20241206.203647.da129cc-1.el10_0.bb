# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qrca"
PV = "0.1~20241206.203647.da129cc"
PR = "1.el10_0"
PACKAGES = " \
 qrca \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qrca-0.1~20241206.203647.da129cc-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8dbe7c979708c4265f87b8465001e40a0050dff7e680d166fffd49dae1c35930"

URI_x86_64_v2_qrca = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qrca-0.1~20241206.203647.da129cc-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qrca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qrca}"
SRC_URI[x86_64_v2_qrca.sha256sum] = "d369f7c79413a82baf17534124db2da3e605ffdcc952374b98259604e6aa75bf"

URI_aarch64_qrca = "${EPEL_MIRROR}/aarch64/Packages/q/qrca-0.1~20241206.203647.da129cc-1.el10_0.aarch64.rpm;name=aarch64_qrca;unpack=0"
SRC_URI:append = " ${URI_aarch64_qrca}"
SRC_URI[aarch64_qrca.sha256sum] = "f7312b59c253faa74eef328cef4c288c2c90875aa85cabcdd418b2efcfaa7304"

RDEPENDS:qrca = " \
 glibc \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kservice \
 kf6-networkmanager-qt \
 kf6-prison \
 kf6-purpose \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xdg-utils \
 "
