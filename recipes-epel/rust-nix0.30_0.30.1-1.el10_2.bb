# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nix0.30"
PV = "0.30.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-nix0.30+acct-devel \
 rust-nix0.30+aio-devel \
 rust-nix0.30+default-devel \
 rust-nix0.30+dir-devel \
 rust-nix0.30+env-devel \
 rust-nix0.30+event-devel \
 rust-nix0.30+fanotify-devel \
 rust-nix0.30+feature-devel \
 rust-nix0.30+fs-devel \
 rust-nix0.30+hostname-devel \
 rust-nix0.30+inotify-devel \
 rust-nix0.30+ioctl-devel \
 rust-nix0.30+kmod-devel \
 rust-nix0.30+memoffset-devel \
 rust-nix0.30+mman-devel \
 rust-nix0.30+mount-devel \
 rust-nix0.30+mqueue-devel \
 rust-nix0.30+net-devel \
 rust-nix0.30+personality-devel \
 rust-nix0.30+pin-utils-devel \
 rust-nix0.30+poll-devel \
 rust-nix0.30+process-devel \
 rust-nix0.30+pthread-devel \
 rust-nix0.30+ptrace-devel \
 rust-nix0.30+quota-devel \
 rust-nix0.30+reboot-devel \
 rust-nix0.30+resource-devel \
 rust-nix0.30+sched-devel \
 rust-nix0.30+signal-devel \
 rust-nix0.30+socket-devel \
 rust-nix0.30+syslog-devel \
 rust-nix0.30+term-devel \
 rust-nix0.30+time-devel \
 rust-nix0.30+ucontext-devel \
 rust-nix0.30+uio-devel \
 rust-nix0.30+user-devel \
 rust-nix0.30+zerocopy-devel \
 rust-nix0.30-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nix0.30-0.30.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7770bbef9a724ef004320f370526f50dacf65a1e897c0e55222e0ee7686708b"

URI_x86_64_v2_rust-nix0.30+acct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+acct-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+acct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+acct-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+acct-devel.sha256sum] = "bccc6e911c891add1bfe2b4c2337031629990c0955b9d6ebcd06ac5841c0d12d"

URI_x86_64_v2_rust-nix0.30+aio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+aio-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+aio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+aio-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+aio-devel.sha256sum] = "dc0fa9afed5fa44d05e6cabd1a13723f14a975ba42a7bbce92ff98f941cdc4e3"

URI_x86_64_v2_rust-nix0.30+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+default-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+default-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+default-devel.sha256sum] = "f644ff5f57a4cfa9cb462b5b330eb911846a59fb5f16d7439fa99f6fde577acd"

URI_x86_64_v2_rust-nix0.30+dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+dir-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+dir-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+dir-devel.sha256sum] = "af1167d4b1ff1acf2e14b108f1cc60b7549ae40695a46732000265551eeb8990"

URI_x86_64_v2_rust-nix0.30+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+env-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+env-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+env-devel.sha256sum] = "c6dcdb3ad18bc42e299d42c5211f0e686ed61e4f407f69ac995b6844ede10641"

URI_x86_64_v2_rust-nix0.30+event-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+event-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+event-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+event-devel.sha256sum] = "bfff072a65a54b66467ee8d075a1b535419e6ad127db811604dcadcf2a904e08"

URI_x86_64_v2_rust-nix0.30+fanotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+fanotify-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+fanotify-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+fanotify-devel.sha256sum] = "0d2cb56ecbfd31b2561dc2a7fbe3678ff745042cfa0f96c83cfab9c82d9da4cf"

URI_x86_64_v2_rust-nix0.30+feature-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+feature-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+feature-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+feature-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+feature-devel.sha256sum] = "acfc71e48be64c828070a7eebdb555c7e7bec1d29752a8cbd2ead0b2f7df0e74"

URI_x86_64_v2_rust-nix0.30+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+fs-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+fs-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+fs-devel.sha256sum] = "fd72ed9ff7c1a620ebee29313d3ec99b6c734ea14782e25c44c39a1ab64c5363"

URI_x86_64_v2_rust-nix0.30+hostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+hostname-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+hostname-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+hostname-devel.sha256sum] = "246d5ac1a210ce7763cb1003a745dc71dd543ae6114f648639019f0cee2fc76a"

URI_x86_64_v2_rust-nix0.30+inotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+inotify-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+inotify-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+inotify-devel.sha256sum] = "0e48c959cb27b875c7db0937114da355331d7b4a5fa03d653ce7c6112f301692"

URI_x86_64_v2_rust-nix0.30+ioctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+ioctl-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+ioctl-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+ioctl-devel.sha256sum] = "618ac9dfae331826db11aa3080f2309a7e09981a89549ab8f8b2f3dbd6d0a91b"

URI_x86_64_v2_rust-nix0.30+kmod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+kmod-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+kmod-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+kmod-devel.sha256sum] = "a0c0c1268ce95e9954af6b13cb1fe452fff0e0f1143c88f25901d892b85d45c4"

URI_x86_64_v2_rust-nix0.30+memoffset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+memoffset-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+memoffset-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+memoffset-devel.sha256sum] = "d13135548bec25aa7668bf26d6d77e1d3f4cbd4ef20f705ce566d52cbea48a48"

URI_x86_64_v2_rust-nix0.30+mman-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+mman-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+mman-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+mman-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+mman-devel.sha256sum] = "5f9f9d4dddbdc3ea08a95b684160536b8b24fe88d9b893767cccf8128e0c3242"

URI_x86_64_v2_rust-nix0.30+mount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+mount-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+mount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+mount-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+mount-devel.sha256sum] = "a030d435960a1575140693e047968030a8bfed853f50792db98b86d99facf89b"

URI_x86_64_v2_rust-nix0.30+mqueue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+mqueue-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+mqueue-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+mqueue-devel.sha256sum] = "caea0a18d2923aec5b9b4ab12a44e60f6967bb5e9e91c7b0b1bd2136161d2c61"

URI_x86_64_v2_rust-nix0.30+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+net-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+net-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+net-devel.sha256sum] = "391e022c9462c7b58f6b53aeffc8e0d42af5a5b0b13ad968fcf69876056f9ada"

URI_x86_64_v2_rust-nix0.30+personality-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+personality-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+personality-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+personality-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+personality-devel.sha256sum] = "876af367fcaee5d658e4dead8c74ce9f36a6c2cc6e39bfed0a0f45ac05fd6432"

URI_x86_64_v2_rust-nix0.30+pin-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+pin-utils-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+pin-utils-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+pin-utils-devel.sha256sum] = "f1df159fb1f5f61df1cf16e16a50468907dce2253a4f41a1a6b4a71b30c058a7"

URI_x86_64_v2_rust-nix0.30+poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+poll-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+poll-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+poll-devel.sha256sum] = "c1bbdf0cbef2e0ad73836b15d5de0b78350484479edf1b25b21a38912be1a06f"

URI_x86_64_v2_rust-nix0.30+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+process-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+process-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+process-devel.sha256sum] = "59202220e6ea2d7df84ad2cc50bf532c6fe62743ac331d42a15c1c07f8aab1cf"

URI_x86_64_v2_rust-nix0.30+pthread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+pthread-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+pthread-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+pthread-devel.sha256sum] = "737e77573c3ea543ced145ff255ad61ff37ca5e95357f3c581d75d5863310c0a"

URI_x86_64_v2_rust-nix0.30+ptrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+ptrace-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+ptrace-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+ptrace-devel.sha256sum] = "94c8eeadc073222e627d2fb5b83a299e537c638d56edb9459d1310b6dc9f3662"

URI_x86_64_v2_rust-nix0.30+quota-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+quota-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+quota-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+quota-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+quota-devel.sha256sum] = "c5965ad9ebf919b9a5fb0617f58e2d3e413a3d3e899bd94fde36adac58f8987d"

URI_x86_64_v2_rust-nix0.30+reboot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+reboot-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+reboot-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+reboot-devel.sha256sum] = "f9b7236729df574ed859346e0ee5cc41d279f9d01e5a53b10e600d208fe61f88"

URI_x86_64_v2_rust-nix0.30+resource-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+resource-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+resource-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+resource-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+resource-devel.sha256sum] = "abc0f62b18e5888f13b03feb98129ce2a72cbfea54266f469ebdf0422e7769dc"

URI_x86_64_v2_rust-nix0.30+sched-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+sched-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+sched-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+sched-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+sched-devel.sha256sum] = "faac44a7b79ccb36104cc1a68de687d53e72ef39c000206917e80b5625f24a15"

URI_x86_64_v2_rust-nix0.30+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+signal-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+signal-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+signal-devel.sha256sum] = "95fef5df9e14e302985235a9589f0ade0c89f3da8daebdfc684952b44c70b918"

URI_x86_64_v2_rust-nix0.30+socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+socket-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+socket-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+socket-devel.sha256sum] = "c1078071cbc692edd9443ae2caba8b7022bf52ad7f1ea666316c44b1aa531053"

URI_x86_64_v2_rust-nix0.30+syslog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+syslog-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+syslog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+syslog-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+syslog-devel.sha256sum] = "7bdd9c1aaff575fca3b074bda6365eff4de98bc9af63a437fa5526d99b7180a8"

URI_x86_64_v2_rust-nix0.30+term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+term-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+term-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+term-devel.sha256sum] = "d72c8d9243b43c0ea66414dbf3e35b6d56bc7401c3cc77a06e69f64b9590a6fc"

URI_x86_64_v2_rust-nix0.30+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+time-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+time-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+time-devel.sha256sum] = "a5f6753aea76f970e16cfbe781fcbe3ad039cb744d8bba44f51ec77061145bb8"

URI_x86_64_v2_rust-nix0.30+ucontext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+ucontext-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+ucontext-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+ucontext-devel.sha256sum] = "c17dc5b66db8557a65b03c03af6c2a0534de7b99db1218cf33a69c4842af0a56"

URI_x86_64_v2_rust-nix0.30+uio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+uio-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+uio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+uio-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+uio-devel.sha256sum] = "a0f406dddb056382305df069247aad908af4f978a77d605944001aa2fefa836d"

URI_x86_64_v2_rust-nix0.30+user-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+user-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+user-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+user-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+user-devel.sha256sum] = "61a66841ff72eab208fe9835e908686f0dc9c0c8ce6e578dfa00eb4e18be00e1"

URI_x86_64_v2_rust-nix0.30+zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30+zerocopy-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30+zerocopy-devel}"
SRC_URI[x86_64_v2_rust-nix0.30+zerocopy-devel.sha256sum] = "81ee6090092de2e64d4ab8aad2f5ae59b431f66d2ba84aabe53eb45fe546bb32"

URI_x86_64_v2_rust-nix0.30-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.30-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.30-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.30-devel}"
SRC_URI[x86_64_v2_rust-nix0.30-devel.sha256sum] = "ad39ba7b4dae1859883602e77f3872b86f64eef001dba69078df133916f06924"

URI_aarch64_rust-nix0.30+acct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+acct-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+acct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+acct-devel}"
SRC_URI[aarch64_rust-nix0.30+acct-devel.sha256sum] = "ec0ffc3ff17e79dfb7f1967be5dd113a3cf9f5a19e37ace16087e47ba6f5b989"

URI_aarch64_rust-nix0.30+aio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+aio-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+aio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+aio-devel}"
SRC_URI[aarch64_rust-nix0.30+aio-devel.sha256sum] = "35357c69b1ef9c2220754f89cadb11943cf0ad8d70834aff8350736f79db2ede"

URI_aarch64_rust-nix0.30+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+default-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+default-devel}"
SRC_URI[aarch64_rust-nix0.30+default-devel.sha256sum] = "422b93cdf7f725000afd5af042b11469db72490b1432a9abfaa430f6ab5694ad"

URI_aarch64_rust-nix0.30+dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+dir-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+dir-devel}"
SRC_URI[aarch64_rust-nix0.30+dir-devel.sha256sum] = "6f719f8751520653911c331e83ef7c6bb17fda13748848908b5adb906d344435"

URI_aarch64_rust-nix0.30+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+env-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+env-devel}"
SRC_URI[aarch64_rust-nix0.30+env-devel.sha256sum] = "558274caa9279a30c6d11d2eedc8717413d1933b0f78ab9aaaa8c2f2e39a46b3"

URI_aarch64_rust-nix0.30+event-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+event-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+event-devel}"
SRC_URI[aarch64_rust-nix0.30+event-devel.sha256sum] = "9278ad8dccb6d8a77ba88255833adfec261c2a28ca87c08184a9c8d6d7d48760"

URI_aarch64_rust-nix0.30+fanotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+fanotify-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+fanotify-devel}"
SRC_URI[aarch64_rust-nix0.30+fanotify-devel.sha256sum] = "38c6594e2f10e9ed556be4057144ce01ced78100df56528e55073e472dfc7fbf"

URI_aarch64_rust-nix0.30+feature-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+feature-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+feature-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+feature-devel}"
SRC_URI[aarch64_rust-nix0.30+feature-devel.sha256sum] = "6b565aa7ae15290b4a71a1bb01b2d83c05a73a981ac6326bd752e0ae348bb7f5"

URI_aarch64_rust-nix0.30+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+fs-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+fs-devel}"
SRC_URI[aarch64_rust-nix0.30+fs-devel.sha256sum] = "7db2cd2515d759ea05d86e99777bf25b712202b0bc8276dda36810cd783d22a6"

URI_aarch64_rust-nix0.30+hostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+hostname-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+hostname-devel}"
SRC_URI[aarch64_rust-nix0.30+hostname-devel.sha256sum] = "de9241b4759ef5dadcf72218113b9b7125e71a2c7ee1a335a2712d3a8c4e9d98"

URI_aarch64_rust-nix0.30+inotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+inotify-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+inotify-devel}"
SRC_URI[aarch64_rust-nix0.30+inotify-devel.sha256sum] = "7ce3137abeee3615b270f735a0ebc282477fcdc34be38aaa64695d551bc9fdab"

URI_aarch64_rust-nix0.30+ioctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+ioctl-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+ioctl-devel}"
SRC_URI[aarch64_rust-nix0.30+ioctl-devel.sha256sum] = "028411f7abef76088b6876f2a894585518faf60c2f728beb3f4d06a078369df9"

URI_aarch64_rust-nix0.30+kmod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+kmod-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+kmod-devel}"
SRC_URI[aarch64_rust-nix0.30+kmod-devel.sha256sum] = "11cea6aedca14f4c6dd75e815bd4b1065ee097200e91b9d6b04b61314f509a75"

URI_aarch64_rust-nix0.30+memoffset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+memoffset-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+memoffset-devel}"
SRC_URI[aarch64_rust-nix0.30+memoffset-devel.sha256sum] = "e42c371ea44b7121acd6c82e4a5e1b0db524b32fb19453b0556580a94c3c1bc5"

URI_aarch64_rust-nix0.30+mman-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+mman-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+mman-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+mman-devel}"
SRC_URI[aarch64_rust-nix0.30+mman-devel.sha256sum] = "9099406cd038919fdb2c04ccdc7182b14f06a73a499097e11159c7aff74e95f1"

URI_aarch64_rust-nix0.30+mount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+mount-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+mount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+mount-devel}"
SRC_URI[aarch64_rust-nix0.30+mount-devel.sha256sum] = "931f13575448ce045f8b2663edd03bad2878be46d06402c5efc672084ddf4588"

URI_aarch64_rust-nix0.30+mqueue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+mqueue-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+mqueue-devel}"
SRC_URI[aarch64_rust-nix0.30+mqueue-devel.sha256sum] = "5de20120fe45ca20385951fe247cf517b516ce11d9157de8fa4ea83eb26a9116"

URI_aarch64_rust-nix0.30+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+net-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+net-devel}"
SRC_URI[aarch64_rust-nix0.30+net-devel.sha256sum] = "ed1b004a73537f9253bc6d274b3f311c696c4cc06110a219992cef04f698d38f"

URI_aarch64_rust-nix0.30+personality-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+personality-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+personality-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+personality-devel}"
SRC_URI[aarch64_rust-nix0.30+personality-devel.sha256sum] = "20014da01f032dab791f322b6fb544f5c7f225f94b690522206826a6183250dc"

URI_aarch64_rust-nix0.30+pin-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+pin-utils-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+pin-utils-devel}"
SRC_URI[aarch64_rust-nix0.30+pin-utils-devel.sha256sum] = "07b442ff9dfb5f9334d060258f421e4f0cfa45b90b17539504368820773d7229"

URI_aarch64_rust-nix0.30+poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+poll-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+poll-devel}"
SRC_URI[aarch64_rust-nix0.30+poll-devel.sha256sum] = "c70ab2f121e60261ae6c1cf7620d6fc17fea988156ecec0fa1285581c54cf38e"

URI_aarch64_rust-nix0.30+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+process-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+process-devel}"
SRC_URI[aarch64_rust-nix0.30+process-devel.sha256sum] = "76d82ad5d59572f790c740a9e5595ec47ae0a98e3bd2304c16ce533232f7dfb1"

URI_aarch64_rust-nix0.30+pthread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+pthread-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+pthread-devel}"
SRC_URI[aarch64_rust-nix0.30+pthread-devel.sha256sum] = "3cd3ed65e9ca3f2233f1ec71106a862066f1b60e019cbf996bbf8798a2f3a801"

URI_aarch64_rust-nix0.30+ptrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+ptrace-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+ptrace-devel}"
SRC_URI[aarch64_rust-nix0.30+ptrace-devel.sha256sum] = "a91aca5f3cce3eaebf26768e7d54845683366d909bc9de437246c71ee8d7c3b3"

URI_aarch64_rust-nix0.30+quota-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+quota-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+quota-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+quota-devel}"
SRC_URI[aarch64_rust-nix0.30+quota-devel.sha256sum] = "6273f39d8202ef06c0ff3d0de40da172d6bbff50d96f2653a8088776abcb402d"

URI_aarch64_rust-nix0.30+reboot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+reboot-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+reboot-devel}"
SRC_URI[aarch64_rust-nix0.30+reboot-devel.sha256sum] = "12301b9083f53d2ab8e9ac0e2083e5c5ae1eb227277f8dda7b2f932124231238"

URI_aarch64_rust-nix0.30+resource-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+resource-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+resource-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+resource-devel}"
SRC_URI[aarch64_rust-nix0.30+resource-devel.sha256sum] = "8b195d9f59409afa83dbc2e46d166b91d4bb52c1fa739b23a0deb4f6267734aa"

URI_aarch64_rust-nix0.30+sched-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+sched-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+sched-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+sched-devel}"
SRC_URI[aarch64_rust-nix0.30+sched-devel.sha256sum] = "684340500a750b4faf97c91fecfb5841b10f16d55907efb16f9b77f41e6acec0"

URI_aarch64_rust-nix0.30+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+signal-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+signal-devel}"
SRC_URI[aarch64_rust-nix0.30+signal-devel.sha256sum] = "a6d00179359e2224f3eee64446448137a28376f681b619b9a5dd9c76bf6f8f31"

URI_aarch64_rust-nix0.30+socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+socket-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+socket-devel}"
SRC_URI[aarch64_rust-nix0.30+socket-devel.sha256sum] = "ee0a6d7bc63f4745e7a1e3988b677830aa26727b7b43d3b08b5604b0c626fbb6"

URI_aarch64_rust-nix0.30+syslog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+syslog-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+syslog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+syslog-devel}"
SRC_URI[aarch64_rust-nix0.30+syslog-devel.sha256sum] = "a6f38bca7242b0a4c0e91e487151e5c1156ed290f7227aa5a3c98c164f510a92"

URI_aarch64_rust-nix0.30+term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+term-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+term-devel}"
SRC_URI[aarch64_rust-nix0.30+term-devel.sha256sum] = "7169b17706f2a1d9775c0a915bcb268a7f0baafbd1195c0da63e2fdb9492a005"

URI_aarch64_rust-nix0.30+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+time-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+time-devel}"
SRC_URI[aarch64_rust-nix0.30+time-devel.sha256sum] = "88b1cace0eaa107a0cc2655e804fa83becfd401972f8734f7cdc7cbd44b1269b"

URI_aarch64_rust-nix0.30+ucontext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+ucontext-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+ucontext-devel}"
SRC_URI[aarch64_rust-nix0.30+ucontext-devel.sha256sum] = "27e984e380b5d82c9d84af283c356bb37bfe1edc1d38acb46cff2097125eab52"

URI_aarch64_rust-nix0.30+uio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+uio-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+uio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+uio-devel}"
SRC_URI[aarch64_rust-nix0.30+uio-devel.sha256sum] = "8e84761544b9194db0d4efff8e5d614bd8f2e6160b5805d79df5dcc36c2045e2"

URI_aarch64_rust-nix0.30+user-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+user-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+user-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+user-devel}"
SRC_URI[aarch64_rust-nix0.30+user-devel.sha256sum] = "524c1fe5398bae1ee0dbe21ff9c728d73120274c99ad5e8a2235539e55e9a184"

URI_aarch64_rust-nix0.30+zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30+zerocopy-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30+zerocopy-devel}"
SRC_URI[aarch64_rust-nix0.30+zerocopy-devel.sha256sum] = "3010008108d64bfa924b8c1e023950c29c5880b811eb065fda0f25aad25c5c35"

URI_aarch64_rust-nix0.30-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.30-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-nix0.30-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.30-devel}"
SRC_URI[aarch64_rust-nix0.30-devel.sha256sum] = "2100e1bc20cd5ac4c90458c00c71dfba37032874d7f52ea87e0c2a84494f55a8"

RDEPENDS:rust-nix0.30+acct-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+aio-devel = " \
 cargo \
 rust-nix0.30+pin-utils-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+default-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+dir-devel = " \
 cargo \
 rust-nix0.30+fs-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+env-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+event-devel = " \
 cargo \
 rust-nix0.30+poll-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+fanotify-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+feature-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+fs-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+hostname-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+inotify-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+ioctl-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+kmod-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+memoffset-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+mman-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+mount-devel = " \
 cargo \
 rust-nix0.30+uio-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+mqueue-devel = " \
 cargo \
 rust-nix0.30+fs-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+net-devel = " \
 cargo \
 rust-nix0.30+socket-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+personality-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+pin-utils-devel = " \
 cargo \
 rust-nix0.30-devel \
 rust-pin-utils+default-devel \
 "
RDEPENDS:rust-nix0.30+poll-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+process-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+pthread-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+ptrace-devel = " \
 cargo \
 rust-nix0.30+process-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+quota-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+reboot-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+resource-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+sched-devel = " \
 cargo \
 rust-nix0.30+process-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+signal-devel = " \
 cargo \
 rust-nix0.30+process-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+socket-devel = " \
 cargo \
 rust-nix0.30+memoffset-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+syslog-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+term-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+time-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+ucontext-devel = " \
 cargo \
 rust-nix0.30+signal-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+uio-devel = " \
 cargo \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+user-devel = " \
 cargo \
 rust-nix0.30+feature-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30+zerocopy-devel = " \
 cargo \
 rust-nix0.30+fs-devel \
 rust-nix0.30+uio-devel \
 rust-nix0.30-devel \
 "
RDEPENDS:rust-nix0.30-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-cfg_aliases+default-devel \
 rust-libc+default-devel \
 rust-libc+extra_traits-devel \
 "
