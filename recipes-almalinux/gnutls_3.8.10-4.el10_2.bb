# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnutls"
PV = "3.8.10"
PR = "4.el10_2"
PACKAGES = " \
 gnutls \
 gnutls-c++ \
 gnutls-dane \
 gnutls-devel \
 gnutls-fips \
 gnutls-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gnutls-3.8.10-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "048f590362d63b874209bfa4cc19be601f6046f9c161cabf1b3cee992e900da7"

URI_x86_64_v2_gnutls = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gnutls-3.8.10-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnutls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls}"
SRC_URI[x86_64_v2_gnutls.sha256sum] = "4241bd98588e293f1d9258eb495459167fe5ef3eaaa358a30c2b69493f87f3f6"

URI_x86_64_v2_gnutls-c++ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-c++-3.8.10-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnutls-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-c++}"
SRC_URI[x86_64_v2_gnutls-c++.sha256sum] = "2d027dda8502f115398726b10a3465d2e0069d6a34e2b97e41eb2ac78958283f"

URI_x86_64_v2_gnutls-dane = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-dane-3.8.10-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnutls-dane;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-dane}"
SRC_URI[x86_64_v2_gnutls-dane.sha256sum] = "e6cd034a6e65409ce94ea1403e9a8120f773b0fdcc63da61ade0755bddd73353"

URI_x86_64_v2_gnutls-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-devel-3.8.10-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnutls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-devel}"
SRC_URI[x86_64_v2_gnutls-devel.sha256sum] = "7ce7bd6e657c0b156eb26b530561d513823c319b3f0706c3f593cec42550adce"

URI_x86_64_v2_gnutls-fips = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-fips-3.8.10-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnutls-fips;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-fips}"
SRC_URI[x86_64_v2_gnutls-fips.sha256sum] = "432306d96462fd56e3d9e707ff7d2ea717b614f425a0093eb6b35ca384bea0c9"

URI_x86_64_v2_gnutls-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-utils-3.8.10-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnutls-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-utils}"
SRC_URI[x86_64_v2_gnutls-utils.sha256sum] = "7338df771166dbacae6212d9f5746b97da00e92a5bd6aa0801dbcc9d9402aed0"

URI_aarch64_gnutls = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gnutls-3.8.10-4.el10_2.aarch64.rpm;name=aarch64_gnutls;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls}"
SRC_URI[aarch64_gnutls.sha256sum] = "bf6127e4d56e1f52d18681d2b69226e213e96c1f6100515068c29c15b2c5d50c"

URI_aarch64_gnutls-c++ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-c++-3.8.10-4.el10_2.aarch64.rpm;name=aarch64_gnutls-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-c++}"
SRC_URI[aarch64_gnutls-c++.sha256sum] = "a2d9065f01739cf0753a14422b181dfab8e81b2ca0090f513ce942fbcb0f79ea"

URI_aarch64_gnutls-dane = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-dane-3.8.10-4.el10_2.aarch64.rpm;name=aarch64_gnutls-dane;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-dane}"
SRC_URI[aarch64_gnutls-dane.sha256sum] = "89d5b706db4bee8fc3ffba4de756cf5a5ca5f27a481a7e8e1fbe54cc8a1ff915"

URI_aarch64_gnutls-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-devel-3.8.10-4.el10_2.aarch64.rpm;name=aarch64_gnutls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-devel}"
SRC_URI[aarch64_gnutls-devel.sha256sum] = "84573f2d04f825a7bbaef8711461c0cf4e2c1cc6e8af1a2668477ed9cd4f4984"

URI_aarch64_gnutls-fips = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-fips-3.8.10-4.el10_2.aarch64.rpm;name=aarch64_gnutls-fips;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-fips}"
SRC_URI[aarch64_gnutls-fips.sha256sum] = "1b52a585e4043d25fe3be03487c0c2ce9c89449c2bad68b5542b02467042671a"

URI_aarch64_gnutls-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-utils-3.8.10-4.el10_2.aarch64.rpm;name=aarch64_gnutls-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-utils}"
SRC_URI[aarch64_gnutls-utils.sha256sum] = "fa1d589c3a3b71e54a3cd7815b08af7e8b185790018517f12485f0a145dc2104"

RDEPENDS:gnutls = " \
 crypto-policies \
 glibc \
 libidn2 \
 libtasn1 \
 libunistring \
 p11-kit \
 p11-kit-trust \
 "
RDEPENDS:gnutls-c++ = " \
 glibc \
 gnutls \
 libgcc \
 libidn2 \
 libstdc++ \
 libtasn1 \
 libunistring \
 p11-kit \
 "
RDEPENDS:gnutls-dane = " \
 glibc \
 gnutls \
 libidn2 \
 libtasn1 \
 libunistring \
 p11-kit \
 unbound-libs \
 "
RDEPENDS:gnutls-devel = " \
 gnutls \
 gnutls-c++ \
 gnutls-dane \
 gnutls-devel \
 libidn2-devel \
 libtasn1-devel \
 p11-kit-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gnutls-fips = " \
 gnutls \
 "
RDEPENDS:gnutls-utils = " \
 glibc \
 gnutls \
 gnutls-dane \
 libtasn1 \
 "
