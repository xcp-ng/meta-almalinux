# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "thermald"
PV = "2.5.10"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 thermald \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/thermald-2.5.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58e8d427211390225c083206c254dca152877972d54b8cc92e5ef2cfb4e49727"

URI_x86_64_v2_thermald = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/thermald-2.5.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_thermald;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thermald}"
SRC_URI[x86_64_v2_thermald.sha256sum] = "56c87d909bf0d258761b23ea23fa64c86c62702d1dae83c393ef3d20290e3b69"

RDEPENDS:thermald = " \
 bash \
 dbus \
 glib2 \
 glibc \
 glibc-common \
 libevdev \
 libgcc \
 libstdc++ \
 libxml2 \
 shadow-utils \
 systemd \
 upower-libs \
 "
