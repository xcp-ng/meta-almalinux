# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-backtrace"
PV = "0.3.76"
PR = "1.el10_2"
PACKAGES = " \
 rust-backtrace+cpp_demangle-devel \
 rust-backtrace+default-devel \
 rust-backtrace+dl_iterate_phdr-devel \
 rust-backtrace+ruzstd-devel \
 rust-backtrace+serde-devel \
 rust-backtrace+serialize-serde-devel \
 rust-backtrace+std-devel \
 rust-backtrace-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-backtrace-0.3.76-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0398d9a16cc5400eda1b9c55fb8d166300230e630689f22d91f54f77807c22e7"

URI_x86_64_v2_rust-backtrace+cpp_demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+cpp_demangle-devel-0.3.76-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+cpp_demangle-devel}"
SRC_URI[x86_64_v2_rust-backtrace+cpp_demangle-devel.sha256sum] = "8a40b22f72b62cb0676a3da14ef261a6cf0a4c73df0701c8e27488ccad15db08"

URI_x86_64_v2_rust-backtrace+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+default-devel-0.3.76-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+default-devel}"
SRC_URI[x86_64_v2_rust-backtrace+default-devel.sha256sum] = "8bdda9e071bc162ae3c7b0508730698675b6ccec8957980c7f43f04cf66ab44f"

URI_x86_64_v2_rust-backtrace+dl_iterate_phdr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+dl_iterate_phdr-devel-0.3.76-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+dl_iterate_phdr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+dl_iterate_phdr-devel}"
SRC_URI[x86_64_v2_rust-backtrace+dl_iterate_phdr-devel.sha256sum] = "4c380ce70c0c01f569f7c1a99ec033726319c91e20e2aa2aa9ee92b80a554d88"

URI_x86_64_v2_rust-backtrace+ruzstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+ruzstd-devel-0.3.76-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+ruzstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+ruzstd-devel}"
SRC_URI[x86_64_v2_rust-backtrace+ruzstd-devel.sha256sum] = "2789024935d4ca50a73165b6fcfa839a82e086c0eb713567ad49ac309c9933ac"

URI_x86_64_v2_rust-backtrace+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+serde-devel-0.3.76-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+serde-devel}"
SRC_URI[x86_64_v2_rust-backtrace+serde-devel.sha256sum] = "bee37cc446903951089c142ba39172bfb51791a0260405eb41418343d99b7bfe"

URI_x86_64_v2_rust-backtrace+serialize-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+serialize-serde-devel-0.3.76-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+serialize-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+serialize-serde-devel}"
SRC_URI[x86_64_v2_rust-backtrace+serialize-serde-devel.sha256sum] = "567be3a3a551689d7e57405a887af4e68c387cc0b05f63f0b792085ca50f397f"

URI_x86_64_v2_rust-backtrace+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+std-devel-0.3.76-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+std-devel}"
SRC_URI[x86_64_v2_rust-backtrace+std-devel.sha256sum] = "8fff10370b5ba061adb1d4cb15d02a4a4ddeb5be229d76c935068160d09d6090"

URI_x86_64_v2_rust-backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace-devel-0.3.76-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace-devel}"
SRC_URI[x86_64_v2_rust-backtrace-devel.sha256sum] = "bfc89e0e787aa8d3a96bb0bba9ed1817fc2db90f560f886aea2571d02dd203c4"

URI_aarch64_rust-backtrace+cpp_demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+cpp_demangle-devel-0.3.76-1.el10_2.noarch.rpm;name=aarch64_rust-backtrace+cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+cpp_demangle-devel}"
SRC_URI[aarch64_rust-backtrace+cpp_demangle-devel.sha256sum] = "39a9efeeea93f11315f06e9d4ad819aa6712735d0058aaece17891f762e0b714"

URI_aarch64_rust-backtrace+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+default-devel-0.3.76-1.el10_2.noarch.rpm;name=aarch64_rust-backtrace+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+default-devel}"
SRC_URI[aarch64_rust-backtrace+default-devel.sha256sum] = "1a7636e9ca682b29b138569c8336f4b92ab8205476e62ef4afc533340ad93576"

URI_aarch64_rust-backtrace+dl_iterate_phdr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+dl_iterate_phdr-devel-0.3.76-1.el10_2.noarch.rpm;name=aarch64_rust-backtrace+dl_iterate_phdr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+dl_iterate_phdr-devel}"
SRC_URI[aarch64_rust-backtrace+dl_iterate_phdr-devel.sha256sum] = "8e291868ad65cad4656de8241bddce0dcb9d66ff94dfafe72927e0807a5e72b3"

URI_aarch64_rust-backtrace+ruzstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+ruzstd-devel-0.3.76-1.el10_2.noarch.rpm;name=aarch64_rust-backtrace+ruzstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+ruzstd-devel}"
SRC_URI[aarch64_rust-backtrace+ruzstd-devel.sha256sum] = "2025c92313440cad68252479eaee3a103d4cb39a44e25b78c8bfb1b783291187"

URI_aarch64_rust-backtrace+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+serde-devel-0.3.76-1.el10_2.noarch.rpm;name=aarch64_rust-backtrace+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+serde-devel}"
SRC_URI[aarch64_rust-backtrace+serde-devel.sha256sum] = "a3a0f93d8134a23a204b263314d347ab79839c7d457b6fb846eeea27a019e071"

URI_aarch64_rust-backtrace+serialize-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+serialize-serde-devel-0.3.76-1.el10_2.noarch.rpm;name=aarch64_rust-backtrace+serialize-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+serialize-serde-devel}"
SRC_URI[aarch64_rust-backtrace+serialize-serde-devel.sha256sum] = "44f1fbba00db278b1890a871710cc823188275885d137fff786bfba0270a71ba"

URI_aarch64_rust-backtrace+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+std-devel-0.3.76-1.el10_2.noarch.rpm;name=aarch64_rust-backtrace+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+std-devel}"
SRC_URI[aarch64_rust-backtrace+std-devel.sha256sum] = "20545c4819bfba8a6edbb3a79b05d11deaf357d126d5266f5229d2ed73dfdcee"

URI_aarch64_rust-backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace-devel-0.3.76-1.el10_2.noarch.rpm;name=aarch64_rust-backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace-devel}"
SRC_URI[aarch64_rust-backtrace-devel.sha256sum] = "dde7635918cb379319e702bb762d4640132165e658067e6052dda6966aef4883"

RDEPENDS:rust-backtrace+cpp_demangle-devel = " \
 cargo \
 rust-backtrace-devel \
 rust-cpp_demangle+alloc-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-backtrace+default-devel = " \
 cargo \
 rust-backtrace+std-devel \
 rust-backtrace-devel \
 "
RDEPENDS:rust-backtrace+dl_iterate_phdr-devel = " \
 cargo \
 rust-backtrace-devel \
 "
RDEPENDS:rust-backtrace+ruzstd-devel = " \
 cargo \
 rust-backtrace-devel \
 rust-ruzstd-devel \
 "
RDEPENDS:rust-backtrace+serde-devel = " \
 cargo \
 rust-backtrace-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-backtrace+serialize-serde-devel = " \
 cargo \
 rust-backtrace+serde-devel \
 rust-backtrace-devel \
 "
RDEPENDS:rust-backtrace+std-devel = " \
 cargo \
 rust-backtrace-devel \
 "
RDEPENDS:rust-backtrace-devel = " \
 cargo \
 rust \
 rust-addr2line-devel \
 rust-cfg-if+default-devel \
 rust-libc-devel \
 rust-miniz_oxide0.8-devel \
 rust-object0.37+archive-devel \
 rust-object0.37+elf-devel \
 rust-object0.37+macho-devel \
 rust-object0.37+pe-devel \
 rust-object0.37+read_core-devel \
 rust-object0.37+unaligned-devel \
 rust-object0.37+xcoff-devel \
 rust-object0.37-devel \
 rust-rustc-demangle+default-devel \
 "
