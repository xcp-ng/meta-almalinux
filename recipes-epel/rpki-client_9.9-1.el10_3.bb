# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpki-client"
PV = "9.9"
PR = "1.el10_3"
PACKAGES = " \
 rpki-client \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rpki-client-9.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "be98fedd39bdd1fe29a6a5498954f47f7fd9466a6320242bada758f1686395bf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpki-client-9.9-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpki-client;unpack=0"
SRC_URI[x86_64_v2_rpki-client.sha256sum] = "5941254076a9fef6b57bc499e14523cc4e80b6e897c98ada8a5f11e771a12617"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rpki-client-9.9-1.el10_3.aarch64.rpm;name=aarch64_rpki-client;unpack=0"
SRC_URI[aarch64_rpki-client.sha256sum] = "4775bd80a86413ad556b28b9bd8396082a2be5b653b2b6a9bd29d38337c30e80"

RDEPENDS:rpki-client = " \
 bash \
 expat \
 glibc \
 libretls \
 openssl-libs \
 rsync \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
