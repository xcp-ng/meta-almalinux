# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-basexx"
PV = "0.4.0"
PR = "15.el10_1"
PACKAGES = " \
 lua-basexx \
 lua5.1-basexx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-basexx-0.4.0-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b876150d02aed71825e0590575f8e6fb845272997049286b1e0d44243bcec9aa"

URI_x86_64_v2_lua-basexx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-basexx-0.4.0-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua-basexx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-basexx}"
SRC_URI[x86_64_v2_lua-basexx.sha256sum] = "5658992c70a1ca31d103a791d503e7aae2b922a87764ab15f439e5069e76437d"

URI_x86_64_v2_lua5.1-basexx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-basexx-0.4.0-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua5.1-basexx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-basexx}"
SRC_URI[x86_64_v2_lua5.1-basexx.sha256sum] = "8d610df19151a96f0344430518d113c831c73cedd1291c61bedfab5875eba447"

URI_aarch64_lua-basexx = "${EPEL_MIRROR}/aarch64/Packages/l/lua-basexx-0.4.0-15.el10_1.noarch.rpm;name=aarch64_lua-basexx;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-basexx}"
SRC_URI[aarch64_lua-basexx.sha256sum] = "a4abb55c2026cd4e32b8b7c532aee1a42a990f0c4e306ca894d23240d20e5123"

URI_aarch64_lua5.1-basexx = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-basexx-0.4.0-15.el10_1.noarch.rpm;name=aarch64_lua5.1-basexx;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-basexx}"
SRC_URI[aarch64_lua5.1-basexx.sha256sum] = "0fe870c4c6d353c5b0d5bc61d441733b188f52d4608945c0933e9be079f5c39d"

RDEPENDS:lua-basexx = " \
 "
RDEPENDS:lua5.1-basexx = " \
 "
