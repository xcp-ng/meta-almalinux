# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-inotify-survey"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kde-inotify-survey \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kde-inotify-survey-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d8f07ddecdc142f534530dea8b1fdb3c31e247368bfab2ea303114133bd5fb57"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-inotify-survey-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-inotify-survey;unpack=0"
SRC_URI[x86_64_v2_kde-inotify-survey.sha256sum] = "34b8faebea5d7a96a29deb7aa05b6c1f41702652fbfc47ff7a4dd707eb578abf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-inotify-survey-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kde-inotify-survey;unpack=0"
SRC_URI[aarch64_kde-inotify-survey.sha256sum] = "ba55def9dc92080403c7ef3c04b43f75edb868f7d4234b533cf00853e61905a2"

RDEPENDS:kde-inotify-survey = " \
 dbus-common \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kded \
 kf6-ki18n \
 kf6-knotifications \
 libstdc++ \
 polkit \
 qt6-qtbase \
 "
