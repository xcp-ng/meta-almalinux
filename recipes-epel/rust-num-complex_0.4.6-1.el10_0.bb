# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-complex"
PV = "0.4.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-num-complex+bytecheck-devel \
 rust-num-complex+bytemuck-devel \
 rust-num-complex+default-devel \
 rust-num-complex+libm-devel \
 rust-num-complex+rand-devel \
 rust-num-complex+rkyv-devel \
 rust-num-complex+serde-devel \
 rust-num-complex+std-devel \
 rust-num-complex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-complex-0.4.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aaccaf2ed39d3ae57cf4026554c962c23d6e4cfb0daa7e6b796961e9ccc73ae0"

URI_x86_64_v2_rust-num-complex+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-complex+bytecheck-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-complex+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-complex+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-num-complex+bytecheck-devel.sha256sum] = "2d67d4bdecdd0b7d76f1d8b364f7d86809b257dd40cc04c054f213beacfb69a8"

URI_x86_64_v2_rust-num-complex+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-complex+bytemuck-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-complex+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-complex+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-num-complex+bytemuck-devel.sha256sum] = "3649bfe583aae22be910bb2cbf5014237436075890b63e4bd2fc4b9a17b71087"

URI_x86_64_v2_rust-num-complex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-complex+default-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-complex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-complex+default-devel}"
SRC_URI[x86_64_v2_rust-num-complex+default-devel.sha256sum] = "ef49d956a55cfc8417b367ee89de72c96ba9535d379596e3b80e5e19113e8067"

URI_x86_64_v2_rust-num-complex+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-complex+libm-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-complex+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-complex+libm-devel}"
SRC_URI[x86_64_v2_rust-num-complex+libm-devel.sha256sum] = "78cff6d765a9d5cfe60ece11bc433b182cb72b97e50b7c9ce3dd0161bb1a1539"

URI_x86_64_v2_rust-num-complex+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-complex+rand-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-complex+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-complex+rand-devel}"
SRC_URI[x86_64_v2_rust-num-complex+rand-devel.sha256sum] = "d67c1f851282f0287370ccfa514f7761650029a80a4eda6e0f10680057091777"

URI_x86_64_v2_rust-num-complex+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-complex+rkyv-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-complex+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-complex+rkyv-devel}"
SRC_URI[x86_64_v2_rust-num-complex+rkyv-devel.sha256sum] = "f6d61e05c7b73ecb69f1f9d06f5646e63bc487176cc453d68c1643812d084d0a"

URI_x86_64_v2_rust-num-complex+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-complex+serde-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-complex+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-complex+serde-devel}"
SRC_URI[x86_64_v2_rust-num-complex+serde-devel.sha256sum] = "4cd70cf7e7c568aa1a5dfa3ae75c199bac74afebfa397d329d260286115c50d6"

URI_x86_64_v2_rust-num-complex+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-complex+std-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-complex+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-complex+std-devel}"
SRC_URI[x86_64_v2_rust-num-complex+std-devel.sha256sum] = "821cb647579e5dc03639e4dd9faeea358d7dcbdbbfd506194ff7af8311a58a3b"

URI_x86_64_v2_rust-num-complex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-complex-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-complex-devel}"
SRC_URI[x86_64_v2_rust-num-complex-devel.sha256sum] = "b5e209b73b4fa11ad00e0316fe96a7553aa58ba5d941ff38c936d07ab71b38c4"

URI_aarch64_rust-num-complex+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-complex+bytecheck-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-num-complex+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-complex+bytecheck-devel}"
SRC_URI[aarch64_rust-num-complex+bytecheck-devel.sha256sum] = "65a90d9b033f186fe2c4da38f1825d4948ffe1cee01fe212cd52ab33ce4d4e1e"

URI_aarch64_rust-num-complex+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-complex+bytemuck-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-num-complex+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-complex+bytemuck-devel}"
SRC_URI[aarch64_rust-num-complex+bytemuck-devel.sha256sum] = "f45fd09683611f43b72897f3cff825c74955955600dced6134cfd38eaba7903d"

URI_aarch64_rust-num-complex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-complex+default-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-num-complex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-complex+default-devel}"
SRC_URI[aarch64_rust-num-complex+default-devel.sha256sum] = "998b55805b83b007293660de714b1a408e3f302ab55ec7f1597824caacef977e"

URI_aarch64_rust-num-complex+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-complex+libm-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-num-complex+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-complex+libm-devel}"
SRC_URI[aarch64_rust-num-complex+libm-devel.sha256sum] = "afa572b274a97da1e51761d443c939da7cb6c968ad8d2452a6334f900abb229f"

URI_aarch64_rust-num-complex+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-complex+rand-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-num-complex+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-complex+rand-devel}"
SRC_URI[aarch64_rust-num-complex+rand-devel.sha256sum] = "0db137d92ecfd29d1353f6466583a87037d1e67e7aa60dafb727960ad64a9379"

URI_aarch64_rust-num-complex+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-complex+rkyv-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-num-complex+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-complex+rkyv-devel}"
SRC_URI[aarch64_rust-num-complex+rkyv-devel.sha256sum] = "f33968ac8476dc6203a98ccf10b0d332eb6ad2eb6beee958e710304715bc353d"

URI_aarch64_rust-num-complex+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-complex+serde-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-num-complex+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-complex+serde-devel}"
SRC_URI[aarch64_rust-num-complex+serde-devel.sha256sum] = "63a7d188a72de13ba00fd82afcf5faec42286934634f442fff00a35dea96597e"

URI_aarch64_rust-num-complex+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-complex+std-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-num-complex+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-complex+std-devel}"
SRC_URI[aarch64_rust-num-complex+std-devel.sha256sum] = "e8b6851e3fec552959c14df3e50c65c56a25dadcc799ee0cb478bb7892ed7f54"

URI_aarch64_rust-num-complex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-complex-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-complex-devel}"
SRC_URI[aarch64_rust-num-complex-devel.sha256sum] = "87cf26b8674642de41ce01df61d91760a31bfe883803e818b32544d2be58508f"

RDEPENDS:rust-num-complex+bytecheck-devel = " \
 cargo \
 rust-bytecheck0.6-devel \
 rust-num-complex-devel \
 "
RDEPENDS:rust-num-complex+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-num-complex-devel \
 "
RDEPENDS:rust-num-complex+default-devel = " \
 cargo \
 rust-num-complex+std-devel \
 rust-num-complex-devel \
 "
RDEPENDS:rust-num-complex+libm-devel = " \
 cargo \
 rust-num-complex-devel \
 rust-num-traits+libm-devel \
 "
RDEPENDS:rust-num-complex+rand-devel = " \
 cargo \
 rust-num-complex-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-num-complex+rkyv-devel = " \
 cargo \
 rust-num-complex-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-num-complex+serde-devel = " \
 cargo \
 rust-num-complex-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-num-complex+std-devel = " \
 cargo \
 rust-num-complex-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-complex-devel = " \
 cargo \
 rust \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
