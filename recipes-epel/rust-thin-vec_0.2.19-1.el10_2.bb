# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thin-vec"
PV = "0.2.19"
PR = "1.el10_2"
PACKAGES = " \
 rust-thin-vec+const_new-devel \
 rust-thin-vec+default-devel \
 rust-thin-vec+gecko-ffi-devel \
 rust-thin-vec+serde-devel \
 rust-thin-vec+std-devel \
 rust-thin-vec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thin-vec-0.2.19-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e97afe856d3981c381b0194adb60ca1698bb337ee969e34732cd0fb2d56fc50"

URI_x86_64_v2_rust-thin-vec+const_new-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+const_new-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+const_new-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+const_new-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+const_new-devel.sha256sum] = "7404298201420a8abfe8a6472ea1c26ff3a282acf481135892da45413ad7ffe8"

URI_x86_64_v2_rust-thin-vec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+default-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+default-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+default-devel.sha256sum] = "cc69e9f80586f8e44158a40b6ae068d3fabc41590a87978ca1f165b2ae247846"

URI_x86_64_v2_rust-thin-vec+gecko-ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+gecko-ffi-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+gecko-ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+gecko-ffi-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+gecko-ffi-devel.sha256sum] = "957b0ef8e23e0bb5dd6ee958e081447296dbb9e2d09fc181e4d4d80aebc103b0"

URI_x86_64_v2_rust-thin-vec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+serde-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+serde-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+serde-devel.sha256sum] = "b8fefd73cd1a25e9178dca9e4fdf4255c41874ddf5a17a1edae579cf06b4ff3e"

URI_x86_64_v2_rust-thin-vec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+std-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+std-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+std-devel.sha256sum] = "7e0f4d857af29941d2057bc3a7eafad9040ee2013c7d86fc2a67559f952a2314"

URI_x86_64_v2_rust-thin-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec-devel}"
SRC_URI[x86_64_v2_rust-thin-vec-devel.sha256sum] = "b42e1cf70b931bdb6c43b9ff3d4a9e66b646a43a2d59098f1b4a9b8cc4054fe2"

URI_aarch64_rust-thin-vec+const_new-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+const_new-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-thin-vec+const_new-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+const_new-devel}"
SRC_URI[aarch64_rust-thin-vec+const_new-devel.sha256sum] = "b4da9bc9af7f2d7621e7039186802457e784fa7f45d28d57e155884308a406f2"

URI_aarch64_rust-thin-vec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+default-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-thin-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+default-devel}"
SRC_URI[aarch64_rust-thin-vec+default-devel.sha256sum] = "1e340e2795d0b0118fcc1e5f712231e14ca9db5e7da22d08fbbe9c1bc185c47b"

URI_aarch64_rust-thin-vec+gecko-ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+gecko-ffi-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-thin-vec+gecko-ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+gecko-ffi-devel}"
SRC_URI[aarch64_rust-thin-vec+gecko-ffi-devel.sha256sum] = "df91a81acfaddaec2be7ff0f1b46c5c2306b59252956d61203e0a77a8353f211"

URI_aarch64_rust-thin-vec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+serde-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-thin-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+serde-devel}"
SRC_URI[aarch64_rust-thin-vec+serde-devel.sha256sum] = "943eea4d702486af562f6100ef65117896cddd44e59780042757cf473f940d4d"

URI_aarch64_rust-thin-vec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+std-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-thin-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+std-devel}"
SRC_URI[aarch64_rust-thin-vec+std-devel.sha256sum] = "5a3cffef17b5ace76ac8b63b8d05d8b79768cbfd0cec38be6ba48fe4655779ed"

URI_aarch64_rust-thin-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-thin-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec-devel}"
SRC_URI[aarch64_rust-thin-vec-devel.sha256sum] = "43e0ce48e0ecfe9347229468dcd217afb3c7a67f18393628e1a04264e73014f2"

RDEPENDS:rust-thin-vec+const_new-devel = " \
 cargo \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+default-devel = " \
 cargo \
 rust-thin-vec+std-devel \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+gecko-ffi-devel = " \
 cargo \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+std-devel = " \
 cargo \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec-devel = " \
 cargo \
 rust \
 "
