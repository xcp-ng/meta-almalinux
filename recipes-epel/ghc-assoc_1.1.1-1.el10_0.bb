# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-assoc"
PV = "1.1.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-assoc \
 ghc-assoc-devel \
 ghc-assoc-doc \
 ghc-assoc-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-assoc-1.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd47ac31e505970e6fbf43d8af96189ab154e71eeba2a81d5dd27c1a8d85d6d9"

URI_x86_64_v2_ghc-assoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-assoc-1.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-assoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-assoc}"
SRC_URI[x86_64_v2_ghc-assoc.sha256sum] = "cdd449e5ad528e7b125701c9b3663af3045b86470214350a6e38bbb963b18383"

URI_x86_64_v2_ghc-assoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-assoc-devel-1.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-assoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-assoc-devel}"
SRC_URI[x86_64_v2_ghc-assoc-devel.sha256sum] = "a3f30f29be5683f7f603daa30b29df2dc892d1bb38cb944c36df9a1f0080a83c"

URI_x86_64_v2_ghc-assoc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-assoc-doc-1.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-assoc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-assoc-doc}"
SRC_URI[x86_64_v2_ghc-assoc-doc.sha256sum] = "29f9c5ee9b805be84fc228f22df5c4381b30c5a45b33c1dd021b06fd3c9ae2bf"

URI_x86_64_v2_ghc-assoc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-assoc-prof-1.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-assoc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-assoc-prof}"
SRC_URI[x86_64_v2_ghc-assoc-prof.sha256sum] = "de90cd82f836fa6c7e0f7dd04e9d0538ff4a4b554aac688dd19a6d47a996587f"

URI_aarch64_ghc-assoc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-assoc-1.1.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-assoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-assoc}"
SRC_URI[aarch64_ghc-assoc.sha256sum] = "d15af0c4a9f4259156dce8d956a640e7614b3e139b3c073c0ecacb2f6bef8c11"

URI_aarch64_ghc-assoc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-assoc-devel-1.1.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-assoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-assoc-devel}"
SRC_URI[aarch64_ghc-assoc-devel.sha256sum] = "07290563de48dc1210e85c0c341d5c04e48cf111689a1bb056affbe816669e37"

URI_aarch64_ghc-assoc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-assoc-doc-1.1.1-1.el10_0.noarch.rpm;name=aarch64_ghc-assoc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-assoc-doc}"
SRC_URI[aarch64_ghc-assoc-doc.sha256sum] = "a4b62479e3535da5c0e4fc047ffb21538af750349cc047d6ea17ed6d665f4ce5"

URI_aarch64_ghc-assoc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-assoc-prof-1.1.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-assoc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-assoc-prof}"
SRC_URI[aarch64_ghc-assoc-prof.sha256sum] = "23ea0f7c38ae071f2cbe44ec9f4dab9a4c1b1dff7d7a669e334de071dde4a071"

RDEPENDS:ghc-assoc = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-assoc-devel = " \
 ghc-assoc \
 ghc-base-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-assoc-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-assoc-prof = " \
 ghc-assoc-devel \
 ghc-base-prof \
 "
