# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hardinfo2"
PV = "2.2.7"
PR = "1.el10_0"
PACKAGES = " \
 hardinfo2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hardinfo2-2.2.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a61407542f28276375a75de7d81917ab89d07f009f48ef5387a6b5c68e341d7b"

URI_x86_64_v2_hardinfo2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hardinfo2-2.2.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hardinfo2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hardinfo2}"
SRC_URI[x86_64_v2_hardinfo2.sha256sum] = "cbc733c1b229453f4b6c49c6764c6c39a4c40d6ed6d6a7cc3255887142f6f215"

URI_aarch64_hardinfo2 = "${EPEL_MIRROR}/aarch64/Packages/h/hardinfo2-2.2.7-1.el10_0.aarch64.rpm;name=aarch64_hardinfo2;unpack=0"
SRC_URI:append = " ${URI_aarch64_hardinfo2}"
SRC_URI[aarch64_hardinfo2.sha256sum] = "b5f62012d8279a8220608eca0429cd70c5a2af69286de13dd1f1c0a61323fbfe"

RDEPENDS:hardinfo2 = " \
 bash \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 json-glib \
 libX11 \
 libgcc \
 libsoup3 \
 libstdc++ \
 pango \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
