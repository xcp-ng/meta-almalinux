# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "adplug"
PV = "2.3.3"
PR = "11.el10_0"
PACKAGES = " \
 adplug \
 adplug-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/adplug-2.3.3-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19f32bbf9048fee5b59bdb360d4d027b5c60cd21b3d122febf3b29e419f4e60e"

URI_x86_64_v2_adplug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/adplug-2.3.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_adplug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adplug}"
SRC_URI[x86_64_v2_adplug.sha256sum] = "27a00264dfeea1620c1b80e1f9b0868024450c81aba630b98e3f2dab349fa82c"

URI_x86_64_v2_adplug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/adplug-devel-2.3.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_adplug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adplug-devel}"
SRC_URI[x86_64_v2_adplug-devel.sha256sum] = "d60892b8d8737e286f3b177b7008f300fd1732458610040fc921f2d4ca168753"

URI_aarch64_adplug = "${EPEL_MIRROR}/aarch64/Packages/a/adplug-2.3.3-11.el10_0.aarch64.rpm;name=aarch64_adplug;unpack=0"
SRC_URI:append = " ${URI_aarch64_adplug}"
SRC_URI[aarch64_adplug.sha256sum] = "6be2766ddef858feae994dfd25cd713c5a2ab16e3b2b2b52bdbc362db6b86940"

URI_aarch64_adplug-devel = "${EPEL_MIRROR}/aarch64/Packages/a/adplug-devel-2.3.3-11.el10_0.aarch64.rpm;name=aarch64_adplug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_adplug-devel}"
SRC_URI[aarch64_adplug-devel.sha256sum] = "79b5bfd4a8f6ffb93df6cc05aeae92da8376e2f1bdfd0e4d53efd258a08cb5ca"

RDEPENDS:adplug = " \
 glibc \
 libbinio \
 libgcc \
 libstdc++ \
 "
RDEPENDS:adplug-devel = " \
 adplug \
 libbinio-devel \
 pkgconf-pkg-config \
 "
