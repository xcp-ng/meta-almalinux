# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-options"
PV = "0.8.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo-options+default-devel \
 rust-cargo-options+serde-devel \
 rust-cargo-options-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-options-0.8.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cadffb0c9190a19fb44daeb603b82a876fb9d447e1f8b28dbd5316b04f2a12c9"

URI_x86_64_v2_rust-cargo-options+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-options+default-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-options+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-options+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-options+default-devel.sha256sum] = "f118eafe0f19867935436cd3ce45f42531ecb86395f1e993c8867eab3db53970"

URI_x86_64_v2_rust-cargo-options+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-options+serde-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-options+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-options+serde-devel}"
SRC_URI[x86_64_v2_rust-cargo-options+serde-devel.sha256sum] = "04eb8e8b9465b67baf589e07b70d611880dc9c51c38ec1457b1e8f9cdffcb7ca"

URI_x86_64_v2_rust-cargo-options-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-options-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-options-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-options-devel}"
SRC_URI[x86_64_v2_rust-cargo-options-devel.sha256sum] = "5acd56c534b83d64180e5f6a4ff7e33251d1ef9ccbef53d31caef38956c0c6bb"

URI_aarch64_rust-cargo-options+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-options+default-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-options+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-options+default-devel}"
SRC_URI[aarch64_rust-cargo-options+default-devel.sha256sum] = "b5cf59ce1f9f00903eefc7696b47617983923f2c04cb14af0cedd45b6e8466c7"

URI_aarch64_rust-cargo-options+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-options+serde-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-options+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-options+serde-devel}"
SRC_URI[aarch64_rust-cargo-options+serde-devel.sha256sum] = "f41f1268c707a46985f9213b48342580a759d7a866c8202d1d6efb498e231309"

URI_aarch64_rust-cargo-options-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-options-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-options-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-options-devel}"
SRC_URI[aarch64_rust-cargo-options-devel.sha256sum] = "c22fc6b15c226ee8e0eea4b587fd8930f33f54e5646038c76b5e15352502ac99"

RDEPENDS:rust-cargo-options+default-devel = " \
 cargo \
 rust-cargo-options-devel \
 "
RDEPENDS:rust-cargo-options+serde-devel = " \
 cargo \
 rust-cargo-options-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-cargo-options-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+unstable-styles-devel \
 rust-clap+wrap_help-devel \
 "
