# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nbdkit"
PV = "1.40.4"
PR = "4.el10_0"
PACKAGES:x86_64_v2 = " \
 nbdkit \
 nbdkit-bash-completion \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-curl-plugin \
 nbdkit-devel \
 nbdkit-example-plugins \
 nbdkit-linuxdisk-plugin \
 nbdkit-nbd-plugin \
 nbdkit-python-plugin \
 nbdkit-selinux \
 nbdkit-server \
 nbdkit-srpm-macros \
 nbdkit-ssh-plugin \
 nbdkit-tar-filter \
 nbdkit-tmpdisk-plugin \
 nbdkit-vddk-plugin \
 nbdkit-xz-filter \
"
PACKAGES:aarch64 = " \
 nbdkit \
 nbdkit-bash-completion \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-curl-plugin \
 nbdkit-devel \
 nbdkit-example-plugins \
 nbdkit-linuxdisk-plugin \
 nbdkit-nbd-plugin \
 nbdkit-python-plugin \
 nbdkit-selinux \
 nbdkit-server \
 nbdkit-srpm-macros \
 nbdkit-ssh-plugin \
 nbdkit-tar-filter \
 nbdkit-tmpdisk-plugin \
 nbdkit-xz-filter \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nbdkit-1.40.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36db921d645261cf34ff9d685545358527599fdc667dff92f1269910844dcb29"

URI_x86_64_v2_nbdkit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit}"
SRC_URI[x86_64_v2_nbdkit.sha256sum] = "91035a744f04a090020e46eab76acaf78ab14e6dbd5ee881d236b3de7c26fa78"

URI_x86_64_v2_nbdkit-bash-completion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-bash-completion-1.40.4-4.el10_0.noarch.rpm;name=x86_64_v2_nbdkit-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-bash-completion}"
SRC_URI[x86_64_v2_nbdkit-bash-completion.sha256sum] = "cfa6a5e80fc664ae79b09e61b6047a9d7559d8e89efd56cef6a02a23abec498c"

URI_x86_64_v2_nbdkit-basic-filters = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-basic-filters-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-basic-filters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-basic-filters}"
SRC_URI[x86_64_v2_nbdkit-basic-filters.sha256sum] = "bd73231543656454b4f9e40a2588066ed92898943c9c1dfadd284c83643b8c67"

URI_x86_64_v2_nbdkit-basic-plugins = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-basic-plugins-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-basic-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-basic-plugins}"
SRC_URI[x86_64_v2_nbdkit-basic-plugins.sha256sum] = "7fa52e4dd9671f07097b4949942be8a86b6d5597aea56d28c21146dcd3c532c6"

URI_x86_64_v2_nbdkit-curl-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-curl-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-curl-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-curl-plugin}"
SRC_URI[x86_64_v2_nbdkit-curl-plugin.sha256sum] = "318b5de21dca4abc46f9ccc2da64c3066ac683f33597ca8479edd323aafb5fa2"

URI_x86_64_v2_nbdkit-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nbdkit-devel-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-devel}"
SRC_URI[x86_64_v2_nbdkit-devel.sha256sum] = "860ec505c9a6a8b2e0ca1e8672fa96e6198b938a76bfc4555afa3c7ba77f42e1"

URI_x86_64_v2_nbdkit-example-plugins = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nbdkit-example-plugins-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-example-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-example-plugins}"
SRC_URI[x86_64_v2_nbdkit-example-plugins.sha256sum] = "1b26db98f43f80ebe7a24ae527d9622dff913ea3b22109891739c87e304b447e"

URI_x86_64_v2_nbdkit-linuxdisk-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-linuxdisk-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-linuxdisk-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-linuxdisk-plugin}"
SRC_URI[x86_64_v2_nbdkit-linuxdisk-plugin.sha256sum] = "5139766a03e42eef10657666eb7871195f4279e581130b66dded8864fc9ed747"

URI_x86_64_v2_nbdkit-nbd-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-nbd-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-nbd-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-nbd-plugin}"
SRC_URI[x86_64_v2_nbdkit-nbd-plugin.sha256sum] = "c1012f5103e2d6827a8149aecca0799fff3bccc001d121506639d68b30092f3c"

URI_x86_64_v2_nbdkit-python-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-python-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-python-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-python-plugin}"
SRC_URI[x86_64_v2_nbdkit-python-plugin.sha256sum] = "ee73c8cb8bbd0a011d5f0ce0689947179f1968e3068103d7c41a22f0357eec9b"

URI_x86_64_v2_nbdkit-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-selinux-1.40.4-4.el10_0.noarch.rpm;name=x86_64_v2_nbdkit-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-selinux}"
SRC_URI[x86_64_v2_nbdkit-selinux.sha256sum] = "191bf14ad202fe97804ce5eadea20fb4ffc7b139d5b9def0afd1cdbc2a4d302b"

URI_x86_64_v2_nbdkit-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-server-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-server}"
SRC_URI[x86_64_v2_nbdkit-server.sha256sum] = "0ec5cb1abf0ebbc772f0522508f47ae9f8554c973e05bccd73d2c0757e02dbf6"

URI_x86_64_v2_nbdkit-srpm-macros = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nbdkit-srpm-macros-1.40.4-4.el10_0.noarch.rpm;name=x86_64_v2_nbdkit-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-srpm-macros}"
SRC_URI[x86_64_v2_nbdkit-srpm-macros.sha256sum] = "2c569b88f522821633bc5d6d6addf53242e9b0db0bd98b93ad33282b4ebddb00"

URI_x86_64_v2_nbdkit-ssh-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-ssh-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-ssh-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-ssh-plugin}"
SRC_URI[x86_64_v2_nbdkit-ssh-plugin.sha256sum] = "86e599de82f912a2f99222d683ae28f072f761dfdc33b0d092d28dfa1b892e35"

URI_x86_64_v2_nbdkit-tar-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-tar-filter-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-tar-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-tar-filter}"
SRC_URI[x86_64_v2_nbdkit-tar-filter.sha256sum] = "d3ecbb62335ec3dc9d4ae870b39c9f2ecf7cd708f3ddcebb2e9be5df986bd551"

URI_x86_64_v2_nbdkit-tmpdisk-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-tmpdisk-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-tmpdisk-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-tmpdisk-plugin}"
SRC_URI[x86_64_v2_nbdkit-tmpdisk-plugin.sha256sum] = "fd9b429ad43f238c570a60a615a840bc4bce00604ee8a36ed362ab20d13e04f5"

URI_x86_64_v2_nbdkit-vddk-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-vddk-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-vddk-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-vddk-plugin}"
SRC_URI[x86_64_v2_nbdkit-vddk-plugin.sha256sum] = "f8d801a95053dab5009320df9227b1ad82af323c3ded8dabc5a0e8799aba5674"

URI_x86_64_v2_nbdkit-xz-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-xz-filter-1.40.4-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nbdkit-xz-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-xz-filter}"
SRC_URI[x86_64_v2_nbdkit-xz-filter.sha256sum] = "c16e950917c128ff10256bbb6c5f5c447a9a36f1c60739d0d91cd679d9b87bef"

URI_aarch64_nbdkit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit}"
SRC_URI[aarch64_nbdkit.sha256sum] = "6a9dd81a274431740272078bfcd2711c83be012ed8131200c3b8b14c464fde6c"

URI_aarch64_nbdkit-bash-completion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-bash-completion-1.40.4-4.el10_0.noarch.rpm;name=aarch64_nbdkit-bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-bash-completion}"
SRC_URI[aarch64_nbdkit-bash-completion.sha256sum] = "cfa6a5e80fc664ae79b09e61b6047a9d7559d8e89efd56cef6a02a23abec498c"

URI_aarch64_nbdkit-basic-filters = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-basic-filters-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit-basic-filters;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-basic-filters}"
SRC_URI[aarch64_nbdkit-basic-filters.sha256sum] = "3a2e1c0ce115eeb8d544a0fda1a98f72cf731531ab5db9130be704bd773ed3a7"

URI_aarch64_nbdkit-basic-plugins = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-basic-plugins-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit-basic-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-basic-plugins}"
SRC_URI[aarch64_nbdkit-basic-plugins.sha256sum] = "a76809eb6ecdce1654175d0eb2fd3528aaaf2f9863a404e8e2a43bda7d6d267d"

URI_aarch64_nbdkit-curl-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-curl-plugin-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit-curl-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-curl-plugin}"
SRC_URI[aarch64_nbdkit-curl-plugin.sha256sum] = "ca45641ecdc0229919e3429765b43b45abf274b2ddfc6d95acafa641881f0668"

URI_aarch64_nbdkit-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nbdkit-devel-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-devel}"
SRC_URI[aarch64_nbdkit-devel.sha256sum] = "103993f97f629f456b06828dbdf0ba94c233ad756eed77630ce596e22de2bf80"

URI_aarch64_nbdkit-example-plugins = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nbdkit-example-plugins-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit-example-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-example-plugins}"
SRC_URI[aarch64_nbdkit-example-plugins.sha256sum] = "b56faef569ad3620a29c956885d8fb9a60b190a8a52860a5e04cfe5fa5283eb5"

URI_aarch64_nbdkit-linuxdisk-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-linuxdisk-plugin-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit-linuxdisk-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-linuxdisk-plugin}"
SRC_URI[aarch64_nbdkit-linuxdisk-plugin.sha256sum] = "f8cb5f5dada46c9aa5488d286fe85cb1a1af6ae57ec13ed9f58b7e90be51e9bb"

URI_aarch64_nbdkit-nbd-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-nbd-plugin-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit-nbd-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-nbd-plugin}"
SRC_URI[aarch64_nbdkit-nbd-plugin.sha256sum] = "ca3bda470b54783ef02436379683ce78eaa902af8e8326ca8babcd31285d6279"

URI_aarch64_nbdkit-python-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-python-plugin-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit-python-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-python-plugin}"
SRC_URI[aarch64_nbdkit-python-plugin.sha256sum] = "ca18b2a71bdd5e5fccb5e15773c75302782c9f9fad03ad9666cba246b3d98ca1"

URI_aarch64_nbdkit-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-selinux-1.40.4-4.el10_0.noarch.rpm;name=aarch64_nbdkit-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-selinux}"
SRC_URI[aarch64_nbdkit-selinux.sha256sum] = "191bf14ad202fe97804ce5eadea20fb4ffc7b139d5b9def0afd1cdbc2a4d302b"

URI_aarch64_nbdkit-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-server-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-server}"
SRC_URI[aarch64_nbdkit-server.sha256sum] = "6b5baa3065d9c14d30caf01aa4171dd85b4146e3268d17664b72d72252143313"

URI_aarch64_nbdkit-srpm-macros = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nbdkit-srpm-macros-1.40.4-4.el10_0.noarch.rpm;name=aarch64_nbdkit-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-srpm-macros}"
SRC_URI[aarch64_nbdkit-srpm-macros.sha256sum] = "2c569b88f522821633bc5d6d6addf53242e9b0db0bd98b93ad33282b4ebddb00"

URI_aarch64_nbdkit-ssh-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-ssh-plugin-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit-ssh-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-ssh-plugin}"
SRC_URI[aarch64_nbdkit-ssh-plugin.sha256sum] = "cdb20e1cd0c86d456e403077736c17f162e15478085b883981057ebfdedb9468"

URI_aarch64_nbdkit-tar-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-tar-filter-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit-tar-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-tar-filter}"
SRC_URI[aarch64_nbdkit-tar-filter.sha256sum] = "7b12124e7eff58e06ea1e39d67153bf904eeadf8581ee2bc21fd93c20f81f9f4"

URI_aarch64_nbdkit-tmpdisk-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-tmpdisk-plugin-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit-tmpdisk-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-tmpdisk-plugin}"
SRC_URI[aarch64_nbdkit-tmpdisk-plugin.sha256sum] = "e1c8d73f04b2a21435436bde5a21a52f2e41d163e53aa9b3c48b83a7b42618b0"

URI_aarch64_nbdkit-xz-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-xz-filter-1.40.4-4.el10_0.aarch64.rpm;name=aarch64_nbdkit-xz-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-xz-filter}"
SRC_URI[aarch64_nbdkit-xz-filter.sha256sum] = "71f9578822741611239dcec262a83bd28ddbecdd82c62d86a36398299cb34525"

RDEPENDS:nbdkit = " \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-selinux \
 nbdkit-server \
 "
RDEPENDS:nbdkit-bash-completion = " \
 bash-completion \
 nbdkit-server \
 "
RDEPENDS:nbdkit-basic-filters = " \
 glibc \
 gnutls \
 libgcc \
 nbdkit-server \
 zlib-ng-compat \
 "
RDEPENDS:nbdkit-basic-plugins = " \
 glibc \
 gnutls \
 libgcc \
 libzstd \
 nbdkit-server \
 "
RDEPENDS:nbdkit-curl-plugin = " \
 glibc \
 libgcc \
 nbdkit-server \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:nbdkit-devel = " \
 nbdkit-server \
 pkgconf-pkg-config \
 "
RDEPENDS:nbdkit-example-plugins = " \
 glibc \
 nbdkit-server \
 "
RDEPENDS:nbdkit-linuxdisk-plugin = " \
 e2fsprogs \
 glibc \
 libgcc \
 nbdkit-server \
 "
RDEPENDS:nbdkit-nbd-plugin = " \
 glibc \
 libgcc \
 libnbd \
 nbdkit-server \
 "
RDEPENDS:nbdkit-python-plugin = " \
 glibc \
 libgcc \
 nbdkit-server \
 python3-libs \
 "
RDEPENDS:nbdkit-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:nbdkit-server = " \
 glibc \
 gnutls \
 libgcc \
 libselinux \
 "
RDEPENDS:nbdkit-srpm-macros = " \
 bash \
 "
RDEPENDS:nbdkit-ssh-plugin = " \
 glibc \
 libgcc \
 libssh \
 nbdkit-server \
 "
RDEPENDS:nbdkit-tar-filter = " \
 glibc \
 libgcc \
 nbdkit-server \
 tar \
 "
RDEPENDS:nbdkit-tmpdisk-plugin = " \
 e2fsprogs \
 glibc \
 libgcc \
 nbdkit-server \
 util-linux \
 "
RDEPENDS:nbdkit-vddk-plugin = " \
 glibc \
 libgcc \
 libxcrypt-compat \
 nbdkit-server \
 "
RDEPENDS:nbdkit-xz-filter = " \
 glibc \
 libgcc \
 nbdkit-server \
 xz-libs \
 "
