# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-terminal-colorsaurus"
PV = "1.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-terminal-colorsaurus+anstyle-devel \
 rust-terminal-colorsaurus+default-devel \
 rust-terminal-colorsaurus+rgb-devel \
 rust-terminal-colorsaurus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-terminal-colorsaurus-1.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0293dbf5c3ba314f7699cfab1fd668ec45f6637345f4ffafe1fbae1122422a3b"

URI_x86_64_v2_rust-terminal-colorsaurus+anstyle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal-colorsaurus+anstyle-devel-1.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal-colorsaurus+anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal-colorsaurus+anstyle-devel}"
SRC_URI[x86_64_v2_rust-terminal-colorsaurus+anstyle-devel.sha256sum] = "75b709aa66dafa240970ac528da83169580012a137a5eda383ee372e2249d693"

URI_x86_64_v2_rust-terminal-colorsaurus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal-colorsaurus+default-devel-1.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal-colorsaurus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal-colorsaurus+default-devel}"
SRC_URI[x86_64_v2_rust-terminal-colorsaurus+default-devel.sha256sum] = "a791bfecca1f84a532b2076848b40f102daeb30ea07b14ec44d35962e2b1a392"

URI_x86_64_v2_rust-terminal-colorsaurus+rgb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal-colorsaurus+rgb-devel-1.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal-colorsaurus+rgb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal-colorsaurus+rgb-devel}"
SRC_URI[x86_64_v2_rust-terminal-colorsaurus+rgb-devel.sha256sum] = "7be9dc86286e0b0f19158a520cfccb3ae47e76e4b6dcacebbe87f4e56e2f028f"

URI_x86_64_v2_rust-terminal-colorsaurus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal-colorsaurus-devel-1.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal-colorsaurus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal-colorsaurus-devel}"
SRC_URI[x86_64_v2_rust-terminal-colorsaurus-devel.sha256sum] = "b8bbb4321a865c422cf909d6264e994ee3fe2f36135d23d0319438dffc702bcb"

URI_aarch64_rust-terminal-colorsaurus+anstyle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal-colorsaurus+anstyle-devel-1.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-terminal-colorsaurus+anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal-colorsaurus+anstyle-devel}"
SRC_URI[aarch64_rust-terminal-colorsaurus+anstyle-devel.sha256sum] = "316b1efd0a15c37cafbda1e849f8f235b4b70cda0fd68a0f4f34d10678eb4c18"

URI_aarch64_rust-terminal-colorsaurus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal-colorsaurus+default-devel-1.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-terminal-colorsaurus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal-colorsaurus+default-devel}"
SRC_URI[aarch64_rust-terminal-colorsaurus+default-devel.sha256sum] = "a7a67426ccb81a947d54886bbc85bb190c5ff4930a48600db1fb126fbd5d0ee4"

URI_aarch64_rust-terminal-colorsaurus+rgb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal-colorsaurus+rgb-devel-1.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-terminal-colorsaurus+rgb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal-colorsaurus+rgb-devel}"
SRC_URI[aarch64_rust-terminal-colorsaurus+rgb-devel.sha256sum] = "da05abcda8835dc29e8b81b38e65e5f435b1365e605da93e5f7dd6c7edfbaf0f"

URI_aarch64_rust-terminal-colorsaurus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal-colorsaurus-devel-1.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-terminal-colorsaurus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal-colorsaurus-devel}"
SRC_URI[aarch64_rust-terminal-colorsaurus-devel.sha256sum] = "2a107e9ae298a88268ec5c70238c225c42d368a30ea50d44992e2ec05b51a7d0"

RDEPENDS:rust-terminal-colorsaurus+anstyle-devel = " \
 cargo \
 rust-anstyle+default-devel \
 rust-terminal-colorsaurus-devel \
 "
RDEPENDS:rust-terminal-colorsaurus+default-devel = " \
 cargo \
 rust-terminal-colorsaurus-devel \
 "
RDEPENDS:rust-terminal-colorsaurus+rgb-devel = " \
 cargo \
 rust-rgb+default-devel \
 rust-terminal-colorsaurus-devel \
 "
RDEPENDS:rust-terminal-colorsaurus-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-memchr+default-devel \
 rust-mio+os-ext-devel \
 rust-mio-devel \
 rust-terminal-trx+default-devel \
 rust-xterm-color+default-devel \
 "
