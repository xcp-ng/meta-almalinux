# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest_derive"
PV = "2.8.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-pest_derive+default-devel \
 rust-pest_derive+grammar-extras-devel \
 rust-pest_derive+std-devel \
 rust-pest_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest_derive-2.8.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ecb592cf076204853628144273754120913dcf839a0e5f76c57a30304f4cfb2"

URI_x86_64_v2_rust-pest_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive+default-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive+default-devel}"
SRC_URI[x86_64_v2_rust-pest_derive+default-devel.sha256sum] = "fd2e73a2e7a72309ead578d9075cf6542d20b1c98c1934092fc9cf54620d1c5d"

URI_x86_64_v2_rust-pest_derive+grammar-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive+grammar-extras-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive+grammar-extras-devel}"
SRC_URI[x86_64_v2_rust-pest_derive+grammar-extras-devel.sha256sum] = "d11701e699f90d9b3445a83d4b578fec6f8b2ff4d893528a2fa7aca5cd02258d"

URI_x86_64_v2_rust-pest_derive+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive+std-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive+std-devel}"
SRC_URI[x86_64_v2_rust-pest_derive+std-devel.sha256sum] = "02971a5d860ddbb01866d3ee150347eb8b64ad1555bc91d8018d281804654fa6"

URI_x86_64_v2_rust-pest_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive-devel}"
SRC_URI[x86_64_v2_rust-pest_derive-devel.sha256sum] = "1b4348cb1cd1fe9637a2344cfe2fe844477f96da6681b5dd0edc75eef21781aa"

URI_aarch64_rust-pest_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive+default-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive+default-devel}"
SRC_URI[aarch64_rust-pest_derive+default-devel.sha256sum] = "137b1a740bf47acf4a71f83b25af3541c34fd8251642ef00c08bc37c41607692"

URI_aarch64_rust-pest_derive+grammar-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive+grammar-extras-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest_derive+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive+grammar-extras-devel}"
SRC_URI[aarch64_rust-pest_derive+grammar-extras-devel.sha256sum] = "dabdd7cb610f8382bf71b57843f084f27bad91e07ffb77ad6bb32da3e3dec652"

URI_aarch64_rust-pest_derive+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive+std-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest_derive+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive+std-devel}"
SRC_URI[aarch64_rust-pest_derive+std-devel.sha256sum] = "1eb4f9cc9836a12532f9c60102cf667ded21b60a3cd21b6116712d86de7de27b"

URI_aarch64_rust-pest_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive-devel}"
SRC_URI[aarch64_rust-pest_derive-devel.sha256sum] = "b1180b2f221169d67bc02ed53621df9fad65b90f306ebc4696b51ccfcb37f3e6"

RDEPENDS:rust-pest_derive+default-devel = " \
 cargo \
 rust-pest_derive+std-devel \
 rust-pest_derive-devel \
 "
RDEPENDS:rust-pest_derive+grammar-extras-devel = " \
 cargo \
 rust-pest_derive-devel \
 rust-pest_generator+grammar-extras-devel \
 "
RDEPENDS:rust-pest_derive+std-devel = " \
 cargo \
 rust-pest+std-devel \
 rust-pest_derive-devel \
 rust-pest_generator+std-devel \
 "
RDEPENDS:rust-pest_derive-devel = " \
 cargo \
 rust \
 rust-pest-devel \
 rust-pest_generator-devel \
 "
