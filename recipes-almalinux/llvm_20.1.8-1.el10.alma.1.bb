# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm"
PV = "20.1.8"
PR = "1.el10.alma.1"
PACKAGES = " \
 clang \
 clang-analyzer \
 clang-devel \
 clang-libs \
 clang-resource-filesystem \
 clang-tools-extra \
 compiler-rt \
 git-clang-format \
 libomp \
 libomp-devel \
 lld \
 lld-devel \
 lld-libs \
 lldb \
 lldb-devel \
 llvm \
 llvm-devel \
 llvm-doc \
 llvm-filesystem \
 llvm-googletest \
 llvm-libs \
 llvm-static \
 llvm-test \
 llvm-toolset \
 python3-clang \
 python3-lit \
 python3-lldb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/llvm-20.1.8-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8abdec18c0b0b5b1c84f8650a161c861bd3e37914d02a5e77139a50c6d8e1f68"

URI_x86_64_v2_clang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang}"
SRC_URI[x86_64_v2_clang.sha256sum] = "9e7ee9bbae27935cbf402dc2d72b5ca94d91aa1c44e26f6f5513a4ea4a95050b"

URI_x86_64_v2_clang-analyzer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-analyzer-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-analyzer}"
SRC_URI[x86_64_v2_clang-analyzer.sha256sum] = "8a4a7e880c4dc88878ec42847b8b30724c42cf2fc950828363656dc01acab368"

URI_x86_64_v2_clang-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-devel-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-devel}"
SRC_URI[x86_64_v2_clang-devel.sha256sum] = "9dcb3fe219bed36b6d3f7dd6e8f78cc20ff28586d26406f63d3baf2df3388eb6"

URI_x86_64_v2_clang-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-libs-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-libs}"
SRC_URI[x86_64_v2_clang-libs.sha256sum] = "ea76f3456240b0e2f244beb785b1987b82a47cbed61f53364991ee06a9235e2a"

URI_x86_64_v2_clang-resource-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-resource-filesystem-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-resource-filesystem}"
SRC_URI[x86_64_v2_clang-resource-filesystem.sha256sum] = "50b1c9f32f43f291fe02748a5c7487e30312132071df8c696598c90077887186"

URI_x86_64_v2_clang-tools-extra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-tools-extra-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-tools-extra}"
SRC_URI[x86_64_v2_clang-tools-extra.sha256sum] = "53d17ecdc8920f3835e3460fa0d10421d8ec890762808120861bc20095e9429c"

URI_x86_64_v2_compiler-rt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/compiler-rt-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_compiler-rt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compiler-rt}"
SRC_URI[x86_64_v2_compiler-rt.sha256sum] = "8ec2095886a11b57ba0fbc266cf929bf56a5b987440b40803cb96c62871cf4a2"

URI_x86_64_v2_git-clang-format = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-clang-format-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_git-clang-format;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-clang-format}"
SRC_URI[x86_64_v2_git-clang-format.sha256sum] = "1fc9d1b2b1f0d92b288eec4e67506078bed3c89d8a4720a82dd09405d4ade715"

URI_x86_64_v2_libomp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libomp-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libomp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp}"
SRC_URI[x86_64_v2_libomp.sha256sum] = "99b7dea454294ba7f3953bc930b8f88aac3497038add800984aaa4fd556f28d0"
RPROVIDES:libomp:append:x86_64_v2 = " virtual/libomp.so_VERSION__64bit_ virtual/libomp.so___64bit_"

URI_x86_64_v2_libomp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libomp-devel-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp-devel}"
SRC_URI[x86_64_v2_libomp-devel.sha256sum] = "29adca88e47bb01adebe4c4f846ef5a6aad52566ddda4425507b2c553466f911"

URI_x86_64_v2_lld = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld}"
SRC_URI[x86_64_v2_lld.sha256sum] = "f41d4261776c65e4015b7314c3fd5487e1eff4ab24a9881fb6836edcb8965f00"

URI_x86_64_v2_lld-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-devel-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld-devel}"
SRC_URI[x86_64_v2_lld-devel.sha256sum] = "4b521ff373fdc139a17fb283b4df40e0e1f80581353bff3da035ebd198a6a2d9"

URI_x86_64_v2_lld-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-libs-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld-libs}"
SRC_URI[x86_64_v2_lld-libs.sha256sum] = "c1d48fc9ed5d8a76a85131d1ca7688d07c524bff104b2060c31dfb3ac3a0d409"

URI_x86_64_v2_lldb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lldb-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb}"
SRC_URI[x86_64_v2_lldb.sha256sum] = "90592fe964dcdabac93248e2e871b9ac92c367bdb12628d4fe815ff21010b9a2"

URI_x86_64_v2_lldb-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lldb-devel-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lldb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb-devel}"
SRC_URI[x86_64_v2_lldb-devel.sha256sum] = "12733447cbce1647e6e137c48e604fa68a1dd12f07701296016805b52d3ae423"

URI_x86_64_v2_llvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm}"
SRC_URI[x86_64_v2_llvm.sha256sum] = "28b77c72c9978891cdc1f22b7ddd27fa560fe8fc90c6e6ae293381b29f2708d9"

URI_x86_64_v2_llvm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-devel-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-devel}"
SRC_URI[x86_64_v2_llvm-devel.sha256sum] = "f72c0c43cecf287dbcaecf8a11ec1cb3f122820912aedd324dc2f7956459926b"

URI_x86_64_v2_llvm-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-doc-20.1.8-1.el10.alma.1.noarch.rpm;name=x86_64_v2_llvm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-doc}"
SRC_URI[x86_64_v2_llvm-doc.sha256sum] = "7df2d626390cae2508b0d0e012114a723dbe3b23b656892a8ada9341c7b95770"

URI_x86_64_v2_llvm-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-filesystem-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-filesystem}"
SRC_URI[x86_64_v2_llvm-filesystem.sha256sum] = "c314516627d2235eed416132890dcb856f8f043e8a0740c4e4493641a04ffa52"

URI_x86_64_v2_llvm-googletest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-googletest-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-googletest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-googletest}"
SRC_URI[x86_64_v2_llvm-googletest.sha256sum] = "27f966cf0f4189a4505b4802f414ab2672c0434d0c98914373b2bea195e883aa"

URI_x86_64_v2_llvm-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-libs-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-libs}"
SRC_URI[x86_64_v2_llvm-libs.sha256sum] = "0f7365c6ff5ac2a125d58447c53b12d17d33625ad3046e5972007f841df36e0d"

URI_x86_64_v2_llvm-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-static-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-static}"
SRC_URI[x86_64_v2_llvm-static.sha256sum] = "0e3ba8d722f6c17b80e2547110ddda6a7e96b8191d49c7536b69ad3107690172"

URI_x86_64_v2_llvm-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-test-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-test}"
SRC_URI[x86_64_v2_llvm-test.sha256sum] = "a906aa4ef54891324321490496658fb3135d1dfaf57338b7e4c4f0825775647f"

URI_x86_64_v2_llvm-toolset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-toolset-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-toolset}"
SRC_URI[x86_64_v2_llvm-toolset.sha256sum] = "7e76a72ebf49f31936aef501499cd2a63c12c09f775c3b3283c6b40f04ef3293"

URI_x86_64_v2_python3-clang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-clang-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-clang}"
SRC_URI[x86_64_v2_python3-clang.sha256sum] = "78a5a9fb497b4d44266984a06ae869ce8797445f2a992afdc473a30c7d8c6aed"

URI_x86_64_v2_python3-lit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lit-20.1.8-1.el10.alma.1.noarch.rpm;name=x86_64_v2_python3-lit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lit}"
SRC_URI[x86_64_v2_python3-lit.sha256sum] = "ed6ff47ae815842b80c30cb3a10e14eac4c77dade80b5be6cefd44343cd17041"

URI_x86_64_v2_python3-lldb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lldb-20.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-lldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lldb}"
SRC_URI[x86_64_v2_python3-lldb.sha256sum] = "9c3135070537e2491403b6cac035689d8526cac89f78214b0308dd6339f8542f"

URI_aarch64_clang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang}"
SRC_URI[aarch64_clang.sha256sum] = "a5c3501408688d3edee3b360a95ca91682090100710567669bb7b1dab8f3d699"

URI_aarch64_clang-analyzer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-analyzer-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-analyzer}"
SRC_URI[aarch64_clang-analyzer.sha256sum] = "b4ffe1dbf46de946cc8f089f3f01e05a9744487df2beb7f3e978f3feb63eec03"

URI_aarch64_clang-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-devel-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-devel}"
SRC_URI[aarch64_clang-devel.sha256sum] = "aadbdc1c241212c1b23f6fd5851d6206667d5ed2d991cf2695305c65df67a4ba"

URI_aarch64_clang-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-libs-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-libs}"
SRC_URI[aarch64_clang-libs.sha256sum] = "ceaf0399428dab49b417fd7ee7eaeed6eb239841a5762f73030f1fa5bea97843"

URI_aarch64_clang-resource-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-resource-filesystem-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-resource-filesystem}"
SRC_URI[aarch64_clang-resource-filesystem.sha256sum] = "a30dabb4267b0f5a812c45022a8d1dedda188c2d331f305f2320634899ebe344"

URI_aarch64_clang-tools-extra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-tools-extra-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-tools-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-tools-extra}"
SRC_URI[aarch64_clang-tools-extra.sha256sum] = "50b82d87fa6560c4572826fcafa3d0a2b781ab69690707bb2023b66457c54c92"

URI_aarch64_compiler-rt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/compiler-rt-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_compiler-rt;unpack=0"
SRC_URI:append = " ${URI_aarch64_compiler-rt}"
SRC_URI[aarch64_compiler-rt.sha256sum] = "2076abe1e98d80bcb4a03ea4c56465deba59f03d8c9151cdec9283978bd604f2"

URI_aarch64_git-clang-format = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-clang-format-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_git-clang-format;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-clang-format}"
SRC_URI[aarch64_git-clang-format.sha256sum] = "9e617ccd65a241c07f8af228ecdb74314e35f40e7945d1469008e6c91ca42d20"

URI_aarch64_libomp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libomp-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_libomp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp}"
SRC_URI[aarch64_libomp.sha256sum] = "66d00735a94786c96f2fb310d1b7af0e64de3384fe27576b31d6acec6b192597"

URI_aarch64_libomp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libomp-devel-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_libomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp-devel}"
SRC_URI[aarch64_libomp-devel.sha256sum] = "3c6eba8721d41e5a901a60c39f9861e4067bbd8584ebd6174b1c31e7857e033e"

URI_aarch64_lld = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lld;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld}"
SRC_URI[aarch64_lld.sha256sum] = "4f29d68e1a1b93e8ac7e2c2f3e521b5d200b0d18f598dba9935e119cece1aeb9"

URI_aarch64_lld-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-devel-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lld-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld-devel}"
SRC_URI[aarch64_lld-devel.sha256sum] = "fc42df086f28c42d88be03e603d5e2e1aae8292adba28dc8e96e41513bf2b654"

URI_aarch64_lld-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-libs-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lld-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld-libs}"
SRC_URI[aarch64_lld-libs.sha256sum] = "c62cc2a2afdc1cd5719a87a72549c2ae301462df5e683ff2421f9a3e398b2631"

URI_aarch64_lldb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lldb-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb}"
SRC_URI[aarch64_lldb.sha256sum] = "60c1d1134a2e6842915820aa87891dc1f93693873e31caaa2564019fa8c28fa3"

URI_aarch64_lldb-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lldb-devel-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lldb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb-devel}"
SRC_URI[aarch64_lldb-devel.sha256sum] = "518ba4ad6887437c4ec7c1336bab8d0ed8f5af5f4d931125b8bb2f08a41e57ac"

URI_aarch64_llvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm}"
SRC_URI[aarch64_llvm.sha256sum] = "be9a4a105ba590f42801bae061d07108075f331c4a495b31434251b55919c8ca"

URI_aarch64_llvm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-devel-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-devel}"
SRC_URI[aarch64_llvm-devel.sha256sum] = "aaa476ef56c266a82fa5cea965ed2d6a6a961746356568b12a12061d15f9aba3"

URI_aarch64_llvm-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-doc-20.1.8-1.el10.alma.1.noarch.rpm;name=aarch64_llvm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-doc}"
SRC_URI[aarch64_llvm-doc.sha256sum] = "7df2d626390cae2508b0d0e012114a723dbe3b23b656892a8ada9341c7b95770"

URI_aarch64_llvm-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-filesystem-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-filesystem}"
SRC_URI[aarch64_llvm-filesystem.sha256sum] = "19939e733eb3442d500e456a126f9bbb77e87057507f418122d84386fd738ab5"

URI_aarch64_llvm-googletest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-googletest-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-googletest;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-googletest}"
SRC_URI[aarch64_llvm-googletest.sha256sum] = "3058cc018650642b6491dea6e625c651bc32cc1707a6f1f5aef557d826b33fe9"

URI_aarch64_llvm-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-libs-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-libs}"
SRC_URI[aarch64_llvm-libs.sha256sum] = "794dc0ade042f122064f3046155af1fe0000b7eda71a50190f7f4b41ee4afc3f"

URI_aarch64_llvm-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-static-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-static}"
SRC_URI[aarch64_llvm-static.sha256sum] = "912c693cd61cebc6363c89bbb6b06ca55aeb511683f7794f053715b50b15f426"

URI_aarch64_llvm-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-test-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-test}"
SRC_URI[aarch64_llvm-test.sha256sum] = "0971dfc80220d956b1adac40749815478c2d069091db94b861b2c0e1932a89d1"

URI_aarch64_llvm-toolset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-toolset-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-toolset}"
SRC_URI[aarch64_llvm-toolset.sha256sum] = "47730ea93cfd0d3f925e3b2227db418e21d5c2f19dd08b95c40deb1d86e1713f"

URI_aarch64_python3-clang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-clang-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-clang}"
SRC_URI[aarch64_python3-clang.sha256sum] = "fb7a636f025832fbaae00f45a35c6817794a52e34eacf69c81570b58371b94df"

URI_aarch64_python3-lit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lit-20.1.8-1.el10.alma.1.noarch.rpm;name=aarch64_python3-lit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lit}"
SRC_URI[aarch64_python3-lit.sha256sum] = "ed6ff47ae815842b80c30cb3a10e14eac4c77dade80b5be6cefd44343cd17041"

URI_aarch64_python3-lldb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lldb-20.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-lldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lldb}"
SRC_URI[aarch64_python3-lldb.sha256sum] = "0c08172a92bb3cbe4d884cddbcb8c0c99ef823b510815169e9c6caeb9a0cb21f"

RDEPENDS:clang = " \
 clang-libs \
 gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 libstdc++-devel \
 llvm-libs \
 "
RDEPENDS:clang-analyzer = " \
 clang \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Hash-Util \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3 \
 "
RDEPENDS:clang-devel = " \
 clang \
 clang-libs \
 clang-tools-extra \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 llvm-devel \
 "
RDEPENDS:clang-libs = " \
 clang-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:clang-resource-filesystem = " \
 "
RDEPENDS:clang-tools-extra = " \
 clang-libs \
 emacs-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm-libs \
 python3 \
 "
RDEPENDS:compiler-rt = " \
 clang-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:git-clang-format = " \
 clang-tools-extra \
 git \
 python3 \
 "
RDEPENDS:libomp = " \
 elfutils-libelf \
 glibc \
 libffi \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:libomp-devel = " \
 clang-resource-filesystem \
 libomp \
 "
RDEPENDS:lld = " \
 alternatives \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 lld-libs \
 llvm-libs \
 "
RDEPENDS:lld-devel = " \
 cmake-filesystem \
 lld \
 lld-libs \
 "
RDEPENDS:lld-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb = " \
 clang-libs \
 glibc \
 libedit \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm-libs \
 ncurses-libs \
 python3-libs \
 python3-lldb \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb-devel = " \
 lldb \
 "
RDEPENDS:llvm = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 python3 \
 zlib-ng-compat \
 "
RDEPENDS:llvm-devel = " \
 alternatives \
 bash \
 cmake-filesystem \
 glibc \
 libedit-devel \
 libgcc \
 libstdc++ \
 libzstd-devel \
 llvm \
 llvm-googletest \
 llvm-libs \
 llvm-static \
 llvm-test \
 "
RDEPENDS:llvm-doc = " \
 llvm \
 "
RDEPENDS:llvm-filesystem = " \
 "
RDEPENDS:llvm-googletest = " \
 llvm-filesystem \
 "
RDEPENDS:llvm-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 libxml2 \
 libzstd \
 llvm-filesystem \
 zlib-ng-compat \
 "
RDEPENDS:llvm-static = " \
 llvm-filesystem \
 "
RDEPENDS:llvm-test = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm \
 llvm-libs \
 "
RDEPENDS:llvm-toolset = " \
 clang \
 lld \
 llvm \
 "
RDEPENDS:python3-clang = " \
 clang-devel \
 python3 \
 "
RDEPENDS:python3-lit = " \
 python3 \
 "
RDEPENDS:python3-lldb = " \
 lldb \
 python3 \
 "
