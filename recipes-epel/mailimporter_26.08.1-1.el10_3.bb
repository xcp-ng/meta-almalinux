# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mailimporter"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 mailimporter \
 mailimporter-akonadi \
 mailimporter-devel \
 mailimporter-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/mailimporter-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c036aab20ce0f6562ab1a5db25c1b8d82b6205fad8153b7ba7ef92c83b04fa6c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter;unpack=0"
SRC_URI[x86_64_v2_mailimporter.sha256sum] = "78c2436d86eff247574fcd20a035bc4a3353f4031423f080b8791c5c90ae999a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-akonadi-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter-akonadi;unpack=0"
SRC_URI[x86_64_v2_mailimporter-akonadi.sha256sum] = "db7ce8ecdaedda56a06eaadcc12606a5228f6026520717dd725f874cb0434367"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter-devel;unpack=0"
SRC_URI[x86_64_v2_mailimporter-devel.sha256sum] = "2df8e46653a51a0dd25ea3f96e2af3ed964c2c3d550e6642236ace9c0fb48672"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mailimporter-doc;unpack=0"
SRC_URI[x86_64_v2_mailimporter-doc.sha256sum] = "395e0e5a18c46c7164384c462034fe570c3d895371a76984d284a0f6b266debc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_mailimporter;unpack=0"
SRC_URI[aarch64_mailimporter.sha256sum] = "58c94cbb9be46824abda330558cf3d03e14bb13b631a18d7e0d706215d08a6dd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-akonadi-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_mailimporter-akonadi;unpack=0"
SRC_URI[aarch64_mailimporter-akonadi.sha256sum] = "3fd147272869b8957de1bcf438d2b0b7d49490dd7b983ec65e8d5e20cc8a8ee8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_mailimporter-devel;unpack=0"
SRC_URI[aarch64_mailimporter-devel.sha256sum] = "20f76d5531b2547ca0c33d185888ac95a50066359221b585ff009ae4b5accf33"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_mailimporter-doc;unpack=0"
SRC_URI[aarch64_mailimporter-doc.sha256sum] = "5843e7004de60cde4688ef53e468cff3754118f6fdbae5a4cd2cc54c05363dcc"

RDEPENDS:mailimporter = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-ki18n \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:mailimporter-akonadi = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kmime \
 libgcc \
 libstdc++ \
 mailimporter \
 qt6-qtbase \
 "
RDEPENDS:mailimporter-devel = " \
 cmake-filesystem \
 kf6-karchive-devel \
 mailimporter \
 mailimporter-akonadi \
 "
RDEPENDS:mailimporter-doc = " \
 "
