# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grub2-breeze-theme"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 grub2-breeze-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grub2-breeze-theme-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "222ce617ecdda50fccc61d2afdd585fba50d6824ba1d46fe6e2840ca96d80847"

URI_x86_64_v2_grub2-breeze-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grub2-breeze-theme-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grub2-breeze-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-breeze-theme}"
SRC_URI[x86_64_v2_grub2-breeze-theme.sha256sum] = "a84eece1fbd770022fe7ddf5d1053dd1fb386777649d5b05862fa229ddc9e1e9"

URI_aarch64_grub2-breeze-theme = "${EPEL_MIRROR}/aarch64/Packages/g/grub2-breeze-theme-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_grub2-breeze-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-breeze-theme}"
SRC_URI[aarch64_grub2-breeze-theme.sha256sum] = "99b41d3440e54bc3337ecff781139355fd04a477a8a4063f726325d69722ab7a"

RDEPENDS:grub2-breeze-theme:x86_64_v2 = " \
 grub2-pc \
"
RDEPENDS:grub2-breeze-theme:aarch64 = " \
 grub2-efi-aa64 \
"
