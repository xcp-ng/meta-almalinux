# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jbig2dec"
PV = "0.20"
PR = "7.el10"
PACKAGES = " \
 jbig2dec-devel \
 jbig2dec-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jbig2dec-0.20-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a76867690f4e9aa1ed4111439bf54eddfc95f7b7892bf08693deca72254e46dc"

URI_x86_64_v2_jbig2dec-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jbig2dec-devel-0.20-7.el10.x86_64_v2.rpm;name=x86_64_v2_jbig2dec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jbig2dec-devel}"
SRC_URI[x86_64_v2_jbig2dec-devel.sha256sum] = "ba08bb346dce0510e31f4989c8223bb0a55b1052d834c9fd1729724fe1c71467"

URI_x86_64_v2_jbig2dec-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jbig2dec-libs-0.20-7.el10.x86_64_v2.rpm;name=x86_64_v2_jbig2dec-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jbig2dec-libs}"
SRC_URI[x86_64_v2_jbig2dec-libs.sha256sum] = "cdee49bffb7711b514de9b06f1d7c857949c0600f4c0873c3be8739505fb0258"

URI_aarch64_jbig2dec-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jbig2dec-devel-0.20-7.el10.aarch64.rpm;name=aarch64_jbig2dec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jbig2dec-devel}"
SRC_URI[aarch64_jbig2dec-devel.sha256sum] = "d70a14154d21b89164840c172ffe7646986bb7784995eb6c7a1aa6ecddb96374"

URI_aarch64_jbig2dec-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jbig2dec-libs-0.20-7.el10.aarch64.rpm;name=aarch64_jbig2dec-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_jbig2dec-libs}"
SRC_URI[aarch64_jbig2dec-libs.sha256sum] = "a2f4ae01fc4649a88cdd102c8502405d8a445ff6b2b0d6626613464564f552ef"

RDEPENDS:jbig2dec-devel = " \
 jbig2dec-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:jbig2dec-libs = " \
 glibc \
 "
