# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf-plugins-core"
PV = "4.7.0"
PR = "10.el10"
PACKAGES = " \
 dnf-plugins-core \
 python3-dnf-plugin-leaves \
 python3-dnf-plugin-modulesync \
 python3-dnf-plugin-post-transaction-actions \
 python3-dnf-plugin-pre-transaction-actions \
 python3-dnf-plugin-show-leaves \
 python3-dnf-plugin-versionlock \
 python3-dnf-plugins-core \
 yum-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dnf-plugins-core-4.7.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "459c476d200b02cef15fba7209f95d4e18d87b8e5e22b3fc6f99843e4943d529"

URI_x86_64_v2_dnf-plugins-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-plugins-core-4.7.0-10.el10.noarch.rpm;name=x86_64_v2_dnf-plugins-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-plugins-core}"
SRC_URI[x86_64_v2_dnf-plugins-core.sha256sum] = "840f84e3bfa456cfa79cb298d519fedae441274941ce241e81e4d57650709d80"

URI_x86_64_v2_python3-dnf-plugin-leaves = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dnf-plugin-leaves-4.7.0-10.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-leaves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-leaves}"
SRC_URI[x86_64_v2_python3-dnf-plugin-leaves.sha256sum] = "47bd75cd152064349af35d9a9f4126b46ebe9ed6b1a1c26a9cb72e0def5bb4cc"

URI_x86_64_v2_python3-dnf-plugin-modulesync = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dnf-plugin-modulesync-4.7.0-10.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-modulesync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-modulesync}"
SRC_URI[x86_64_v2_python3-dnf-plugin-modulesync.sha256sum] = "f70f98855928fe959f7b4d5784e205ac214acbd852c127e21eb3fd3b48966c2d"

URI_x86_64_v2_python3-dnf-plugin-post-transaction-actions = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugin-post-transaction-actions-4.7.0-10.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-post-transaction-actions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-post-transaction-actions}"
SRC_URI[x86_64_v2_python3-dnf-plugin-post-transaction-actions.sha256sum] = "5249c1760cebb46c0268f70d8ddbad8a007902b76f583b6c40f0d7a38b37029b"

URI_x86_64_v2_python3-dnf-plugin-pre-transaction-actions = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugin-pre-transaction-actions-4.7.0-10.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-pre-transaction-actions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-pre-transaction-actions}"
SRC_URI[x86_64_v2_python3-dnf-plugin-pre-transaction-actions.sha256sum] = "33a3517e7dd8ffdfa78840e10afd5ee3d1cf5c0fb7695329f21f0ff9f6d92496"

URI_x86_64_v2_python3-dnf-plugin-show-leaves = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dnf-plugin-show-leaves-4.7.0-10.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-show-leaves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-show-leaves}"
SRC_URI[x86_64_v2_python3-dnf-plugin-show-leaves.sha256sum] = "f11bc2c284462f06efada25c7244077bf3ed5d9911eeaac2a4c0b756c280c252"

URI_x86_64_v2_python3-dnf-plugin-versionlock = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugin-versionlock-4.7.0-10.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-versionlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-versionlock}"
SRC_URI[x86_64_v2_python3-dnf-plugin-versionlock.sha256sum] = "2f7d1cc362a087288f197a1ba211280f9056ee9407c852a8206e3863b10452f2"

URI_x86_64_v2_python3-dnf-plugins-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugins-core-4.7.0-10.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugins-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugins-core}"
SRC_URI[x86_64_v2_python3-dnf-plugins-core.sha256sum] = "3e9a81c73c438c444d1459eec704ff8a321d42cdade6a96d19138e9c83d901cb"

URI_x86_64_v2_yum-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/yum-utils-4.7.0-10.el10.noarch.rpm;name=x86_64_v2_yum-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yum-utils}"
SRC_URI[x86_64_v2_yum-utils.sha256sum] = "fce81447d6897a370a28786979f74c0ea0069f38e10d7f4cccca40863319152b"

URI_aarch64_dnf-plugins-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-plugins-core-4.7.0-10.el10.noarch.rpm;name=aarch64_dnf-plugins-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-plugins-core}"
SRC_URI[aarch64_dnf-plugins-core.sha256sum] = "840f84e3bfa456cfa79cb298d519fedae441274941ce241e81e4d57650709d80"

URI_aarch64_python3-dnf-plugin-leaves = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dnf-plugin-leaves-4.7.0-10.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-leaves;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-leaves}"
SRC_URI[aarch64_python3-dnf-plugin-leaves.sha256sum] = "47bd75cd152064349af35d9a9f4126b46ebe9ed6b1a1c26a9cb72e0def5bb4cc"

URI_aarch64_python3-dnf-plugin-modulesync = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dnf-plugin-modulesync-4.7.0-10.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-modulesync;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-modulesync}"
SRC_URI[aarch64_python3-dnf-plugin-modulesync.sha256sum] = "f70f98855928fe959f7b4d5784e205ac214acbd852c127e21eb3fd3b48966c2d"

URI_aarch64_python3-dnf-plugin-post-transaction-actions = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugin-post-transaction-actions-4.7.0-10.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-post-transaction-actions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-post-transaction-actions}"
SRC_URI[aarch64_python3-dnf-plugin-post-transaction-actions.sha256sum] = "5249c1760cebb46c0268f70d8ddbad8a007902b76f583b6c40f0d7a38b37029b"

URI_aarch64_python3-dnf-plugin-pre-transaction-actions = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugin-pre-transaction-actions-4.7.0-10.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-pre-transaction-actions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-pre-transaction-actions}"
SRC_URI[aarch64_python3-dnf-plugin-pre-transaction-actions.sha256sum] = "33a3517e7dd8ffdfa78840e10afd5ee3d1cf5c0fb7695329f21f0ff9f6d92496"

URI_aarch64_python3-dnf-plugin-show-leaves = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dnf-plugin-show-leaves-4.7.0-10.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-show-leaves;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-show-leaves}"
SRC_URI[aarch64_python3-dnf-plugin-show-leaves.sha256sum] = "f11bc2c284462f06efada25c7244077bf3ed5d9911eeaac2a4c0b756c280c252"

URI_aarch64_python3-dnf-plugin-versionlock = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugin-versionlock-4.7.0-10.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-versionlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-versionlock}"
SRC_URI[aarch64_python3-dnf-plugin-versionlock.sha256sum] = "2f7d1cc362a087288f197a1ba211280f9056ee9407c852a8206e3863b10452f2"

URI_aarch64_python3-dnf-plugins-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugins-core-4.7.0-10.el10.noarch.rpm;name=aarch64_python3-dnf-plugins-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugins-core}"
SRC_URI[aarch64_python3-dnf-plugins-core.sha256sum] = "3e9a81c73c438c444d1459eec704ff8a321d42cdade6a96d19138e9c83d901cb"

URI_aarch64_yum-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/yum-utils-4.7.0-10.el10.noarch.rpm;name=aarch64_yum-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_yum-utils}"
SRC_URI[aarch64_yum-utils.sha256sum] = "fce81447d6897a370a28786979f74c0ea0069f38e10d7f4cccca40863319152b"

RDEPENDS:dnf-plugins-core = " \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-leaves = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-modulesync = " \
 createrepo_c \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-post-transaction-actions = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-pre-transaction-actions = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-show-leaves = " \
 python3 \
 python3-dnf-plugin-leaves \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-versionlock = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugins-core = " \
 python3 \
 python3-dateutil \
 python3-dbus \
 python3-dnf \
 python3-hawkey \
 python3-systemd \
 "
RDEPENDS:yum-utils = " \
 dnf-plugins-core \
 python3 \
 python3-dnf \
 "
