# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "svgpart"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 svgpart \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/svgpart-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "61f46694e1c2162bead0379cd2d358dca93e921fb6754f0a12c48b1150088162"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/svgpart-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_svgpart;unpack=0"
SRC_URI[x86_64_v2_svgpart.sha256sum] = "367c95578b9a3a794f321aa603bf0ba86980836654cf71fa75d83c2f813ef218"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/svgpart-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_svgpart;unpack=0"
SRC_URI[aarch64_svgpart.sha256sum] = "c396d8b844796b5d1dbfbc6e45d8f23fcb1e9d3f72ed7ad97ac1fa560e47337b"

RDEPENDS:svgpart = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kparts \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
