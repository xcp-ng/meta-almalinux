# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "roctracer"
PV = "7.1.0"
PR = "4.el10_2"
PACKAGES:x86_64_v2 = " \
 roctracer \
 roctracer-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/roctracer-7.1.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0af7bcaaebb1952dc0736596ea7ba3287108dade3fbebc8b80a137076c66464b"

URI_x86_64_v2_roctracer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/roctracer-7.1.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_roctracer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_roctracer}"
SRC_URI[x86_64_v2_roctracer.sha256sum] = "c9dc3713e78de474727b1ff8db1f78d20e118a9497e58e3e552948c20e320e97"

URI_x86_64_v2_roctracer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/roctracer-devel-7.1.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_roctracer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_roctracer-devel}"
SRC_URI[x86_64_v2_roctracer-devel.sha256sum] = "b86546a943c8be06078ea3c75d37c274b03f61cf951397b2eac3806dfd9dea66"

RDEPENDS:roctracer = " \
 glibc \
 libatomic \
 libgcc \
 libstdc++ \
 rocm-comgr \
 rocm-runtime \
 "
RDEPENDS:roctracer-devel = " \
 roctracer \
 "
