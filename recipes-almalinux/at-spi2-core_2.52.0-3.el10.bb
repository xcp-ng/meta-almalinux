# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "at-spi2-core"
PV = "2.52.0"
PR = "3.el10"
PACKAGES = " \
 at-spi2-atk \
 at-spi2-atk-devel \
 at-spi2-core \
 at-spi2-core-devel \
 atk \
 atk-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/at-spi2-core-2.52.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ec3f442e9cb8aaa4ce0f8d394fca7f3044ad072152ff4c2ab57944486c891f8"

URI_x86_64_v2_at-spi2-atk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/at-spi2-atk-2.52.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_at-spi2-atk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_at-spi2-atk}"
SRC_URI[x86_64_v2_at-spi2-atk.sha256sum] = "ce996afbc1a1d69055d55ca288f4fa46d905a9a633b91707dbc6f6c8f354b3ce"

URI_x86_64_v2_at-spi2-atk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/at-spi2-atk-devel-2.52.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_at-spi2-atk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_at-spi2-atk-devel}"
SRC_URI[x86_64_v2_at-spi2-atk-devel.sha256sum] = "12adcee2b8ce7a90f22980a691eb4211f88a1e2087a307305235e6c87ab19aa0"

URI_x86_64_v2_at-spi2-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/at-spi2-core-2.52.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_at-spi2-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_at-spi2-core}"
SRC_URI[x86_64_v2_at-spi2-core.sha256sum] = "5119d4923238c5b082d49b91a078f71edfe27819cc311dde48c8f9ac0a3b5719"

URI_x86_64_v2_at-spi2-core-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/at-spi2-core-devel-2.52.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_at-spi2-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_at-spi2-core-devel}"
SRC_URI[x86_64_v2_at-spi2-core-devel.sha256sum] = "b1a709790ef96e29f2770a27a852294c2819527fbc07af5413aaa63cfe4f124c"

URI_x86_64_v2_atk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/atk-2.52.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_atk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atk}"
SRC_URI[x86_64_v2_atk.sha256sum] = "533d2a14b5a2d9c5a94931d2c54d9b669486cfb1cee3b772d4e48c7df845df48"

URI_x86_64_v2_atk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/atk-devel-2.52.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_atk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atk-devel}"
SRC_URI[x86_64_v2_atk-devel.sha256sum] = "9d39dcdb6dcf9bb3e92e834aad430dd3ba9d395d87bcc66fbbda77cd355ab72b"

URI_aarch64_at-spi2-atk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/at-spi2-atk-2.52.0-3.el10.aarch64.rpm;name=aarch64_at-spi2-atk;unpack=0"
SRC_URI:append = " ${URI_aarch64_at-spi2-atk}"
SRC_URI[aarch64_at-spi2-atk.sha256sum] = "e9c2a54d7b57ed5277965415625ee14671c0f97207f5a3ff5b0e3e6ff3912ce8"

URI_aarch64_at-spi2-atk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/at-spi2-atk-devel-2.52.0-3.el10.aarch64.rpm;name=aarch64_at-spi2-atk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_at-spi2-atk-devel}"
SRC_URI[aarch64_at-spi2-atk-devel.sha256sum] = "d749b031aa42d7b12135efd561ae86cce6e10ace45ddd0a24083fe2664c477ee"

URI_aarch64_at-spi2-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/at-spi2-core-2.52.0-3.el10.aarch64.rpm;name=aarch64_at-spi2-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_at-spi2-core}"
SRC_URI[aarch64_at-spi2-core.sha256sum] = "1e28700bd16f8d05aee54d412343f0166100837af49a9144ea9c0cf990f55287"

URI_aarch64_at-spi2-core-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/at-spi2-core-devel-2.52.0-3.el10.aarch64.rpm;name=aarch64_at-spi2-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_at-spi2-core-devel}"
SRC_URI[aarch64_at-spi2-core-devel.sha256sum] = "ef13a20a48ebc1411e4edd8ea579331f98fabeaaf7d68ff807789f319394947f"

URI_aarch64_atk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/atk-2.52.0-3.el10.aarch64.rpm;name=aarch64_atk;unpack=0"
SRC_URI:append = " ${URI_aarch64_atk}"
SRC_URI[aarch64_atk.sha256sum] = "6591550232d289150f2b04c27b9eb901d1367d2a42302b3a933d254619623d08"

URI_aarch64_atk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/atk-devel-2.52.0-3.el10.aarch64.rpm;name=aarch64_atk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_atk-devel}"
SRC_URI[aarch64_atk-devel.sha256sum] = "1117c58d6cd781c2ce3fa24dd399d5a81ab8723fbef336fd66ab1903cc519b55"

RDEPENDS:at-spi2-atk = " \
 at-spi2-core \
 atk \
 dbus-libs \
 glib2 \
 glibc \
 "
RDEPENDS:at-spi2-atk-devel = " \
 at-spi2-atk \
 at-spi2-core-devel \
 atk-devel \
 dbus-devel \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:at-spi2-core = " \
 bash \
 dbus \
 dbus-libs \
 glib2 \
 glibc \
 libX11 \
 libXi \
 libXtst \
 systemd-libs \
 xprop \
 "
RDEPENDS:at-spi2-core-devel = " \
 at-spi2-core \
 dbus-devel \
 glib2-devel \
 libX11-devel \
 libXi-devel \
 libXtst-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:atk = " \
 at-spi2-core \
 glib2 \
 glibc \
 "
RDEPENDS:atk-devel = " \
 atk \
 glib2-devel \
 pkgconf-pkg-config \
 "
