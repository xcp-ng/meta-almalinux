# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-fs"
PV = "0.16.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-fs+default-devel \
 rust-gix-fs+serde-devel \
 rust-gix-fs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-fs-0.16.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec52c739d5ccdfb87c14ff31fbf3c77a91be6b8fb4ab0209920c74c14e5c48e0"

URI_x86_64_v2_rust-gix-fs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-fs+default-devel-0.16.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-fs+default-devel}"
SRC_URI[x86_64_v2_rust-gix-fs+default-devel.sha256sum] = "7bbc73bb146194e502bbf17c642800ceb7043fda9f125703ebf9927a2871caeb"

URI_x86_64_v2_rust-gix-fs+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-fs+serde-devel-0.16.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-fs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-fs+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-fs+serde-devel.sha256sum] = "fec7260cf98777831ad535964865d7ce060b1892c751dc96009c77d126bbe8a4"

URI_x86_64_v2_rust-gix-fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-fs-devel-0.16.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-fs-devel}"
SRC_URI[x86_64_v2_rust-gix-fs-devel.sha256sum] = "0fed03441e1015b7af17dc9270c436d68e20c1290990e75f8cd704933ec3cee3"

URI_aarch64_rust-gix-fs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-fs+default-devel-0.16.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-fs+default-devel}"
SRC_URI[aarch64_rust-gix-fs+default-devel.sha256sum] = "5c05c43fe6b0ed105d65649e25723eeb5ca6ca683fbc266cc4e261d384cb2fd5"

URI_aarch64_rust-gix-fs+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-fs+serde-devel-0.16.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-fs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-fs+serde-devel}"
SRC_URI[aarch64_rust-gix-fs+serde-devel.sha256sum] = "df6394084b10edd46e24b122e39ec36532ae225ad9fa3dd8430adb557fa2a5db"

URI_aarch64_rust-gix-fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-fs-devel-0.16.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-fs-devel}"
SRC_URI[aarch64_rust-gix-fs-devel.sha256sum] = "c5ceb3513f9c72ff7d2e5f4a1e7641086f832a6b3245a21cd6e476e53e81a714"

RDEPENDS:rust-gix-fs+default-devel = " \
 cargo \
 rust-gix-fs-devel \
 "
RDEPENDS:rust-gix-fs+serde-devel = " \
 cargo \
 rust-gix-fs-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-fs-devel = " \
 cargo \
 rust \
 rust-bstr+default-devel \
 rust-fastrand+std-devel \
 rust-fastrand-devel \
 rust-gix-features+default-devel \
 rust-gix-features+fs-read-dir-devel \
 rust-gix-path+default-devel \
 rust-gix-utils+default-devel \
 rust-thiserror+default-devel \
 "
