# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bpaf_derive"
PV = "0.5.23"
PR = "1.el10_3"
PACKAGES = " \
 rust-bpaf_derive+default-devel \
 rust-bpaf_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bpaf_derive-0.5.23-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c5929406567a0a0279de8722fe28b43de3c795b81ba3670614e2927943b2f27"

URI_x86_64_v2_rust-bpaf_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf_derive+default-devel-0.5.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf_derive+default-devel}"
SRC_URI[x86_64_v2_rust-bpaf_derive+default-devel.sha256sum] = "3cd03589121807aa8b5b60ed743935a44da4ccc886e4b6ab4942bdb7f3d0981e"

URI_x86_64_v2_rust-bpaf_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf_derive-devel-0.5.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf_derive-devel}"
SRC_URI[x86_64_v2_rust-bpaf_derive-devel.sha256sum] = "318c41870c618a1b3a207b45faba45420dceb7147ab1b039fd153cc0a9589a4c"

URI_aarch64_rust-bpaf_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf_derive+default-devel-0.5.23-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf_derive+default-devel}"
SRC_URI[aarch64_rust-bpaf_derive+default-devel.sha256sum] = "02e44e0932131f68025385a633c8c64b75284b9b50483ab1403d065a948e8d51"

URI_aarch64_rust-bpaf_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf_derive-devel-0.5.23-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf_derive-devel}"
SRC_URI[aarch64_rust-bpaf_derive-devel.sha256sum] = "78ecd180555410e5fc41b8929c050d3bd80e3b59ffff517ab8ef548bca629051"

RDEPENDS:rust-bpaf_derive+default-devel = " \
 cargo \
 rust-bpaf_derive-devel \
 "
RDEPENDS:rust-bpaf_derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 rust-syn2+visit-mut-devel \
 "
