# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-der"
PV = "0.7.10"
PR = "3.el10_2"
PACKAGES = " \
 rust-der+alloc-devel \
 rust-der+arbitrary-devel \
 rust-der+bytes-devel \
 rust-der+default-devel \
 rust-der+derive-devel \
 rust-der+flagset-devel \
 rust-der+oid-devel \
 rust-der+pem-devel \
 rust-der+real-devel \
 rust-der+std-devel \
 rust-der+time-devel \
 rust-der+zeroize-devel \
 rust-der-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-der-0.7.10-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8334a94bf7ccc4c365e6c100683d0d85936a11dd58af77da8f72f74a0cc7057d"

URI_x86_64_v2_rust-der+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+alloc-devel-0.7.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+alloc-devel}"
SRC_URI[x86_64_v2_rust-der+alloc-devel.sha256sum] = "5515200196a2cd7d0b7e3f98cb45161f55ef34400da7a87fd6e37bd9803e1495"

URI_x86_64_v2_rust-der+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+arbitrary-devel-0.7.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-der+arbitrary-devel.sha256sum] = "e6b0289b51cf620bad5938c658fce38e5fd64aff01619961adf8540cef0c6816"

URI_x86_64_v2_rust-der+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+bytes-devel-0.7.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+bytes-devel}"
SRC_URI[x86_64_v2_rust-der+bytes-devel.sha256sum] = "4857304fdd6c2313e50075c82dad3b8891378119e4b1468739270472153ad900"

URI_x86_64_v2_rust-der+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+default-devel-0.7.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+default-devel}"
SRC_URI[x86_64_v2_rust-der+default-devel.sha256sum] = "a314a44d0fd2f703cd58b9aeddfd217e972e26015632b774b9b482237814b0f4"

URI_x86_64_v2_rust-der+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+derive-devel-0.7.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+derive-devel}"
SRC_URI[x86_64_v2_rust-der+derive-devel.sha256sum] = "03a01c241b6ff0abfa9ccdd943ee2329b0c93f8688277a5165801ea29fb48e4f"

URI_x86_64_v2_rust-der+flagset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+flagset-devel-0.7.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+flagset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+flagset-devel}"
SRC_URI[x86_64_v2_rust-der+flagset-devel.sha256sum] = "159b669a48054e5862d4098aa5fad90ba24db042eae9e8c021ec209312a8db55"

URI_x86_64_v2_rust-der+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+oid-devel-0.7.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+oid-devel}"
SRC_URI[x86_64_v2_rust-der+oid-devel.sha256sum] = "bf81c4ec318a1020c95c05c120c23c526e4f49935423a88ae4a0aa2a24ce2b74"

URI_x86_64_v2_rust-der+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+pem-devel-0.7.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+pem-devel}"
SRC_URI[x86_64_v2_rust-der+pem-devel.sha256sum] = "1bed2b6264466170eaa2e53c9bd8c081fb4b73c09c5a734aa391b2ad9cf0d16b"

URI_x86_64_v2_rust-der+real-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+real-devel-0.7.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+real-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+real-devel}"
SRC_URI[x86_64_v2_rust-der+real-devel.sha256sum] = "8318b92f53cc5355ab00fa813287d59b0b00a6d4bd9c875122181c00c559b6e1"

URI_x86_64_v2_rust-der+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+std-devel-0.7.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+std-devel}"
SRC_URI[x86_64_v2_rust-der+std-devel.sha256sum] = "6b4931d07ab0bd3c25c3d18c8cbb3c03ad4edebed298d0b745ab89e1b0eaf37c"

URI_x86_64_v2_rust-der+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+time-devel-0.7.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+time-devel}"
SRC_URI[x86_64_v2_rust-der+time-devel.sha256sum] = "ae75f5da90c6a159f8f2cd8e569b3f8e77c1c2739881dd7f473b71a1c6248b55"

URI_x86_64_v2_rust-der+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+zeroize-devel-0.7.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+zeroize-devel}"
SRC_URI[x86_64_v2_rust-der+zeroize-devel.sha256sum] = "ca1f68d7f656a5cc8acf2c9bbe937fe1d936002400183f7b2072f3b0e5cba635"

URI_x86_64_v2_rust-der-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-devel-0.7.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-devel}"
SRC_URI[x86_64_v2_rust-der-devel.sha256sum] = "1d663f2d76a1a3ee86297edc6aba3579fbe2f9bb6919178fda8aefefadb66f9c"

URI_aarch64_rust-der+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+alloc-devel-0.7.10-3.el10_2.noarch.rpm;name=aarch64_rust-der+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+alloc-devel}"
SRC_URI[aarch64_rust-der+alloc-devel.sha256sum] = "7ea626862731477747dd3684fbdf4ec9553485906fb77ad4ea1a0a8b1dc82b24"

URI_aarch64_rust-der+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+arbitrary-devel-0.7.10-3.el10_2.noarch.rpm;name=aarch64_rust-der+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+arbitrary-devel}"
SRC_URI[aarch64_rust-der+arbitrary-devel.sha256sum] = "a56694aa8f2f50af17bdcb55785664d7d690ee7139143ca958bf3b17c3f16702"

URI_aarch64_rust-der+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+bytes-devel-0.7.10-3.el10_2.noarch.rpm;name=aarch64_rust-der+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+bytes-devel}"
SRC_URI[aarch64_rust-der+bytes-devel.sha256sum] = "13a4ba21cb9735d9289b4f73f232fadec98ee2f395225841fb280163e32d4782"

URI_aarch64_rust-der+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+default-devel-0.7.10-3.el10_2.noarch.rpm;name=aarch64_rust-der+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+default-devel}"
SRC_URI[aarch64_rust-der+default-devel.sha256sum] = "c395d141dd59e6c2cdcb256c20ac9b74d05dd9d02f95896fdb28b4ce0355b1fa"

URI_aarch64_rust-der+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+derive-devel-0.7.10-3.el10_2.noarch.rpm;name=aarch64_rust-der+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+derive-devel}"
SRC_URI[aarch64_rust-der+derive-devel.sha256sum] = "8820575fb57ac455d5fc2439f1099833bf3e0ccf6503cf3d032623c2ccb36ba7"

URI_aarch64_rust-der+flagset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+flagset-devel-0.7.10-3.el10_2.noarch.rpm;name=aarch64_rust-der+flagset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+flagset-devel}"
SRC_URI[aarch64_rust-der+flagset-devel.sha256sum] = "0b546c943917fb545943c82ea255fc8733ea726fae86bd28e801b06e9c9cab27"

URI_aarch64_rust-der+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+oid-devel-0.7.10-3.el10_2.noarch.rpm;name=aarch64_rust-der+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+oid-devel}"
SRC_URI[aarch64_rust-der+oid-devel.sha256sum] = "8842d2d7975b501f8c46e93ed8e7548fe144c762a316f78b523267770fccb613"

URI_aarch64_rust-der+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+pem-devel-0.7.10-3.el10_2.noarch.rpm;name=aarch64_rust-der+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+pem-devel}"
SRC_URI[aarch64_rust-der+pem-devel.sha256sum] = "b5011b78cc6c09296085a012262b1da8dc4a8fdb5206b8190a4b2c96947aba49"

URI_aarch64_rust-der+real-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+real-devel-0.7.10-3.el10_2.noarch.rpm;name=aarch64_rust-der+real-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+real-devel}"
SRC_URI[aarch64_rust-der+real-devel.sha256sum] = "33adc817637df2b7565422a610d195449fcfbc291ae64618752ca0aee33ca924"

URI_aarch64_rust-der+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+std-devel-0.7.10-3.el10_2.noarch.rpm;name=aarch64_rust-der+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+std-devel}"
SRC_URI[aarch64_rust-der+std-devel.sha256sum] = "5bbefc1cf3674d160b2f3f5483a14734f45faa9ca28a0e2482838b1604bfc6aa"

URI_aarch64_rust-der+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+time-devel-0.7.10-3.el10_2.noarch.rpm;name=aarch64_rust-der+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+time-devel}"
SRC_URI[aarch64_rust-der+time-devel.sha256sum] = "e314c45f57c55bf6228a403a502bbe29ec5be46271534dd5d113f2dfe82a83f8"

URI_aarch64_rust-der+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+zeroize-devel-0.7.10-3.el10_2.noarch.rpm;name=aarch64_rust-der+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+zeroize-devel}"
SRC_URI[aarch64_rust-der+zeroize-devel.sha256sum] = "1eed7cfd7515191fb86c2ab1799c06274a9d1fe831d683bbbeeb9b0bdcddc1d2"

URI_aarch64_rust-der-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-devel-0.7.10-3.el10_2.noarch.rpm;name=aarch64_rust-der-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-devel}"
SRC_URI[aarch64_rust-der-devel.sha256sum] = "8a87b61dea3762c50a95f4978a856b3fd8cbede337c1d0c56b6ac5fbb474330d"

RDEPENDS:rust-der+alloc-devel = " \
 cargo \
 rust-der-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-der+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-const-oid+arbitrary-devel \
 rust-const-oid+default-devel \
 rust-der+std-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+bytes-devel = " \
 cargo \
 rust-bytes-devel \
 rust-der+alloc-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+default-devel = " \
 cargo \
 rust-der-devel \
 "
RDEPENDS:rust-der+derive-devel = " \
 cargo \
 rust-der-devel \
 rust-der_derive+default-devel \
 "
RDEPENDS:rust-der+flagset-devel = " \
 cargo \
 rust-der-devel \
 rust-flagset+default-devel \
 "
RDEPENDS:rust-der+oid-devel = " \
 cargo \
 rust-const-oid+default-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+pem-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-der+zeroize-devel \
 rust-der-devel \
 rust-pem-rfc7468+alloc-devel \
 rust-pem-rfc7468+default-devel \
 "
RDEPENDS:rust-der+real-devel = " \
 cargo \
 rust-der-devel \
 "
RDEPENDS:rust-der+std-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+time-devel = " \
 cargo \
 rust-der-devel \
 rust-time-devel \
 "
RDEPENDS:rust-der+zeroize-devel = " \
 cargo \
 rust-der-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-der-devel = " \
 cargo \
 rust \
 "
