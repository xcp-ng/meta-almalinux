# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-core"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-reqsign-core+default-devel \
 rust-reqsign-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-core-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7087b96b769af94bae08c72ab58d3cf43b23c98eca452f8ba7a273cdc0fd677d"

URI_x86_64_v2_rust-reqsign-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-core+default-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-core+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-core+default-devel.sha256sum] = "c670040ab666464f76cad4e87b84cb1d4f9f6ab4f51d0eadeb9373880890e9a9"

URI_x86_64_v2_rust-reqsign-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-core-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-core-devel}"
SRC_URI[x86_64_v2_rust-reqsign-core-devel.sha256sum] = "51b04d4c9970a48a3fa8da8df5877dc90e8832636c38a97dddcb9af386927ebc"

URI_aarch64_rust-reqsign-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-core+default-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-core+default-devel}"
SRC_URI[aarch64_rust-reqsign-core+default-devel.sha256sum] = "8ca547f9ce5e8da92f0d6c72d2cde458056326903b1c6dc999bcfcc89defb0de"

URI_aarch64_rust-reqsign-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-core-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-core-devel}"
SRC_URI[aarch64_rust-reqsign-core-devel.sha256sum] = "0419dd4d4fbbe13d0ace378710475d55b6064bc26b34965800133344dfae31a0"

RDEPENDS:rust-reqsign-core+default-devel = " \
 cargo \
 rust-reqsign-core-devel \
 "
RDEPENDS:rust-reqsign-core-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-base64+default-devel \
 rust-bytes+default-devel \
 rust-form_urlencoded+default-devel \
 rust-hex+default-devel \
 rust-hmac+default-devel \
 rust-http+default-devel \
 rust-jiff+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-sha1+default-devel \
 rust-sha2+default-devel \
 rust-sha2+oid-devel \
 "
