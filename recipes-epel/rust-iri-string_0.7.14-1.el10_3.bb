# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-iri-string"
PV = "0.7.14"
PR = "1.el10_3"
PACKAGES = " \
 rust-iri-string+alloc-devel \
 rust-iri-string+default-devel \
 rust-iri-string+memchr-devel \
 rust-iri-string+serde-devel \
 rust-iri-string+std-devel \
 rust-iri-string-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-iri-string-0.7.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "11c5abb446039d3316b072f68b4fb060f5a8a952da5a157a1b97562fe8348fc5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+alloc-devel-0.7.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-iri-string+alloc-devel.sha256sum] = "67fc86cbeaa7d9db4c1ac199c94102b6bd79180dcab1ba7b3b3beed2bcc4a72d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+default-devel-0.7.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-iri-string+default-devel.sha256sum] = "d072948daede99a016be01df30a359b6a3b018974007cea7381eeabc1d21d69f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+memchr-devel-0.7.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+memchr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-iri-string+memchr-devel.sha256sum] = "16218d3ced25018b8d946283a5c2c660a1c89d8cb4a8312603d470be609b476c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+serde-devel-0.7.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-iri-string+serde-devel.sha256sum] = "ba7fe797bdc79e796ed89c7e6160464969042af292f18c7cbd801267b3cbfecb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+std-devel-0.7.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-iri-string+std-devel.sha256sum] = "14b61bf283b704bd52aff77bebf8532b7322244ba11955804a9e6f884f6abed6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string-devel-0.7.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string-devel;unpack=0"
SRC_URI[x86_64_v2_rust-iri-string-devel.sha256sum] = "9346b75ef5515c116dc211ac4ee2de42cd7bd7ea6433daed0e9b3bf98643bde1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+alloc-devel-0.7.14-1.el10_3.noarch.rpm;name=aarch64_rust-iri-string+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-iri-string+alloc-devel.sha256sum] = "1ccd4cfe65e2af5414b89ea957cfe83f3ca53a7250a1f608f9a27c1d19ca043c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+default-devel-0.7.14-1.el10_3.noarch.rpm;name=aarch64_rust-iri-string+default-devel;unpack=0"
SRC_URI[aarch64_rust-iri-string+default-devel.sha256sum] = "0ff6a57e6893c1d6b047e81e52e30d12e883e0b2c50cac17dcbb2d9cbb54ae20"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+memchr-devel-0.7.14-1.el10_3.noarch.rpm;name=aarch64_rust-iri-string+memchr-devel;unpack=0"
SRC_URI[aarch64_rust-iri-string+memchr-devel.sha256sum] = "0b5b80053f1d60b5fa5f11db51281ea78eee188b1cf00d620045108e0919ea2f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+serde-devel-0.7.14-1.el10_3.noarch.rpm;name=aarch64_rust-iri-string+serde-devel;unpack=0"
SRC_URI[aarch64_rust-iri-string+serde-devel.sha256sum] = "51c0196cebd3445cac34db0df5eb12504b3dc182985b7f617fc0dababc303772"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+std-devel-0.7.14-1.el10_3.noarch.rpm;name=aarch64_rust-iri-string+std-devel;unpack=0"
SRC_URI[aarch64_rust-iri-string+std-devel.sha256sum] = "07b176bfa2b526fe8ed8a9df89b821ff677c5361b0b11957c82bde6a778ab880"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string-devel-0.7.14-1.el10_3.noarch.rpm;name=aarch64_rust-iri-string-devel;unpack=0"
SRC_URI[aarch64_rust-iri-string-devel.sha256sum] = "29f0ccd99e7a0597e31625cf7459ac8ff8a1100ec293983598063001f66502fe"

RDEPENDS:rust-iri-string+alloc-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string+default-devel = " \
 cargo \
 rust-iri-string+std-devel \
 rust-iri-string-devel \
 "
RDEPENDS:rust-iri-string+memchr-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-iri-string+serde-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string+std-devel = " \
 cargo \
 rust-iri-string+alloc-devel \
 rust-iri-string-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string-devel = " \
 cargo \
 rust \
 "
