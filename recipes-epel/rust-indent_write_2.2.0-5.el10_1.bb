# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indent_write"
PV = "2.2.0"
PR = "5.el10_1"
PACKAGES = " \
 rust-indent_write+default-devel \
 rust-indent_write+std-devel \
 rust-indent_write-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indent_write-2.2.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9bb369209ad40b6d5aa434c2778c3dc9fdf5f7a27b8e96ca59ce65037caf832"

URI_x86_64_v2_rust-indent_write+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indent_write+default-devel-2.2.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indent_write+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indent_write+default-devel}"
SRC_URI[x86_64_v2_rust-indent_write+default-devel.sha256sum] = "9972c4bf1fc07860f502adc1b3ae8fcd0b961fc6f431a871a87923d4326ea79b"

URI_x86_64_v2_rust-indent_write+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indent_write+std-devel-2.2.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indent_write+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indent_write+std-devel}"
SRC_URI[x86_64_v2_rust-indent_write+std-devel.sha256sum] = "b2d12e69cb42bb42c5f9ee6682a1f14789f0949143dafa0e170e39e3c3431d32"

URI_x86_64_v2_rust-indent_write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indent_write-devel-2.2.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indent_write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indent_write-devel}"
SRC_URI[x86_64_v2_rust-indent_write-devel.sha256sum] = "3e19cd8789215f6cda3a4d52ff5f96d7e29f2c428177175b60dcae3240219608"

URI_aarch64_rust-indent_write+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indent_write+default-devel-2.2.0-5.el10_1.noarch.rpm;name=aarch64_rust-indent_write+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indent_write+default-devel}"
SRC_URI[aarch64_rust-indent_write+default-devel.sha256sum] = "426bdbc4fff8af3e59fc83b8edbe213b29cd1b657b3690573294f98c97e51448"

URI_aarch64_rust-indent_write+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indent_write+std-devel-2.2.0-5.el10_1.noarch.rpm;name=aarch64_rust-indent_write+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indent_write+std-devel}"
SRC_URI[aarch64_rust-indent_write+std-devel.sha256sum] = "640b56d4648757c7100f0f93ae738d2da0c6b03f898f4d618964a8033e2d33f9"

URI_aarch64_rust-indent_write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indent_write-devel-2.2.0-5.el10_1.noarch.rpm;name=aarch64_rust-indent_write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indent_write-devel}"
SRC_URI[aarch64_rust-indent_write-devel.sha256sum] = "4df87a6d064c604b7bd15d57263ea7562e89abcad70fa581ad87f25c10747148"

RDEPENDS:rust-indent_write+default-devel = " \
 cargo \
 rust-indent_write+std-devel \
 rust-indent_write-devel \
 "
RDEPENDS:rust-indent_write+std-devel = " \
 cargo \
 rust-indent_write-devel \
 "
RDEPENDS:rust-indent_write-devel = " \
 cargo \
 "
