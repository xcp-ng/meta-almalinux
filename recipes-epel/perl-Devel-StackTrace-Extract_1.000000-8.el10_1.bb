# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-StackTrace-Extract"
PV = "1.000000"
PR = "8.el10_1"
PACKAGES = " \
 perl-Devel-StackTrace-Extract \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-StackTrace-Extract-1.000000-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06e70b56450a4c3f941cbfb62ddd104265cebaef01f1417f7abadd2cbdd2c4e4"

URI_x86_64_v2_perl-Devel-StackTrace-Extract = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-StackTrace-Extract-1.000000-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-StackTrace-Extract;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-StackTrace-Extract}"
SRC_URI[x86_64_v2_perl-Devel-StackTrace-Extract.sha256sum] = "c701cbe0ed90ee03d57baddca431ee132959efe689ae727cd2bc9b72d99a560b"

URI_aarch64_perl-Devel-StackTrace-Extract = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-StackTrace-Extract-1.000000-8.el10_1.noarch.rpm;name=aarch64_perl-Devel-StackTrace-Extract;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-StackTrace-Extract}"
SRC_URI[aarch64_perl-Devel-StackTrace-Extract.sha256sum] = "dbbdeee008c056c943fc0352ea37f12040707a6e856c4b8cdf81c19eaefe3f63"

RDEPENDS:perl-Devel-StackTrace-Extract = " \
 perl-Devel-StackTrace \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-base \
 perl-libs \
 "
