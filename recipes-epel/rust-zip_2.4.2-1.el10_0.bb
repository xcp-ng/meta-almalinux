# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zip"
PV = "2.4.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-zip+_all-features-devel \
 rust-zip+_deflate-any-devel \
 rust-zip+aes-crypto-devel \
 rust-zip+aes-devel \
 rust-zip+bzip2-devel \
 rust-zip+chrono-devel \
 rust-zip+constant_time_eq-devel \
 rust-zip+default-devel \
 rust-zip+deflate-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip+deflate-miniz-devel \
 rust-zip+deflate-zlib-devel \
 rust-zip+deflate-zlib-ng-devel \
 rust-zip+deflate-zopfli-devel \
 rust-zip+deflate64-devel \
 rust-zip+flate2-devel \
 rust-zip+getrandom-devel \
 rust-zip+hmac-devel \
 rust-zip+lzma-devel \
 rust-zip+lzma-rs-devel \
 rust-zip+pbkdf2-devel \
 rust-zip+sha1-devel \
 rust-zip+time-devel \
 rust-zip+unreserved-devel \
 rust-zip+xz-devel \
 rust-zip+zeroize-devel \
 rust-zip+zopfli-devel \
 rust-zip+zstd-devel \
 rust-zip-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zip-2.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28e22796d27251c1dfa37a600997fbf669683fd7c964aea7f2d9bb56c8d17be5"

URI_x86_64_v2_rust-zip+_all-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+_all-features-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+_all-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+_all-features-devel}"
SRC_URI[x86_64_v2_rust-zip+_all-features-devel.sha256sum] = "559f3d71550012a4d94f7a6bc7068765977a7caa31265f75e6d9d9fa5502876e"

URI_x86_64_v2_rust-zip+_deflate-any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+_deflate-any-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+_deflate-any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+_deflate-any-devel}"
SRC_URI[x86_64_v2_rust-zip+_deflate-any-devel.sha256sum] = "aae22091384178271bf5117136f3e31b26316e78ed1ead6f7eb7ae2c839cd098"

URI_x86_64_v2_rust-zip+aes-crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+aes-crypto-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+aes-crypto-devel}"
SRC_URI[x86_64_v2_rust-zip+aes-crypto-devel.sha256sum] = "0016577d92d8522cdddaf77cee94cd4d061ef604bcff0fd88036b0679be115e9"

URI_x86_64_v2_rust-zip+aes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+aes-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+aes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+aes-devel}"
SRC_URI[x86_64_v2_rust-zip+aes-devel.sha256sum] = "435b723c7499432f644616e52e45c09b2cdd37661385256024a58e9740d7ab93"

URI_x86_64_v2_rust-zip+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+bzip2-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+bzip2-devel}"
SRC_URI[x86_64_v2_rust-zip+bzip2-devel.sha256sum] = "a685a266bd496a3b444c0e653126c8e754570f69f2876c11b9ea37ecda99fd24"
RPROVIDES:rust-zip+bzip2-devel:x86_64_v2 = "virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_3.0.0~"

URI_x86_64_v2_rust-zip+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+chrono-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+chrono-devel}"
SRC_URI[x86_64_v2_rust-zip+chrono-devel.sha256sum] = "bd8bf2295cdca6074b6bcda8c802600d3e3facb52d34e6c0639119f1a1f0fae7"

URI_x86_64_v2_rust-zip+constant_time_eq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+constant_time_eq-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+constant_time_eq-devel}"
SRC_URI[x86_64_v2_rust-zip+constant_time_eq-devel.sha256sum] = "6541fe8a469aa91aad18df304e5bdef3295081266281490ce613a4752f613211"

URI_x86_64_v2_rust-zip+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+default-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+default-devel}"
SRC_URI[x86_64_v2_rust-zip+default-devel.sha256sum] = "3cf5244de6160813ab5ffe0242ecc9edadf46946129b0ed0990abdd597ded2b4"

URI_x86_64_v2_rust-zip+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-devel.sha256sum] = "edbff6588d2be254a5ac9328b233ecb3c6e55219a7ef3da71fd8bb9146f6027c"
RPROVIDES:rust-zip+deflate-devel:x86_64_v2 = "virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_3.0.0~"

URI_x86_64_v2_rust-zip+deflate-flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-flate2-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-flate2-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-flate2-devel.sha256sum] = "50251102fedb3d3fa43751980626a65ae79cec7a92de842c8cf8050e0ea55b79"

URI_x86_64_v2_rust-zip+deflate-miniz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-miniz-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-miniz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-miniz-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-miniz-devel.sha256sum] = "e9f74bff5924c86bef5120150249791b6ee1c3bc1cdf596ff2f2a8be89744ee9"

URI_x86_64_v2_rust-zip+deflate-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-zlib-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-zlib-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-zlib-devel.sha256sum] = "79b7599518d33159127285e5d6c8cb2d6f190c380ac43a8ac8084d6eab40c816"

URI_x86_64_v2_rust-zip+deflate-zlib-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-zlib-ng-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-zlib-ng-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-zlib-ng-devel.sha256sum] = "c1d492d79d6421df91ad728e1c3aa22143fe0274613238cb9e180e53c2944558"

URI_x86_64_v2_rust-zip+deflate-zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-zopfli-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-zopfli-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-zopfli-devel.sha256sum] = "3a4c56d5e95eae1dfc228eb713bed77584c0afa5290c1aa492025e8522bb958c"

URI_x86_64_v2_rust-zip+deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate64-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate64-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate64-devel.sha256sum] = "4a7f51cc7a683bef2373d230cc129711802eabadfacf1b527480a77879222038"

URI_x86_64_v2_rust-zip+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+flate2-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+flate2-devel}"
SRC_URI[x86_64_v2_rust-zip+flate2-devel.sha256sum] = "d3b8b3f373d28c0831582aa9403f4c23bd7df7be761297025f53f494d70becdc"

URI_x86_64_v2_rust-zip+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+getrandom-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+getrandom-devel}"
SRC_URI[x86_64_v2_rust-zip+getrandom-devel.sha256sum] = "b579041c83c7b57e2668f76301b5e45b6f41c121165000c851c78fd7c68a1905"

URI_x86_64_v2_rust-zip+hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+hmac-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+hmac-devel}"
SRC_URI[x86_64_v2_rust-zip+hmac-devel.sha256sum] = "d11bf162e82a5648ac17205ab31b17a24e467d7be26fda0f53e49620675b16a6"

URI_x86_64_v2_rust-zip+lzma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+lzma-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+lzma-devel}"
SRC_URI[x86_64_v2_rust-zip+lzma-devel.sha256sum] = "2314a87ff21ff70e4d789f44e09d7aa8e8b2068307bda49c64f5eea67de94d4a"

URI_x86_64_v2_rust-zip+lzma-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+lzma-rs-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+lzma-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+lzma-rs-devel}"
SRC_URI[x86_64_v2_rust-zip+lzma-rs-devel.sha256sum] = "66ee27b5a7734b9b5ae7c486fa92d9aa8c4d187fd18558af16b8f47acb69c321"

URI_x86_64_v2_rust-zip+pbkdf2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+pbkdf2-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+pbkdf2-devel}"
SRC_URI[x86_64_v2_rust-zip+pbkdf2-devel.sha256sum] = "6c0dfd5b599f2fd791c64e0035d6e6a072a45f7d4868e3b81c84292b94e904c4"

URI_x86_64_v2_rust-zip+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+sha1-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+sha1-devel}"
SRC_URI[x86_64_v2_rust-zip+sha1-devel.sha256sum] = "1f2372219daf957678ef17f6b5069d2825b6e33f306cd2969dbf212bf43e358d"

URI_x86_64_v2_rust-zip+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+time-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+time-devel}"
SRC_URI[x86_64_v2_rust-zip+time-devel.sha256sum] = "c91dc0495addda8535776eae995ba45bbce3111eb6be0b3777c2637d9ee1c004"

URI_x86_64_v2_rust-zip+unreserved-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+unreserved-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+unreserved-devel}"
SRC_URI[x86_64_v2_rust-zip+unreserved-devel.sha256sum] = "8c4c29f0c4ed996fa23a4ee495175edc158c077cad5d0f363484fbef1625ad62"

URI_x86_64_v2_rust-zip+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+xz-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+xz-devel}"
SRC_URI[x86_64_v2_rust-zip+xz-devel.sha256sum] = "5419bdb32322f072eb26982378852ee198f453473395f8d7d30b94006300fc4d"

URI_x86_64_v2_rust-zip+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+zeroize-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+zeroize-devel}"
SRC_URI[x86_64_v2_rust-zip+zeroize-devel.sha256sum] = "29cb9554379af3a404da7ca1ef29e7ec523b5d669f8edb0f5cc3a3e6e0b9bbf9"

URI_x86_64_v2_rust-zip+zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+zopfli-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+zopfli-devel}"
SRC_URI[x86_64_v2_rust-zip+zopfli-devel.sha256sum] = "4394e88b1ae67d865b7f6629bd4e83316ea6cd67a62cac55ce31eaf3168b4ffb"

URI_x86_64_v2_rust-zip+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+zstd-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+zstd-devel}"
SRC_URI[x86_64_v2_rust-zip+zstd-devel.sha256sum] = "5ab242403eedda6e2ef890f7b73ed49764f660e64f1bae3e75b4e853b5d8607c"

URI_x86_64_v2_rust-zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip-devel-2.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip-devel}"
SRC_URI[x86_64_v2_rust-zip-devel.sha256sum] = "211a859d592550fef71b22bd882e9beab037f75bdd26c0961a808a98bdc4e76d"
RPROVIDES:rust-zip-devel:x86_64_v2 = "virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_3.0.0~"

URI_aarch64_rust-zip+_all-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+_all-features-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+_all-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+_all-features-devel}"
SRC_URI[aarch64_rust-zip+_all-features-devel.sha256sum] = "f875ebdc017294d125bc2ec8c1fc81479ef2e1799fa359fd20eab82efce6ea4c"

URI_aarch64_rust-zip+_deflate-any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+_deflate-any-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+_deflate-any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+_deflate-any-devel}"
SRC_URI[aarch64_rust-zip+_deflate-any-devel.sha256sum] = "13ea9a8264e43f9a8509f2730bd46d5a289ec10cf032d097e35192c37ee5175d"

URI_aarch64_rust-zip+aes-crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+aes-crypto-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+aes-crypto-devel}"
SRC_URI[aarch64_rust-zip+aes-crypto-devel.sha256sum] = "12846b0900c62d25bf028926987a0b1d941e796ee12987e98311f9b9da9beaec"

URI_aarch64_rust-zip+aes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+aes-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+aes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+aes-devel}"
SRC_URI[aarch64_rust-zip+aes-devel.sha256sum] = "3772feebb0e972b96821f9714d905d602d3ffe1584d76bf768a7311a305259e7"

URI_aarch64_rust-zip+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+bzip2-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+bzip2-devel}"
SRC_URI[aarch64_rust-zip+bzip2-devel.sha256sum] = "93952011e5763eef479f020944b65364d8a826b28c3a2af165029092e15e6beb"
RPROVIDES:rust-zip+bzip2-devel:aarch64 = "virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_3.0.0~"

URI_aarch64_rust-zip+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+chrono-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+chrono-devel}"
SRC_URI[aarch64_rust-zip+chrono-devel.sha256sum] = "de02f8c457147b0011aa7e752097f5cef41af780fa51098af9c65f56066f75ce"

URI_aarch64_rust-zip+constant_time_eq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+constant_time_eq-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+constant_time_eq-devel}"
SRC_URI[aarch64_rust-zip+constant_time_eq-devel.sha256sum] = "00928959e5ac0fa1790f224751838fbdcfaa1ac39c7407f2898359717330e678"

URI_aarch64_rust-zip+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+default-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+default-devel}"
SRC_URI[aarch64_rust-zip+default-devel.sha256sum] = "a98d0e05f9ce1f82ef0eef3dfba904b480cfcb68c8746f133501fab5c23a23f8"

URI_aarch64_rust-zip+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-devel}"
SRC_URI[aarch64_rust-zip+deflate-devel.sha256sum] = "b2ec7a510589fac3ea7861d48bf57ad25ed99810c4a9ac58d556f50e0e1e2e11"
RPROVIDES:rust-zip+deflate-devel:aarch64 = "virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_3.0.0~"

URI_aarch64_rust-zip+deflate-flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-flate2-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+deflate-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-flate2-devel}"
SRC_URI[aarch64_rust-zip+deflate-flate2-devel.sha256sum] = "f6a878f314cafd60f5318fed5c13af16e00a041a9d8795e97527576f79558aa4"

URI_aarch64_rust-zip+deflate-miniz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-miniz-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+deflate-miniz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-miniz-devel}"
SRC_URI[aarch64_rust-zip+deflate-miniz-devel.sha256sum] = "3c73d89f8900caabcc2f3e5793130d29dbf6361cdb6f0c0d11f85bb23705b960"

URI_aarch64_rust-zip+deflate-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-zlib-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+deflate-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-zlib-devel}"
SRC_URI[aarch64_rust-zip+deflate-zlib-devel.sha256sum] = "b2c52176786759f8f71b8ada832e46c225399b255c1cba12e604668d70f3ce3f"

URI_aarch64_rust-zip+deflate-zlib-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-zlib-ng-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+deflate-zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-zlib-ng-devel}"
SRC_URI[aarch64_rust-zip+deflate-zlib-ng-devel.sha256sum] = "d7738950bd9cc4e8a177de19c4969556029424837f9229f62a5e921d837ba458"

URI_aarch64_rust-zip+deflate-zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-zopfli-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+deflate-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-zopfli-devel}"
SRC_URI[aarch64_rust-zip+deflate-zopfli-devel.sha256sum] = "d48ef4a89c68754e15147c44736fda1edcedf9d9277ee6bcdec1262be0623fd7"

URI_aarch64_rust-zip+deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate64-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate64-devel}"
SRC_URI[aarch64_rust-zip+deflate64-devel.sha256sum] = "42400d8a2a1fe62f2161c0974c603fa71cdd224978622ab67d161c2943b495f2"

URI_aarch64_rust-zip+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+flate2-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+flate2-devel}"
SRC_URI[aarch64_rust-zip+flate2-devel.sha256sum] = "4bc367eb189e93442da020bdb2d62c351cb6dc2592252c27c0fa38d26feae0b4"

URI_aarch64_rust-zip+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+getrandom-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+getrandom-devel}"
SRC_URI[aarch64_rust-zip+getrandom-devel.sha256sum] = "fe2c75fdd43f3f28f4bcc1322b04e5d434d3fba4d4f17f17c1d10dc4efd1d17f"

URI_aarch64_rust-zip+hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+hmac-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+hmac-devel}"
SRC_URI[aarch64_rust-zip+hmac-devel.sha256sum] = "1e9c719e92ce0f5eb7b7ac3890d43173712b5a149eb2eadcf7aa5b174f6a6a71"

URI_aarch64_rust-zip+lzma-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+lzma-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+lzma-devel}"
SRC_URI[aarch64_rust-zip+lzma-devel.sha256sum] = "da931a44299e0a1da2c8db907a3dee4caec51ca171b578595608793bd7224be2"

URI_aarch64_rust-zip+lzma-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+lzma-rs-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+lzma-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+lzma-rs-devel}"
SRC_URI[aarch64_rust-zip+lzma-rs-devel.sha256sum] = "f75526a7a8d06a231efa56c53dd5ed4a342b4523d93706b3c744843210971bd3"

URI_aarch64_rust-zip+pbkdf2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+pbkdf2-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+pbkdf2-devel}"
SRC_URI[aarch64_rust-zip+pbkdf2-devel.sha256sum] = "89110bdba0e12121bb065d96a975c8d131ab8c4249770f0a8239a94e7eb7d8f6"

URI_aarch64_rust-zip+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+sha1-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+sha1-devel}"
SRC_URI[aarch64_rust-zip+sha1-devel.sha256sum] = "07f237b006201daa199e2f19107ae0827259f6ec85659f9ef353d73f91a6579c"

URI_aarch64_rust-zip+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+time-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+time-devel}"
SRC_URI[aarch64_rust-zip+time-devel.sha256sum] = "3b4adde3e232897c3998f57ec8034e5a5adab93a0216c57c9ecbe9120ee5f8c6"

URI_aarch64_rust-zip+unreserved-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+unreserved-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+unreserved-devel}"
SRC_URI[aarch64_rust-zip+unreserved-devel.sha256sum] = "1f50a5da8c98480573f8029afa57bd55d0f727680f9a7f4fa354f8fa10fe8fc7"

URI_aarch64_rust-zip+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+xz-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+xz-devel}"
SRC_URI[aarch64_rust-zip+xz-devel.sha256sum] = "d7a169e5ca69118d355078dffe11607ffc06d551ec38f386eac400f22156062e"

URI_aarch64_rust-zip+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+zeroize-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+zeroize-devel}"
SRC_URI[aarch64_rust-zip+zeroize-devel.sha256sum] = "393419c1ef7bfc460994b8e2cd8e3a7fc366911fab3f4947b6f4d839b18359c7"

URI_aarch64_rust-zip+zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+zopfli-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+zopfli-devel}"
SRC_URI[aarch64_rust-zip+zopfli-devel.sha256sum] = "415207677df73b011726a16e00f9bf9456881eed95ae4eacb897ee7a3a404477"

URI_aarch64_rust-zip+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+zstd-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+zstd-devel}"
SRC_URI[aarch64_rust-zip+zstd-devel.sha256sum] = "dfa38ff8f0df6fa0fbcdc2a77c5707a73c3f03340ca35ba75f64f3d98963cc80"

URI_aarch64_rust-zip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip-devel-2.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip-devel}"
SRC_URI[aarch64_rust-zip-devel.sha256sum] = "08fffb9d02e054ab09f033cd4e7ce2f09b0db5c2bafa648d838a6e583d6a77e5"
RPROVIDES:rust-zip-devel:aarch64 = "virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_3.0.0~"

RDEPENDS:rust-zip+_all-features-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+_deflate-any-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+aes-crypto-devel = " \
 cargo \
 rust-zip+aes-devel \
 rust-zip+constant_time_eq-devel \
 rust-zip+getrandom-devel \
 rust-zip+hmac-devel \
 rust-zip+pbkdf2-devel \
 rust-zip+sha1-devel \
 rust-zip+zeroize-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+aes-devel = " \
 cargo \
 rust-aes+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+chrono-devel = " \
 cargo \
 rust-chrono+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+constant_time_eq-devel = " \
 cargo \
 rust-constant_time_eq+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+default-devel = " \
 cargo \
 rust-zip+aes-crypto-devel \
 rust-zip+bzip2-devel \
 rust-zip+deflate-devel \
 rust-zip+deflate64-devel \
 rust-zip+lzma-devel \
 rust-zip+time-devel \
 rust-zip+xz-devel \
 rust-zip+zstd-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-devel = " \
 cargo \
 rust-flate2+rust_backend-devel \
 rust-flate2-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip+deflate-zopfli-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-flate2-devel = " \
 cargo \
 rust-zip+_deflate-any-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-miniz-devel = " \
 cargo \
 rust-zip+deflate-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-zlib-devel = " \
 cargo \
 rust-flate2+zlib-devel \
 rust-flate2-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-zlib-ng-devel = " \
 cargo \
 rust-flate2+zlib-ng-devel \
 rust-flate2-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-zopfli-devel = " \
 cargo \
 rust-zip+_deflate-any-devel \
 rust-zip+zopfli-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate64-devel = " \
 cargo \
 rust-deflate64+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+flate2-devel = " \
 cargo \
 rust-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-getrandom+std-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+hmac-devel = " \
 cargo \
 rust-hmac+default-devel \
 rust-hmac+reset-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+lzma-devel = " \
 cargo \
 rust-lzma-rs+stream-devel \
 rust-lzma-rs-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+lzma-rs-devel = " \
 cargo \
 rust-lzma-rs-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+pbkdf2-devel = " \
 cargo \
 rust-pbkdf2+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+sha1-devel = " \
 cargo \
 rust-sha1+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+time-devel = " \
 cargo \
 rust-time+std-devel \
 rust-time-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+unreserved-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+xz-devel = " \
 cargo \
 rust-xz2+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+zeroize-devel = " \
 cargo \
 rust-zeroize+default-devel \
 rust-zeroize+zeroize_derive-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+zopfli-devel = " \
 cargo \
 rust-zip-devel \
 rust-zopfli+default-devel \
 "
RDEPENDS:rust-zip+zstd-devel = " \
 cargo \
 rust-zip-devel \
 rust-zstd-devel \
 "
RDEPENDS:rust-zip-devel = " \
 cargo \
 rust \
 rust-crc32fast+default-devel \
 rust-displaydoc-devel \
 rust-indexmap+default-devel \
 rust-memchr+default-devel \
 rust-thiserror+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_3.0.0~ rpm/virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_3.0.0~ rpm/virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_3.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_3.0.0~ rpm/virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_3.0.0~ rpm/virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_3.0.0~"
