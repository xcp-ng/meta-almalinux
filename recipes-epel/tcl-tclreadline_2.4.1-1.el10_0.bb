# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tcl-tclreadline"
PV = "2.4.1"
PR = "1.el10_0"
PACKAGES = " \
 tcl-tclreadline \
 tcl-tclreadline-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tcl-tclreadline-2.4.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4ca25115c0fcf32216193ab933a56449ef3b1437a8e12519d18fbc2fe7bf716"

URI_x86_64_v2_tcl-tclreadline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcl-tclreadline-2.4.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcl-tclreadline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tcl-tclreadline}"
SRC_URI[x86_64_v2_tcl-tclreadline.sha256sum] = "42711c0d2bea9e00f759b59d0ea6b56d6f7f9abd6c8abdc5c76331cb36506326"

URI_x86_64_v2_tcl-tclreadline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcl-tclreadline-devel-2.4.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcl-tclreadline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tcl-tclreadline-devel}"
SRC_URI[x86_64_v2_tcl-tclreadline-devel.sha256sum] = "f7f72d153bcdb272ac61bdcf2b63ca19473c0b76c4f8dfda9d5b93f7c4cec0e2"

URI_aarch64_tcl-tclreadline = "${EPEL_MIRROR}/aarch64/Packages/t/tcl-tclreadline-2.4.1-1.el10_0.aarch64.rpm;name=aarch64_tcl-tclreadline;unpack=0"
SRC_URI:append = " ${URI_aarch64_tcl-tclreadline}"
SRC_URI[aarch64_tcl-tclreadline.sha256sum] = "9efe55739d4bec8fadf5e99abaf21cf77850e73fd851031d051de5e68684c107"

URI_aarch64_tcl-tclreadline-devel = "${EPEL_MIRROR}/aarch64/Packages/t/tcl-tclreadline-devel-2.4.1-1.el10_0.aarch64.rpm;name=aarch64_tcl-tclreadline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tcl-tclreadline-devel}"
SRC_URI[aarch64_tcl-tclreadline-devel.sha256sum] = "64d6ed27cbb0ffb4e516b69e3aed927c84f984ba7245b8ff91b57fb9645752fc"

RDEPENDS:tcl-tclreadline = " \
 glibc \
 readline \
 tcl \
 "
RDEPENDS:tcl-tclreadline-devel = " \
 tcl-tclreadline \
 "
