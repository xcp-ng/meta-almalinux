# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssh"
PV = "9.9p1"
PR = "25.el10_2.alma.1"
PACKAGES = " \
 openssh \
 openssh-askpass \
 openssh-clients \
 openssh-keycat \
 openssh-keysign \
 openssh-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openssh-9.9p1-25.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "255c6670b8c94f11ee781d3321f1d30eece6b8f74872a4a683533a9059e9cd35"

URI_x86_64_v2_openssh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-9.9p1-25.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh}"
SRC_URI[x86_64_v2_openssh.sha256sum] = "c721902ca86a8b14140c6417c95e485219074d244e0d11167f238de38a4273d3"

URI_x86_64_v2_openssh-askpass = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssh-askpass-9.9p1-25.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-askpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-askpass}"
SRC_URI[x86_64_v2_openssh-askpass.sha256sum] = "8e34921643845426e71ed976c965814c406e0d409cf20e6b466ede72cf8574ba"

URI_x86_64_v2_openssh-clients = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-clients-9.9p1-25.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-clients}"
SRC_URI[x86_64_v2_openssh-clients.sha256sum] = "393f2a14da524585fea54c6fe54a253de744abe49285988d3284e06064f45a94"

URI_x86_64_v2_openssh-keycat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-keycat-9.9p1-25.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-keycat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-keycat}"
SRC_URI[x86_64_v2_openssh-keycat.sha256sum] = "80659364176ed1c0b6e2ac7da1ecc7a89ecd517367f4d36ecabbd5ca01b70bc3"

URI_x86_64_v2_openssh-keysign = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssh-keysign-9.9p1-25.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-keysign}"
SRC_URI[x86_64_v2_openssh-keysign.sha256sum] = "6d706b9259ae0db0d677cc8b51e36a62085986cd943ea3e1ff7bc2db6bcc44ef"

URI_x86_64_v2_openssh-server = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-server-9.9p1-25.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-server}"
SRC_URI[x86_64_v2_openssh-server.sha256sum] = "88e63a28c392981603cce77728612f40d8377dd7a45c9612e8bf67291d0901fa"

URI_aarch64_openssh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-9.9p1-25.el10_2.alma.1.aarch64.rpm;name=aarch64_openssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh}"
SRC_URI[aarch64_openssh.sha256sum] = "6c2633e058aa07216548d3433a8ad2f45ba830f3213c46e690d2949047457191"

URI_aarch64_openssh-askpass = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssh-askpass-9.9p1-25.el10_2.alma.1.aarch64.rpm;name=aarch64_openssh-askpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-askpass}"
SRC_URI[aarch64_openssh-askpass.sha256sum] = "a6081683aac0b5273f1653c52b2e726c5f14650989f121f78c67f70db305b884"

URI_aarch64_openssh-clients = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-clients-9.9p1-25.el10_2.alma.1.aarch64.rpm;name=aarch64_openssh-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-clients}"
SRC_URI[aarch64_openssh-clients.sha256sum] = "3d5e7b4608da0e3275989c76b7ab0b37b4dcc35d49f0c58861f7d4e2eb61a7d3"

URI_aarch64_openssh-keycat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-keycat-9.9p1-25.el10_2.alma.1.aarch64.rpm;name=aarch64_openssh-keycat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-keycat}"
SRC_URI[aarch64_openssh-keycat.sha256sum] = "5bd71eb066e961e4ec99ac5327dbe354be0da56e708471b94acc8ad57673354e"

URI_aarch64_openssh-keysign = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssh-keysign-9.9p1-25.el10_2.alma.1.aarch64.rpm;name=aarch64_openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-keysign}"
SRC_URI[aarch64_openssh-keysign.sha256sum] = "31bf2e717431dd3e86dc449bb2e0cd693a25ae7b629e46a909bc9759a3075d7d"

URI_aarch64_openssh-server = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-server-9.9p1-25.el10_2.alma.1.aarch64.rpm;name=aarch64_openssh-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-server}"
SRC_URI[aarch64_openssh-server.sha256sum] = "c034e505809db587adf9f562966b5136ee0926d03bcaa6b3440d1737c2c03e2e"

RDEPENDS:openssh = " \
 audit-libs \
 glibc \
 libselinux \
 openssl-libs \
 util-linux \
 "
RDEPENDS:openssh-askpass = " \
 glib2 \
 glibc \
 gtk3 \
 openssh \
 "
RDEPENDS:openssh-clients = " \
 bash \
 crypto-policies \
 glibc \
 krb5-libs \
 libedit \
 libfido2 \
 libselinux \
 openssh \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:openssh-keycat = " \
 glibc \
 openssh \
 pam-libs \
 "
RDEPENDS:openssh-keysign = " \
 glibc \
 openssh \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:openssh-server = " \
 audit-libs \
 bash \
 crypto-policies \
 glibc \
 krb5-libs \
 libcom_err \
 libselinux \
 libxcrypt \
 openssh \
 openssl-libs \
 pam \
 pam-libs \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
