# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-width"
PV = "0.2.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-unicode-width+cjk-devel \
 rust-unicode-width+default-devel \
 rust-unicode-width+no_std-devel \
 rust-unicode-width-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-width-0.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7627c68ea23b68dea380545f08f183f447518a2af5c56bcc2029294eb88ccffd"

URI_x86_64_v2_rust-unicode-width+cjk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width+cjk-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width+cjk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-width+cjk-devel}"
SRC_URI[x86_64_v2_rust-unicode-width+cjk-devel.sha256sum] = "7842869a17853b90729acd9f833a49bc0718555da8f0cd88628d596dabc78447"

URI_x86_64_v2_rust-unicode-width+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width+default-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-width+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-width+default-devel.sha256sum] = "5e9b734686287b7afeb691b53186aae984a0e252033c172ced60a1d87acdc602"
RPROVIDES:rust-unicode-width+default-devel:x86_64_v2 = "virtual/crate_unicode-width/default__ge_0.0.0_with_crate_unicode-width/default__lt_1.0.0~"

URI_x86_64_v2_rust-unicode-width+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width+no_std-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-width+no_std-devel}"
SRC_URI[x86_64_v2_rust-unicode-width+no_std-devel.sha256sum] = "fbb0f87f4185304dff0b08a8301742b76fb5fad4a218a151c17312a361188b39"

URI_x86_64_v2_rust-unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-width-devel}"
SRC_URI[x86_64_v2_rust-unicode-width-devel.sha256sum] = "95ec0eb25270827f44969a712f42684c558d75226f1f6f61e64ea691adbd7e84"

URI_aarch64_rust-unicode-width+cjk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width+cjk-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-width+cjk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-width+cjk-devel}"
SRC_URI[aarch64_rust-unicode-width+cjk-devel.sha256sum] = "5f38b885fa3b67efe6a7feedfdb5759e0f0e8ead4d3ecff46d48ca82d7a5272f"

URI_aarch64_rust-unicode-width+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width+default-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-width+default-devel}"
SRC_URI[aarch64_rust-unicode-width+default-devel.sha256sum] = "7f4ab6ffb4918ae4df7f3f8c26df8d3541887655c3b833c72328abccb57db70d"
RPROVIDES:rust-unicode-width+default-devel:aarch64 = "virtual/crate_unicode-width/default__ge_0.0.0_with_crate_unicode-width/default__lt_1.0.0~"

URI_aarch64_rust-unicode-width+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width+no_std-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-width+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-width+no_std-devel}"
SRC_URI[aarch64_rust-unicode-width+no_std-devel.sha256sum] = "a66d0c35307d49e654e892ac97ed1b9ddd933d06d52c359d148ba5ff14349e3c"

URI_aarch64_rust-unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-width-devel}"
SRC_URI[aarch64_rust-unicode-width-devel.sha256sum] = "05b5b5039702782140f971d2ca70f1ec074b0623a867cbecb7e6baffbb90e86a"

RDEPENDS:rust-unicode-width+cjk-devel = " \
 cargo \
 rust-unicode-width-devel \
 "
RDEPENDS:rust-unicode-width+default-devel = " \
 cargo \
 rust-unicode-width+cjk-devel \
 rust-unicode-width-devel \
 "
RDEPENDS:rust-unicode-width+no_std-devel = " \
 cargo \
 rust-unicode-width-devel \
 "
RDEPENDS:rust-unicode-width-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_unicode-width/default__ge_0.0.0_with_crate_unicode-width/default__lt_1.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_unicode-width/default__ge_0.0.0_with_crate_unicode-width/default__lt_1.0.0~"
