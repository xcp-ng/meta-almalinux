# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-writeable"
PV = "0.6.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-writeable+alloc-devel \
 rust-writeable+default-devel \
 rust-writeable+either-devel \
 rust-writeable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-writeable-0.6.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2949dbc22f3688576e6d6b60a760c0d1ef9b788ec2bcdc778a209577e77252eb"

URI_x86_64_v2_rust-writeable+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+alloc-devel-0.6.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable+alloc-devel}"
SRC_URI[x86_64_v2_rust-writeable+alloc-devel.sha256sum] = "a4484f0ea243d8bc6b2fb67a46e92491bb4e90d4ad62a2d36208d95165c82efe"

URI_x86_64_v2_rust-writeable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+default-devel-0.6.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable+default-devel}"
SRC_URI[x86_64_v2_rust-writeable+default-devel.sha256sum] = "95bfbad194d2c4a57688b72a749bc0f0b3b2e5be70d95826eed8ea30a4df523d"

URI_x86_64_v2_rust-writeable+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+either-devel-0.6.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable+either-devel}"
SRC_URI[x86_64_v2_rust-writeable+either-devel.sha256sum] = "286a12d95046c1254ebca99c31163eb1f353e24f3d6ad1c5c8b3bd4f4253aa9a"

URI_x86_64_v2_rust-writeable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable-devel-0.6.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable-devel}"
SRC_URI[x86_64_v2_rust-writeable-devel.sha256sum] = "7e6464b850bdcf416014d384f487c1cf5973bdc586bbfcfb87369a00d0dc5609"

URI_aarch64_rust-writeable+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+alloc-devel-0.6.2-1.el10_1.noarch.rpm;name=aarch64_rust-writeable+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable+alloc-devel}"
SRC_URI[aarch64_rust-writeable+alloc-devel.sha256sum] = "683d9b3083b18bbf5c4cffd0cc36c281b0186b10151c95d7add7a0525240f631"

URI_aarch64_rust-writeable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+default-devel-0.6.2-1.el10_1.noarch.rpm;name=aarch64_rust-writeable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable+default-devel}"
SRC_URI[aarch64_rust-writeable+default-devel.sha256sum] = "5368dba5db876be1d14f7d4f2fb0483f5c2efb980df9fed7a3844e6c1c75d998"

URI_aarch64_rust-writeable+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+either-devel-0.6.2-1.el10_1.noarch.rpm;name=aarch64_rust-writeable+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable+either-devel}"
SRC_URI[aarch64_rust-writeable+either-devel.sha256sum] = "33b6b91d033f92613a753b8c68b44c4093447c22ceea5b21a3179d1862e94a23"

URI_aarch64_rust-writeable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable-devel-0.6.2-1.el10_1.noarch.rpm;name=aarch64_rust-writeable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable-devel}"
SRC_URI[aarch64_rust-writeable-devel.sha256sum] = "09e970b25d1c8980903a6c44923b0980cd98c6da1ddb96e90222b33879791439"

RDEPENDS:rust-writeable+alloc-devel = " \
 cargo \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable+default-devel = " \
 cargo \
 rust-writeable+alloc-devel \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable+either-devel = " \
 cargo \
 rust-either-devel \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable-devel = " \
 cargo \
 rust \
 "
