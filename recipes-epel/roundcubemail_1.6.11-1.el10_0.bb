# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "roundcubemail"
PV = "1.6.11"
PR = "1.el10_0"
PACKAGES = " \
 roundcubemail \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/roundcubemail-1.6.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b17d688b808b102586ac8dd452ca45d82a601c0af76ac6263bab73a23d77e124"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/roundcubemail-1.6.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_roundcubemail;unpack=0"
SRC_URI[x86_64_v2_roundcubemail.sha256sum] = "cd1269f9b9c1b13931382a975910af2c720745d78b69a224f65ac0c75cd2e1b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/roundcubemail-1.6.11-1.el10_0.noarch.rpm;name=aarch64_roundcubemail;unpack=0"
SRC_URI[aarch64_roundcubemail.sha256sum] = "647ba35c1d1cd27f6e91f5647344a47e0eacb6a7d9421d7bda1ed4b44e1ee706"

RDEPENDS:roundcubemail = " \
 bash \
 httpd-filesystem \
 mailcap \
 nginx-filesystem \
 php-common \
 php-fpm \
 php-gd \
 php-intl \
 php-ldap \
 php-mbstring \
 php-pdo \
 php-pecl-zip \
 php-process \
 php-xml \
 virtual/webserver \
 "
