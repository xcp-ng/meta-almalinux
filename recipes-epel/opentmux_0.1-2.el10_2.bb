# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opentmux"
PV = "0.1"
PR = "2.el10_2"
PACKAGES = " \
 opentmux \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/opentmux-0.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "02987ff9baab4b63f02da06ae7e9b41f97478c72d877e36c6c63d1e131a48293"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opentmux-0.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opentmux;unpack=0"
SRC_URI[x86_64_v2_opentmux.sha256sum] = "e4f0ca4f68c7f6bf370d86373dde39d488959d21e77b80dcb8ff70b7da5fe8e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opentmux-0.1-2.el10_2.aarch64.rpm;name=aarch64_opentmux;unpack=0"
SRC_URI[aarch64_opentmux.sha256sum] = "360ab8ad09e5034fcb30833ab17f71f7f4c47a7d8e838dbad5cb947c57d96d1b"

RDEPENDS:opentmux = " \
 bash \
 glibc \
 grep \
 libevent \
 libutempter \
 ncurses-libs \
 sed \
 systemd-libs \
 virtual/coreutils \
 "
