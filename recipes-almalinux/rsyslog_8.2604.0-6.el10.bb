# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rsyslog"
PV = "8.2604.0"
PR = "6.el10"
PACKAGES = " \
 rsyslog \
 rsyslog-crypto \
 rsyslog-doc \
 rsyslog-elasticsearch \
 rsyslog-gnutls \
 rsyslog-gssapi \
 rsyslog-kafka \
 rsyslog-mmaudit \
 rsyslog-mmfields \
 rsyslog-mmjsonparse \
 rsyslog-mmkubernetes \
 rsyslog-mmnormalize \
 rsyslog-mmsnmptrapd \
 rsyslog-mysql \
 rsyslog-omamqp1 \
 rsyslog-openssl \
 rsyslog-pgsql \
 rsyslog-relp \
 rsyslog-snmp \
 rsyslog-udpspoof \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rsyslog-8.2604.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "df51cb29aaa82d23604fc78755e6fcca71c9dc12c69ba6fcbc6d64edec087315"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog;unpack=0"
SRC_URI[x86_64_v2_rsyslog.sha256sum] = "c46e0aec6ef771e392ee446cf6ade74c9f7b84f4023738875c60f4dc716827be"
RPROVIDES:rsyslog:append:x86_64_v2 = " virtual/syslog"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-crypto-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-crypto;unpack=0"
SRC_URI[x86_64_v2_rsyslog-crypto.sha256sum] = "9b9fa92bf8b128f05cba56dee8bc87cc66b96275d6eb72ea1102e9479f49bff6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-doc-8.2604.0-6.el10.noarch.rpm;name=x86_64_v2_rsyslog-doc;unpack=0"
SRC_URI[x86_64_v2_rsyslog-doc.sha256sum] = "fd66d3e59d30eb7dd1ca3133cea1e6489bda22d9b60945e8f3279a9fc93e70c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-elasticsearch-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-elasticsearch;unpack=0"
SRC_URI[x86_64_v2_rsyslog-elasticsearch.sha256sum] = "76786f64d2cbb6a849112f21a60520551169980a3e800de464ac13325dcee5bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-gnutls-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-gnutls;unpack=0"
SRC_URI[x86_64_v2_rsyslog-gnutls.sha256sum] = "87d33d60367f167dc2927e8b4d54dca227025dbf6e88ea70b83a4e5faa90b2d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-gssapi-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-gssapi;unpack=0"
SRC_URI[x86_64_v2_rsyslog-gssapi.sha256sum] = "7577a2243bff72362bc3eb45ba01825c6405e99bcf02305b8c3f4eed2088481c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-kafka-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-kafka;unpack=0"
SRC_URI[x86_64_v2_rsyslog-kafka.sha256sum] = "a818e6aac01f127c41f63413a4c8c4e7d6321bb322e63c04fd3aa79e5a1fffb1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmaudit-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmaudit;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mmaudit.sha256sum] = "3102c35918fc4bd2ed3aa4c5d52fc180b8051873aec57944f8649e7679bcb1aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmfields-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmfields;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mmfields.sha256sum] = "4d1be32cef695e2788e1c69b9fa8f7d2dc8f53f070a755d65085de6239dea5e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmjsonparse-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmjsonparse;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mmjsonparse.sha256sum] = "d035fe0b1e6068b98137fd02459117e0e373bc00bf77edf797143368711b90bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmkubernetes-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmkubernetes;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mmkubernetes.sha256sum] = "06116be5ac1ff1f404a62384ed646faf17825e42da38408b2420b7f52cf9e707"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmnormalize-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmnormalize;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mmnormalize.sha256sum] = "daabfd73c73fc96f4e34edc08d84b243d907cbae3a0300b11fa5b8737915dd86"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmsnmptrapd-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmsnmptrapd;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mmsnmptrapd.sha256sum] = "6a9eae9008a070b99d3132b941efe1902240390d81a8ff901c345fd629304562"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mysql-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mysql;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mysql.sha256sum] = "2cd1344dba6895139dbebe616811135dcdecef67adc96dc946d1137e4ea2b353"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-omamqp1-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-omamqp1;unpack=0"
SRC_URI[x86_64_v2_rsyslog-omamqp1.sha256sum] = "950834bd708d37ab03cf76a4dc69c377a411367bd3ecd095fd07795f9914fcd4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-openssl-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-openssl;unpack=0"
SRC_URI[x86_64_v2_rsyslog-openssl.sha256sum] = "aa8596b6b7e4c75b900233a23545a7b4582e28a0cd83217c2236380d676fdcd0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-pgsql-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-pgsql;unpack=0"
SRC_URI[x86_64_v2_rsyslog-pgsql.sha256sum] = "d97eacfb92763e7d53075e96dd11b35eae819eb7ccd7960ca6cef45cec20d0d6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-relp-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-relp;unpack=0"
SRC_URI[x86_64_v2_rsyslog-relp.sha256sum] = "d09377a3a8c33129938ea58366244a483919ba43180e917fff92507a570bcf93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-snmp-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-snmp;unpack=0"
SRC_URI[x86_64_v2_rsyslog-snmp.sha256sum] = "1a0a6afb0f0525bf9f33670cbd8c7ba83d673b3f591a655ff51c5a6e070d847e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-udpspoof-8.2604.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-udpspoof;unpack=0"
SRC_URI[x86_64_v2_rsyslog-udpspoof.sha256sum] = "88fe9e5b72800e976ea1d13ab453b04fd34ca45fda087020c6ee892f8b5003ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog;unpack=0"
SRC_URI[aarch64_rsyslog.sha256sum] = "1cedcc02602c8132daa9b97c43ff18b67245e491d19ba6873b6f5b64d86dcd8a"
RPROVIDES:rsyslog:append:aarch64 = " virtual/syslog"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-crypto-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-crypto;unpack=0"
SRC_URI[aarch64_rsyslog-crypto.sha256sum] = "ae0af739b69ab7bca5f71e64afe06010af78fa0f53dbb349c8fe459594419ccc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-doc-8.2604.0-6.el10.noarch.rpm;name=aarch64_rsyslog-doc;unpack=0"
SRC_URI[aarch64_rsyslog-doc.sha256sum] = "fd66d3e59d30eb7dd1ca3133cea1e6489bda22d9b60945e8f3279a9fc93e70c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-elasticsearch-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-elasticsearch;unpack=0"
SRC_URI[aarch64_rsyslog-elasticsearch.sha256sum] = "65cca7570888f3eef4805521b973d640db00ff7a7da28fe43b3c63af8bb062e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-gnutls-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-gnutls;unpack=0"
SRC_URI[aarch64_rsyslog-gnutls.sha256sum] = "dea815bcfe7156416f7e041535e64f44c326cb99317fbacc50e6771a2f6e1bcc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-gssapi-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-gssapi;unpack=0"
SRC_URI[aarch64_rsyslog-gssapi.sha256sum] = "887ce35c610032a17135df74dc08741faa639d3fa65f5ad04623504b6f96bde5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-kafka-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-kafka;unpack=0"
SRC_URI[aarch64_rsyslog-kafka.sha256sum] = "b89c5480baf2ac36ee0b5ecdce599e89c3a82c617c0699d9314acdd21d1fd518"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmaudit-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-mmaudit;unpack=0"
SRC_URI[aarch64_rsyslog-mmaudit.sha256sum] = "d436fdd31cd45a1dc5d6c0a52e5847589edcb0fa4914f7de979042df48a7fc22"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmfields-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-mmfields;unpack=0"
SRC_URI[aarch64_rsyslog-mmfields.sha256sum] = "10f8ea85cb56eeed380d939d194b8732cea4c85e8e17b337fcef6fa97e396a76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmjsonparse-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-mmjsonparse;unpack=0"
SRC_URI[aarch64_rsyslog-mmjsonparse.sha256sum] = "cfa06c09d608751e9bb0f83d4d4cb84f58eea38e8e15f8a2d87fa826b183f227"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmkubernetes-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-mmkubernetes;unpack=0"
SRC_URI[aarch64_rsyslog-mmkubernetes.sha256sum] = "afaf85c8d046533ac6d9dafcd51e158a088651da4cbd8002a724972449cc3e80"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmnormalize-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-mmnormalize;unpack=0"
SRC_URI[aarch64_rsyslog-mmnormalize.sha256sum] = "9d86c4c3faef521e96cd1f70006f88e009afbcc63ec6e2799d5846f37d91274d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmsnmptrapd-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-mmsnmptrapd;unpack=0"
SRC_URI[aarch64_rsyslog-mmsnmptrapd.sha256sum] = "4f6dc6340e1ddce5327279553e44ff6796c005d6b0bfb08324f262e6acc35dd7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mysql-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-mysql;unpack=0"
SRC_URI[aarch64_rsyslog-mysql.sha256sum] = "a879badfa6fbb83d1209337eee3fb656b46af1aa0e49a2c87610f2e10019d1a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-omamqp1-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-omamqp1;unpack=0"
SRC_URI[aarch64_rsyslog-omamqp1.sha256sum] = "5edaf94a48233ffb30d33971034cbaa00d58ee1de3e0f1de516fb2df5db6f053"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-openssl-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-openssl;unpack=0"
SRC_URI[aarch64_rsyslog-openssl.sha256sum] = "aebaab5d51bc2722183f58d72f6293c33bfcdd2142eaf73030401e3bd6a305b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-pgsql-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-pgsql;unpack=0"
SRC_URI[aarch64_rsyslog-pgsql.sha256sum] = "67ef77e5e09f3f6c63a7fa970f904e389712f1208a19e222944f785200539b41"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-relp-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-relp;unpack=0"
SRC_URI[aarch64_rsyslog-relp.sha256sum] = "d41318c7b413ea3776e9ffdf4cc27577e75c9c81833464cde1964411d36ac57b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-snmp-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-snmp;unpack=0"
SRC_URI[aarch64_rsyslog-snmp.sha256sum] = "40859eca2a57abfb83d2b55291d714afe47dd5a6e6e461c71c1ecd1a2e664c0d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-udpspoof-8.2604.0-6.el10.aarch64.rpm;name=aarch64_rsyslog-udpspoof;unpack=0"
SRC_URI[aarch64_rsyslog-udpspoof.sha256sum] = "546dd8a3a4fc80474f0b2d61c24ec1c244b3ab1a405622b560fe0dea30d4bf9d"

RDEPENDS:rsyslog = " \
 bash \
 glibc \
 libcap-ng \
 libestr \
 libfastjson \
 libgcc \
 libuuid \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:rsyslog-crypto = " \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-doc = " \
 "
RDEPENDS:rsyslog-elasticsearch = " \
 glibc \
 libcap-ng \
 rsyslog \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:rsyslog-gnutls = " \
 glibc \
 gnutls \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-gssapi = " \
 glibc \
 krb5-libs \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-kafka = " \
 glibc \
 libcap-ng \
 librdkafka \
 rsyslog \
 "
RDEPENDS:rsyslog-mmaudit = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mmfields = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mmjsonparse = " \
 glibc \
 libcap-ng \
 libfastjson \
 rsyslog \
 "
RDEPENDS:rsyslog-mmkubernetes = " \
 glibc \
 libcap-ng \
 libfastjson \
 liblognorm \
 rsyslog \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:rsyslog-mmnormalize = " \
 glibc \
 libcap-ng \
 libfastjson \
 liblognorm \
 rsyslog \
 "
RDEPENDS:rsyslog-mmsnmptrapd = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mysql = " \
 glibc \
 mariadb-connector-c \
 rsyslog \
 "
RDEPENDS:rsyslog-omamqp1 = " \
 cyrus-sasl-lib \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-openssl = " \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-pgsql = " \
 glibc \
 libcap-ng \
 libpq \
 rsyslog \
 "
RDEPENDS:rsyslog-relp = " \
 glibc \
 libcap-ng \
 librelp \
 rsyslog \
 "
RDEPENDS:rsyslog-snmp = " \
 glibc \
 libcap-ng \
 net-snmp-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-udpspoof = " \
 glibc \
 libcap-ng \
 libnet \
 rsyslog \
 "
