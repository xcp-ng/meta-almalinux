# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-adblock"
PV = "0.9.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-adblock+addr-devel \
 rust-adblock+content-blocking-devel \
 rust-adblock+default-devel \
 rust-adblock+embedded-domain-resolver-devel \
 rust-adblock+full-regex-handling-devel \
 rust-adblock+lifeguard-devel \
 rust-adblock+object-pooling-devel \
 rust-adblock+regex-debug-info-devel \
 rust-adblock+resource-assembler-devel \
 rust-adblock+unsync-regex-caching-devel \
 rust-adblock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-adblock-0.9.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10f66d1da4fbb23dc2d86344dd3f6f05f3ac93f87b393f22ebb2e8a3568771a6"

URI_x86_64_v2_rust-adblock+addr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+addr-devel-0.9.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+addr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+addr-devel}"
SRC_URI[x86_64_v2_rust-adblock+addr-devel.sha256sum] = "36181a6f69778709086576b9655bcbfe34811dc3cbe90956ac7bff895328ed74"

URI_x86_64_v2_rust-adblock+content-blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+content-blocking-devel-0.9.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+content-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+content-blocking-devel}"
SRC_URI[x86_64_v2_rust-adblock+content-blocking-devel.sha256sum] = "9f975dfdfbf0fc5791741c487aa29fc0cf3ccaa2b2afa132db3aa02d22d42e14"

URI_x86_64_v2_rust-adblock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+default-devel-0.9.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+default-devel}"
SRC_URI[x86_64_v2_rust-adblock+default-devel.sha256sum] = "fc74d8c5dcc7f18eefe8d356ac4433103ebf5a224f5e12ab5068267e348adb24"

URI_x86_64_v2_rust-adblock+embedded-domain-resolver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+embedded-domain-resolver-devel-0.9.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+embedded-domain-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+embedded-domain-resolver-devel}"
SRC_URI[x86_64_v2_rust-adblock+embedded-domain-resolver-devel.sha256sum] = "e9a8a00dbfa8e3a78f3abe4f31337497e3e00e05302f2c6c7855eb832f4f8878"

URI_x86_64_v2_rust-adblock+full-regex-handling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+full-regex-handling-devel-0.9.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+full-regex-handling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+full-regex-handling-devel}"
SRC_URI[x86_64_v2_rust-adblock+full-regex-handling-devel.sha256sum] = "7cd440278ef5c7ae769fa8ce0a948b8cc194f338aef48fe772ec2dbbc2e459d2"

URI_x86_64_v2_rust-adblock+lifeguard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+lifeguard-devel-0.9.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+lifeguard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+lifeguard-devel}"
SRC_URI[x86_64_v2_rust-adblock+lifeguard-devel.sha256sum] = "54aff801f3a999f2a080969559d4349fb7db19190121bd2b477e8df959816b61"

URI_x86_64_v2_rust-adblock+object-pooling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+object-pooling-devel-0.9.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+object-pooling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+object-pooling-devel}"
SRC_URI[x86_64_v2_rust-adblock+object-pooling-devel.sha256sum] = "9cba8e8d65e9e764f1eef914d0bef71057806d8c2f905cd4b2e4bf6a85ca5041"

URI_x86_64_v2_rust-adblock+regex-debug-info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+regex-debug-info-devel-0.9.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+regex-debug-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+regex-debug-info-devel}"
SRC_URI[x86_64_v2_rust-adblock+regex-debug-info-devel.sha256sum] = "2be29a6b14cc15325347bf17a7d03b391c76cd8753ebc776cb7e5afaca42476a"

URI_x86_64_v2_rust-adblock+resource-assembler-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+resource-assembler-devel-0.9.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+resource-assembler-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+resource-assembler-devel}"
SRC_URI[x86_64_v2_rust-adblock+resource-assembler-devel.sha256sum] = "f68ae1dd2314a8afa42a72fec70774c1bea6a8c41b459ddd30cfd31c41938955"

URI_x86_64_v2_rust-adblock+unsync-regex-caching-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+unsync-regex-caching-devel-0.9.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+unsync-regex-caching-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+unsync-regex-caching-devel}"
SRC_URI[x86_64_v2_rust-adblock+unsync-regex-caching-devel.sha256sum] = "1bc64ef68742a7f610750bbc1668c37d96b4af8aede6aee3f0e50386ded7f0e7"

URI_x86_64_v2_rust-adblock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock-devel-0.9.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock-devel}"
SRC_URI[x86_64_v2_rust-adblock-devel.sha256sum] = "799484990c8292e719ee5405dce59ab1bf0f0ef0097503ff6da64190a9f98d6b"

URI_aarch64_rust-adblock+addr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+addr-devel-0.9.8-1.el10_1.noarch.rpm;name=aarch64_rust-adblock+addr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+addr-devel}"
SRC_URI[aarch64_rust-adblock+addr-devel.sha256sum] = "52aa71a0032dfb72b1634ad2b7e8ce891a2c6eb8419b3c545590159fa465becb"

URI_aarch64_rust-adblock+content-blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+content-blocking-devel-0.9.8-1.el10_1.noarch.rpm;name=aarch64_rust-adblock+content-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+content-blocking-devel}"
SRC_URI[aarch64_rust-adblock+content-blocking-devel.sha256sum] = "d38af109a629c91031a4397a3141776bbe6171c25939dad5ca4d9d65b309fde3"

URI_aarch64_rust-adblock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+default-devel-0.9.8-1.el10_1.noarch.rpm;name=aarch64_rust-adblock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+default-devel}"
SRC_URI[aarch64_rust-adblock+default-devel.sha256sum] = "988ac92f25ed7f9a75e45510df9d080c5c1cdaada63a5dd188a22e1242b21010"

URI_aarch64_rust-adblock+embedded-domain-resolver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+embedded-domain-resolver-devel-0.9.8-1.el10_1.noarch.rpm;name=aarch64_rust-adblock+embedded-domain-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+embedded-domain-resolver-devel}"
SRC_URI[aarch64_rust-adblock+embedded-domain-resolver-devel.sha256sum] = "9a1ea3ae2fa0c3feb22fde837c170cbf074eef8b51e7eef77c362811878c9b58"

URI_aarch64_rust-adblock+full-regex-handling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+full-regex-handling-devel-0.9.8-1.el10_1.noarch.rpm;name=aarch64_rust-adblock+full-regex-handling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+full-regex-handling-devel}"
SRC_URI[aarch64_rust-adblock+full-regex-handling-devel.sha256sum] = "a3bc8cb430d0dd6af204b84d8070ef8f6396ae139c54363a97ed23ce55469aa1"

URI_aarch64_rust-adblock+lifeguard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+lifeguard-devel-0.9.8-1.el10_1.noarch.rpm;name=aarch64_rust-adblock+lifeguard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+lifeguard-devel}"
SRC_URI[aarch64_rust-adblock+lifeguard-devel.sha256sum] = "1fea0a7655d69ac49a055459fb82cb6aa05449917a287e1f7bb367384d9a0d70"

URI_aarch64_rust-adblock+object-pooling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+object-pooling-devel-0.9.8-1.el10_1.noarch.rpm;name=aarch64_rust-adblock+object-pooling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+object-pooling-devel}"
SRC_URI[aarch64_rust-adblock+object-pooling-devel.sha256sum] = "0bf263c6d1697d2a2735cdc0a75ff9500568aaed942060647a25cb1fa2992ff7"

URI_aarch64_rust-adblock+regex-debug-info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+regex-debug-info-devel-0.9.8-1.el10_1.noarch.rpm;name=aarch64_rust-adblock+regex-debug-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+regex-debug-info-devel}"
SRC_URI[aarch64_rust-adblock+regex-debug-info-devel.sha256sum] = "249987f8348b0d3a2fc0ffbac486f01dda471b1276ae61676eaab494adc3f993"

URI_aarch64_rust-adblock+resource-assembler-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+resource-assembler-devel-0.9.8-1.el10_1.noarch.rpm;name=aarch64_rust-adblock+resource-assembler-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+resource-assembler-devel}"
SRC_URI[aarch64_rust-adblock+resource-assembler-devel.sha256sum] = "4be93a46d8e697c06fea2331f80d1558288277d447f8353570a91e0421cbfe13"

URI_aarch64_rust-adblock+unsync-regex-caching-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+unsync-regex-caching-devel-0.9.8-1.el10_1.noarch.rpm;name=aarch64_rust-adblock+unsync-regex-caching-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+unsync-regex-caching-devel}"
SRC_URI[aarch64_rust-adblock+unsync-regex-caching-devel.sha256sum] = "53413351f7255280574274743024a3da940842df3cd2996644a4a60b4d9d1fb2"

URI_aarch64_rust-adblock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock-devel-0.9.8-1.el10_1.noarch.rpm;name=aarch64_rust-adblock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock-devel}"
SRC_URI[aarch64_rust-adblock-devel.sha256sum] = "dcc8313f3cf5caec1879c088483df7e432fd3d8b232e51d315d1b90ad0bc821a"

RDEPENDS:rust-adblock+addr-devel = " \
 cargo \
 rust-adblock-devel \
 rust-addr+psl-devel \
 rust-addr-devel \
 "
RDEPENDS:rust-adblock+content-blocking-devel = " \
 cargo \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+default-devel = " \
 cargo \
 rust-adblock+embedded-domain-resolver-devel \
 rust-adblock+full-regex-handling-devel \
 rust-adblock+object-pooling-devel \
 rust-adblock+unsync-regex-caching-devel \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+embedded-domain-resolver-devel = " \
 cargo \
 rust-adblock+addr-devel \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+full-regex-handling-devel = " \
 cargo \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+lifeguard-devel = " \
 cargo \
 rust-adblock-devel \
 rust-lifeguard+default-devel \
 "
RDEPENDS:rust-adblock+object-pooling-devel = " \
 cargo \
 rust-adblock+lifeguard-devel \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+regex-debug-info-devel = " \
 cargo \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+resource-assembler-devel = " \
 cargo \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+unsync-regex-caching-devel = " \
 cargo \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-bitflags1+default-devel \
 rust-idna+default-devel \
 rust-itertools0.13+default-devel \
 rust-memchr+default-devel \
 rust-once_cell+default-devel \
 rust-percent-encoding+default-devel \
 rust-regex+default-devel \
 rust-rmp-serde+default-devel \
 rust-seahash3+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_json+default-devel \
 rust-thiserror1+default-devel \
 rust-url+default-devel \
 "
