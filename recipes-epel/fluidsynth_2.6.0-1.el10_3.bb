# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fluidsynth"
PV = "2.6.0"
PR = "1.el10_3"
PACKAGES = " \
 fluidsynth \
 fluidsynth-devel \
 fluidsynth-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fluidsynth-2.6.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7ce5b659b54ca59804dc97aa306b219e931b2328b737b42d3f1d46570496efb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluidsynth-2.6.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluidsynth;unpack=0"
SRC_URI[x86_64_v2_fluidsynth.sha256sum] = "ce0549de50026c2779ccf7f88c689d920c0c094dd6e1080d79474a97b18d0fbd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluidsynth-devel-2.6.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluidsynth-devel;unpack=0"
SRC_URI[x86_64_v2_fluidsynth-devel.sha256sum] = "b2475a99d5b34eceeb739246803dc020786d5f289f9d5533aaf66f66e19d265b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluidsynth-libs-2.6.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluidsynth-libs;unpack=0"
SRC_URI[x86_64_v2_fluidsynth-libs.sha256sum] = "c98064986eafcb715dbc57d74909c551277f438ba86a4776f030cba7c5ac625e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fluidsynth-2.6.0-1.el10_3.aarch64.rpm;name=aarch64_fluidsynth;unpack=0"
SRC_URI[aarch64_fluidsynth.sha256sum] = "05446971bba6343d20fb6fc729064d140513e45420c1b1b92fb15938225b64c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fluidsynth-devel-2.6.0-1.el10_3.aarch64.rpm;name=aarch64_fluidsynth-devel;unpack=0"
SRC_URI[aarch64_fluidsynth-devel.sha256sum] = "dc28b84f379dca3de7f7fa371c779a443c7b84a7bb3a9945291626dd2ec9e2c0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fluidsynth-libs-2.6.0-1.el10_3.aarch64.rpm;name=aarch64_fluidsynth-libs;unpack=0"
SRC_URI[aarch64_fluidsynth-libs.sha256sum] = "ae59208218fc83ab2ba210388058ef0dfd9a929c273ec56d62319e4c3b043a72"

RDEPENDS:fluidsynth = " \
 fluidsynth-libs \
 glibc \
 libstdc++ \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:fluidsynth-devel = " \
 alsa-lib-devel \
 cmake-filesystem \
 dbus-devel \
 fluidsynth \
 fluidsynth-libs \
 libsndfile-devel \
 pipewire-devel \
 pipewire-jack-audio-connection-kit-devel \
 pkgconf-pkg-config \
 pulseaudio-libs-devel \
 readline-devel \
 systemd-devel \
 "
RDEPENDS:fluidsynth-libs = " \
 alsa-lib \
 dbus-libs \
 glibc \
 libgcc \
 libgomp \
 libsndfile \
 libstdc++ \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pulseaudio-libs \
 readline \
 "
