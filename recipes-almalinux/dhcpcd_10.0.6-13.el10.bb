# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dhcpcd"
PV = "10.0.6"
PR = "13.el10"
PACKAGES = " \
 dhcpcd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dhcpcd-10.0.6-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "19923363f857f3c36f1d58cd8599085550f6aee537a06d02368eed3de6e4a14d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dhcpcd-10.0.6-13.el10.x86_64_v2.rpm;name=x86_64_v2_dhcpcd;unpack=0"
SRC_URI[x86_64_v2_dhcpcd.sha256sum] = "d24ed7426a5bac7b99188b5cb586dcbe59e290da9309dde0f9108794d734e060"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dhcpcd-10.0.6-13.el10.aarch64.rpm;name=aarch64_dhcpcd;unpack=0"
SRC_URI[aarch64_dhcpcd.sha256sum] = "60cc7e28e17dc2546707565f7deb62f9e6d9b8252815f9a74a65a7cab5f5e45b"

RDEPENDS:dhcpcd = " \
 bash \
 glibc \
 shadow-utils \
 systemd \
 systemd-libs \
 "
