# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtpositioning"
PV = "6.9.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtpositioning \
 qt6-qtpositioning-devel \
 qt6-qtpositioning-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtpositioning-6.9.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5af7c8de5c768490c32af76f5cf59baa70132a71c14bb34e5879dc48b721eab0"

URI_x86_64_v2_qt6-qtpositioning = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtpositioning-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpositioning;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpositioning}"
SRC_URI[x86_64_v2_qt6-qtpositioning.sha256sum] = "642823696a00156f62007c5c05b664fc49af164dd84c5a3cf589e4ac5b677f71"

URI_x86_64_v2_qt6-qtpositioning-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtpositioning-devel-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpositioning-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpositioning-devel}"
SRC_URI[x86_64_v2_qt6-qtpositioning-devel.sha256sum] = "c7fc5b600fb3e2b987bab97c1ca4e02928d6f26ca14d1c22656d2b5996d53ae5"

URI_x86_64_v2_qt6-qtpositioning-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtpositioning-examples-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpositioning-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpositioning-examples}"
SRC_URI[x86_64_v2_qt6-qtpositioning-examples.sha256sum] = "5e64fdf9bfda16adae40069a24dbf01267e0de6f8f2ac06bd8e5ae490fbbf399"

URI_aarch64_qt6-qtpositioning = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtpositioning-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtpositioning;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpositioning}"
SRC_URI[aarch64_qt6-qtpositioning.sha256sum] = "9d5a962d0fe699cf2de7098ae1f8739f1a10bfe218dc87dcc0355f8a5bfc1098"

URI_aarch64_qt6-qtpositioning-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtpositioning-devel-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtpositioning-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpositioning-devel}"
SRC_URI[aarch64_qt6-qtpositioning-devel.sha256sum] = "3d95a0d1e90472ae95ef69d70bf94c2ac35859fb3a793e8665e8e53b85ac8bf2"

URI_aarch64_qt6-qtpositioning-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtpositioning-examples-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtpositioning-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpositioning-examples}"
SRC_URI[aarch64_qt6-qtpositioning-examples.sha256sum] = "3311823f539220b4ce3aa7803113daafea0845ffc3cf9d801c44df70dbaa4507"

RDEPENDS:qt6-qtpositioning = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 qt6-qtserialport \
 "
RDEPENDS:qt6-qtpositioning-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtpositioning \
 qt6-qtpositioning-devel \
 "
RDEPENDS:qt6-qtpositioning-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 "
