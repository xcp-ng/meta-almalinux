# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strip-ansi-escapes"
PV = "0.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-strip-ansi-escapes+default-devel \
 rust-strip-ansi-escapes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strip-ansi-escapes-0.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4c29e0d233548e06ae138bc6d37a8d4f36d02918b22f0a83a5c7a86240feb60"

URI_x86_64_v2_rust-strip-ansi-escapes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strip-ansi-escapes+default-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strip-ansi-escapes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strip-ansi-escapes+default-devel}"
SRC_URI[x86_64_v2_rust-strip-ansi-escapes+default-devel.sha256sum] = "55be58c6950a96bd4f61b5fa45b046e8a69eacde70d84f8f96311bcb79a34b36"

URI_x86_64_v2_rust-strip-ansi-escapes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strip-ansi-escapes-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strip-ansi-escapes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strip-ansi-escapes-devel}"
SRC_URI[x86_64_v2_rust-strip-ansi-escapes-devel.sha256sum] = "883af50f52f21da96e15eec26c04a08d20b3a35367e27ae9b82213567d6f4a7c"

URI_aarch64_rust-strip-ansi-escapes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strip-ansi-escapes+default-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-strip-ansi-escapes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strip-ansi-escapes+default-devel}"
SRC_URI[aarch64_rust-strip-ansi-escapes+default-devel.sha256sum] = "3bc7daae87b94996667750123c1a123b6567d1f167460898aef735eab7890cce"

URI_aarch64_rust-strip-ansi-escapes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strip-ansi-escapes-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-strip-ansi-escapes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strip-ansi-escapes-devel}"
SRC_URI[aarch64_rust-strip-ansi-escapes-devel.sha256sum] = "e08b4616be531f2926a6d3f60c90762a28f31652663791552ceeceef61de513e"

RDEPENDS:rust-strip-ansi-escapes+default-devel = " \
 cargo \
 rust-strip-ansi-escapes-devel \
 "
RDEPENDS:rust-strip-ansi-escapes-devel = " \
 cargo \
 rust-vte-devel \
 "
