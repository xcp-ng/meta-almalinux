# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-compact_str"
PV = "0.10.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-compact_str+arbitrary-devel \
 rust-compact_str+bytes-devel \
 rust-compact_str+default-devel \
 rust-compact_str+proptest-devel \
 rust-compact_str+quickcheck-devel \
 rust-compact_str+rkyv-devel \
 rust-compact_str+schemars-devel \
 rust-compact_str+serde-devel \
 rust-compact_str+smallvec-devel \
 rust-compact_str+std-devel \
 rust-compact_str+zeroize-devel \
 rust-compact_str-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-compact_str-0.10.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bc8995b93208cd778134593fad30de3d47e3f74529287ce40e3bf8a51ec4ca4"

URI_x86_64_v2_rust-compact_str+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+arbitrary-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-compact_str+arbitrary-devel.sha256sum] = "9b21e7f066f833ad854a54ede7684a2e1ac073c70ec9db374f0437bb2e020521"

URI_x86_64_v2_rust-compact_str+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+bytes-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+bytes-devel}"
SRC_URI[x86_64_v2_rust-compact_str+bytes-devel.sha256sum] = "d67a1f69024c67389690a1c1ece8542c87b56f0496249aa942262f820cc90cc4"

URI_x86_64_v2_rust-compact_str+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+default-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+default-devel}"
SRC_URI[x86_64_v2_rust-compact_str+default-devel.sha256sum] = "9afcb8a5eef68bbe3eb63fda9bf4ccfa8af4303b3ad7bec682592083f3304a02"

URI_x86_64_v2_rust-compact_str+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+proptest-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+proptest-devel}"
SRC_URI[x86_64_v2_rust-compact_str+proptest-devel.sha256sum] = "eab5670a657767d1a442a2169ad9408b0867c9899bbd2fe1c48c1468da4ab9a8"

URI_x86_64_v2_rust-compact_str+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+quickcheck-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-compact_str+quickcheck-devel.sha256sum] = "63c11a5232c5f57fa33702b3ea452b4e746b1ddb154c49e04adec8c1100461c7"

URI_x86_64_v2_rust-compact_str+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+rkyv-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+rkyv-devel}"
SRC_URI[x86_64_v2_rust-compact_str+rkyv-devel.sha256sum] = "5fcf86b6f17537977f5fba112686e768b9e8dfc378adbe1d4338b8f4c0c358da"

URI_x86_64_v2_rust-compact_str+schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+schemars-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+schemars-devel}"
SRC_URI[x86_64_v2_rust-compact_str+schemars-devel.sha256sum] = "e3fe16b54a5c71fc2c3750bbb9a931934befd51e61765d7aed9646e5aa28b4ca"

URI_x86_64_v2_rust-compact_str+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+serde-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+serde-devel}"
SRC_URI[x86_64_v2_rust-compact_str+serde-devel.sha256sum] = "2103fe9cb5075cf4281ea4da5461cca637ec1bd97f5c766569e1ec6a499d97b6"

URI_x86_64_v2_rust-compact_str+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+smallvec-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+smallvec-devel}"
SRC_URI[x86_64_v2_rust-compact_str+smallvec-devel.sha256sum] = "12255e8ce42ac500b1f048ebc4e673c69bb3bac4377d1287377ae2fc7309705c"

URI_x86_64_v2_rust-compact_str+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+std-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+std-devel}"
SRC_URI[x86_64_v2_rust-compact_str+std-devel.sha256sum] = "a00027ecd1b2dcb35af3626351e63277726fbb9f87cb9126a1b89cbebfce5fcb"

URI_x86_64_v2_rust-compact_str+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+zeroize-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+zeroize-devel}"
SRC_URI[x86_64_v2_rust-compact_str+zeroize-devel.sha256sum] = "553e0bb9c8130e66ea6aff855204609c14092de85cd3fc7418adcd1400451b75"

URI_x86_64_v2_rust-compact_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str-devel}"
SRC_URI[x86_64_v2_rust-compact_str-devel.sha256sum] = "eba9d5877658dce9a5a664f598d5270a90bd10939c3bc1f03501cdf77b0587dd"

URI_aarch64_rust-compact_str+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+arbitrary-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+arbitrary-devel}"
SRC_URI[aarch64_rust-compact_str+arbitrary-devel.sha256sum] = "5773958b930fdc0ca5e64c7a14924e48915e9aa8b27fcd59b43e822efaa61e85"

URI_aarch64_rust-compact_str+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+bytes-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+bytes-devel}"
SRC_URI[aarch64_rust-compact_str+bytes-devel.sha256sum] = "dd07c565930aa4c7deb2a258f41c25fa922c4aafb364acb4bfff7420e3e56ad7"

URI_aarch64_rust-compact_str+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+default-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+default-devel}"
SRC_URI[aarch64_rust-compact_str+default-devel.sha256sum] = "ad2bb90be0aac68375d7adc602b66360e4aa948fd9114a0ac4d5fba0f6e60045"

URI_aarch64_rust-compact_str+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+proptest-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+proptest-devel}"
SRC_URI[aarch64_rust-compact_str+proptest-devel.sha256sum] = "d2d16a5d7e65f3ab91800d5da33fb3c0ebb264a9a073e0891d89c5b4cf49e919"

URI_aarch64_rust-compact_str+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+quickcheck-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+quickcheck-devel}"
SRC_URI[aarch64_rust-compact_str+quickcheck-devel.sha256sum] = "f34dde6e9cd13f1808b3329a6c62760b09f60a44be09eae3985364fec175ea88"

URI_aarch64_rust-compact_str+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+rkyv-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+rkyv-devel}"
SRC_URI[aarch64_rust-compact_str+rkyv-devel.sha256sum] = "b0a832191bc09a1f2a69f3ebe4caecacacb53979f03ac489556424573f6384dc"

URI_aarch64_rust-compact_str+schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+schemars-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+schemars-devel}"
SRC_URI[aarch64_rust-compact_str+schemars-devel.sha256sum] = "e344d640048975476dd6c4cd7e6e2de1fb9c66ca1da3d711b3206d05bacdf369"

URI_aarch64_rust-compact_str+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+serde-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+serde-devel}"
SRC_URI[aarch64_rust-compact_str+serde-devel.sha256sum] = "a85c004687027dc364b011c12bcb0ed8f1608ba05ba1b0205069c23590c11e60"

URI_aarch64_rust-compact_str+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+smallvec-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+smallvec-devel}"
SRC_URI[aarch64_rust-compact_str+smallvec-devel.sha256sum] = "cf11f6e418be3c9ac54f67e8c0af1ad5ac08aa818c897d1af681e8e2a239768f"

URI_aarch64_rust-compact_str+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+std-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+std-devel}"
SRC_URI[aarch64_rust-compact_str+std-devel.sha256sum] = "5601356cb3ac6c53530f8598356ddd996d055c05051bf04e59d00f780ec7adc2"

URI_aarch64_rust-compact_str+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+zeroize-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+zeroize-devel}"
SRC_URI[aarch64_rust-compact_str+zeroize-devel.sha256sum] = "d8159b006b4ac4bbed9942ac49ca58161f1e86b8fd735d2a5d372a3b7e3ebfe0"

URI_aarch64_rust-compact_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str-devel}"
SRC_URI[aarch64_rust-compact_str-devel.sha256sum] = "13a8fe5ba59bf29bbe6ace663c0385784fdca1157449b29825b657921b5c91ed"

RDEPENDS:rust-compact_str+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+default-devel = " \
 cargo \
 rust-compact_str+std-devel \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+proptest-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-compact_str+quickcheck-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-compact_str+rkyv-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-compact_str+schemars-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-compact_str+serde-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-compact_str+smallvec-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 "
RDEPENDS:rust-compact_str+std-devel = " \
 cargo \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+zeroize-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-compact_str-devel = " \
 cargo \
 rust \
 rust-castaway+alloc-devel \
 rust-castaway-devel \
 rust-cfg-if+default-devel \
 rust-itoa+default-devel \
 rust-static_assertions+default-devel \
 rust-zmij+default-devel \
 "
