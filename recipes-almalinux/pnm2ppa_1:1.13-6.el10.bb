# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pnm2ppa"
PE = "1"
PV = "1.13"
PR = "6.el10"
PACKAGES = " \
 pnm2ppa \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pnm2ppa-1.13-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c05a08b1997cd8708f46ab19351f38dcbf1f0cb68be3631c0542f3d88d22d1bf"

URI_x86_64_v2_pnm2ppa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pnm2ppa-1.13-6.el10.x86_64_v2.rpm;name=x86_64_v2_pnm2ppa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pnm2ppa}"
SRC_URI[x86_64_v2_pnm2ppa.sha256sum] = "40faea3932983a9155ac372ffa1f0e138f2e2140a57d44d335aaf561f85ccb05"

URI_aarch64_pnm2ppa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pnm2ppa-1.13-6.el10.aarch64.rpm;name=aarch64_pnm2ppa;unpack=0"
SRC_URI:append = " ${URI_aarch64_pnm2ppa}"
SRC_URI[aarch64_pnm2ppa.sha256sum] = "b5d503a18984e050ed5ab53663f4c50cf2504517142563543fda0b46e392a096"

RDEPENDS:pnm2ppa = " \
 bash \
 foomatic \
 glibc \
 "
