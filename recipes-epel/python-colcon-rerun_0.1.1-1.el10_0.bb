# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-rerun"
PV = "0.1.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-rerun \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-rerun-0.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54b7fd8142ad0908670f2461e601c718a4077324d346f0fea5d037ddd1823990"

URI_x86_64_v2_python3-colcon-rerun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-rerun-0.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-rerun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-rerun}"
SRC_URI[x86_64_v2_python3-colcon-rerun.sha256sum] = "3a579d595da47fa4400da0b1b4de72e3c5ec3b94882de11ddab9116e800b8cd3"

URI_aarch64_python3-colcon-rerun = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-rerun-0.1.1-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-rerun;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-rerun}"
SRC_URI[aarch64_python3-colcon-rerun.sha256sum] = "1b6959cc8f93b85073cf9d12d18a3a38bcfe45253607908795ad008a1e769a93"

RDEPENDS:python3-colcon-rerun = " \
 python3 \
 python3-colcon-core \
 python3-filelock \
 python3-pyyaml \
 "
