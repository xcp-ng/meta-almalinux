# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-path-dedot"
PV = "4.0.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-path-dedot+default-devel \
 rust-path-dedot+fixed_workdir-devel \
 rust-path-dedot-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-path-dedot-4.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "960be8ff47a7b1f96d8e7338335efdc9346b2d614c7ee4a214b6d4a33c5359ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-dedot+default-devel-4.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-dedot+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-path-dedot+default-devel.sha256sum] = "a9a01a3cc3e9aa13088072a6c1c221fb346ab0afd615e31ab3f66ada167486fc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-dedot+fixed_workdir-devel-4.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-dedot+fixed_workdir-devel;unpack=0"
SRC_URI[x86_64_v2_rust-path-dedot+fixed_workdir-devel.sha256sum] = "8762f9d4e999490660b30260af7e1800aeb52f6076a1d7edb8019d0e3a47086d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-dedot-devel-4.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-dedot-devel;unpack=0"
SRC_URI[x86_64_v2_rust-path-dedot-devel.sha256sum] = "93133fccd771298c698a481d13f1c715b603806631f03126669cad098ac64e7a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-path-dedot+default-devel-4.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-path-dedot+default-devel;unpack=0"
SRC_URI[aarch64_rust-path-dedot+default-devel.sha256sum] = "c5a4240c09f03d1b33249ac6ce505c0759712d47aa95a1b47c745b8d2b33bb29"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-path-dedot+fixed_workdir-devel-4.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-path-dedot+fixed_workdir-devel;unpack=0"
SRC_URI[aarch64_rust-path-dedot+fixed_workdir-devel.sha256sum] = "6858cfd943e41d5baa393b54de512c2f6ee6aa7c4bda7e65148670f91f004017"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-path-dedot-devel-4.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-path-dedot-devel;unpack=0"
SRC_URI[aarch64_rust-path-dedot-devel.sha256sum] = "94eae1d30377e78db302bf7e6ae39e63c2df013d399fb4ec5c8b99fbdec46923"

RDEPENDS:rust-path-dedot+default-devel = " \
 cargo \
 rust-path-dedot-devel \
 "
RDEPENDS:rust-path-dedot+fixed_workdir-devel = " \
 cargo \
 rust-path-dedot-devel \
 "
RDEPENDS:rust-path-dedot-devel = " \
 cargo \
 rust \
 "
