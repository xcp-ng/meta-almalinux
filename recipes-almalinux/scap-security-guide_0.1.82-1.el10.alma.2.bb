# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scap-security-guide"
PV = "0.1.82"
PR = "1.el10.alma.2"
PACKAGES = " \
 scap-security-guide \
 scap-security-guide-doc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/scap-security-guide-0.1.82-1.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "552dc9b16f0249ab29c1184cc267a721f378fc96ae4f665d0321cd9478944680"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scap-security-guide-0.1.82-1.el10.alma.2.noarch.rpm;name=x86_64_v2_scap-security-guide;unpack=0"
SRC_URI[x86_64_v2_scap-security-guide.sha256sum] = "482e67b9e3c0406b6377277b6cfa0b449303356557f1e7b73f9df7af003aa774"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scap-security-guide-doc-0.1.82-1.el10.alma.2.noarch.rpm;name=x86_64_v2_scap-security-guide-doc;unpack=0"
SRC_URI[x86_64_v2_scap-security-guide-doc.sha256sum] = "9d9f319114c81125e492b54ad306590cebedd120f68f6d98cda3f9d6d16b03c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scap-security-guide-0.1.82-1.el10.alma.2.noarch.rpm;name=aarch64_scap-security-guide;unpack=0"
SRC_URI[aarch64_scap-security-guide.sha256sum] = "482e67b9e3c0406b6377277b6cfa0b449303356557f1e7b73f9df7af003aa774"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scap-security-guide-doc-0.1.82-1.el10.alma.2.noarch.rpm;name=aarch64_scap-security-guide-doc;unpack=0"
SRC_URI[aarch64_scap-security-guide-doc.sha256sum] = "9d9f319114c81125e492b54ad306590cebedd120f68f6d98cda3f9d6d16b03c9"

RDEPENDS:scap-security-guide = " \
 openscap-scanner \
 xml-common \
 "
RDEPENDS:scap-security-guide-doc = " \
 scap-security-guide \
 "
