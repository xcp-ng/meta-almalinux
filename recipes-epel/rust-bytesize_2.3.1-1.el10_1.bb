# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytesize"
PV = "2.3.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-bytesize+arbitrary-devel \
 rust-bytesize+default-devel \
 rust-bytesize+serde-devel \
 rust-bytesize+std-devel \
 rust-bytesize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytesize-2.3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bab2e0bde1d4469b77d4e19067b985c1a55754be4b5446374098dba79c0e2387"

URI_x86_64_v2_rust-bytesize+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+arbitrary-devel-2.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-bytesize+arbitrary-devel.sha256sum] = "8c1f552fcf06b08bfb90b00dfdadf90612f7f4fd75c85839fd4d41e1e08dabc4"

URI_x86_64_v2_rust-bytesize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+default-devel-2.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+default-devel}"
SRC_URI[x86_64_v2_rust-bytesize+default-devel.sha256sum] = "80eb75f8311cdb65416492ce20a428d4e4ed168244e4140d2290ddac9622f03e"

URI_x86_64_v2_rust-bytesize+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+serde-devel-2.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+serde-devel}"
SRC_URI[x86_64_v2_rust-bytesize+serde-devel.sha256sum] = "51d6e45eb563612a54587463cbd4b1c2cae7319d13dcfe324d639fcc50552404"

URI_x86_64_v2_rust-bytesize+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+std-devel-2.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+std-devel}"
SRC_URI[x86_64_v2_rust-bytesize+std-devel.sha256sum] = "e3ea80a60856e374de34226653687bfaec378f005a91948de6f906de786a3b8d"

URI_x86_64_v2_rust-bytesize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize-devel-2.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize-devel}"
SRC_URI[x86_64_v2_rust-bytesize-devel.sha256sum] = "706168ba20e6f7679a242df9ef518cd3abef4c88d597298d509931cb9b1ac1f4"

URI_aarch64_rust-bytesize+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+arbitrary-devel-2.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-bytesize+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+arbitrary-devel}"
SRC_URI[aarch64_rust-bytesize+arbitrary-devel.sha256sum] = "3a9d4b2fe650cddd8faaae0301d440978a8f2c5e71fb465b990b4566cf83c3e0"

URI_aarch64_rust-bytesize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+default-devel-2.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-bytesize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+default-devel}"
SRC_URI[aarch64_rust-bytesize+default-devel.sha256sum] = "00b17cdd5dc10fc6572a8470976decce8ab1f89efb56a635a74f9e9b73eb6a40"

URI_aarch64_rust-bytesize+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+serde-devel-2.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-bytesize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+serde-devel}"
SRC_URI[aarch64_rust-bytesize+serde-devel.sha256sum] = "a3336055c9760ea50664a76f718f691b8d61b1c25f5b62f69f3895594c7b7f34"

URI_aarch64_rust-bytesize+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+std-devel-2.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-bytesize+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+std-devel}"
SRC_URI[aarch64_rust-bytesize+std-devel.sha256sum] = "4c3f100daaedea076c95185a6e34fc96b54931ed60ae96c53b639a5dd434a6b1"

URI_aarch64_rust-bytesize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize-devel-2.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize-devel}"
SRC_URI[aarch64_rust-bytesize-devel.sha256sum] = "bf09d909b61d6502621953233240d96d8ac56ea5b493e2c50074322e6b1db068"

RDEPENDS:rust-bytesize+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-bytesize-devel \
 "
RDEPENDS:rust-bytesize+default-devel = " \
 cargo \
 rust-bytesize+std-devel \
 rust-bytesize-devel \
 "
RDEPENDS:rust-bytesize+serde-devel = " \
 cargo \
 rust-bytesize-devel \
 rust-serde_core+default-devel \
 "
RDEPENDS:rust-bytesize+std-devel = " \
 cargo \
 rust-bytesize-devel \
 "
RDEPENDS:rust-bytesize-devel = " \
 cargo \
 rust \
 "
