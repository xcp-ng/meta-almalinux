# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dovecot"
PE = "1"
PV = "2.3.21"
PR = "19.el10_2.1"
PACKAGES = " \
 dovecot \
 dovecot-devel \
 dovecot-mysql \
 dovecot-pgsql \
 dovecot-pigeonhole \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dovecot-2.3.21-19.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65bda18194736e4e13c54e63929811e7ac20774d3d557288d904cc897a0421f6"

URI_x86_64_v2_dovecot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-2.3.21-19.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_dovecot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot}"
SRC_URI[x86_64_v2_dovecot.sha256sum] = "7b5acf171b3c43c8de8fafb9a136e28b9b72aaa602ed703d3c5acd3bd89d3528"

URI_x86_64_v2_dovecot-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dovecot-devel-2.3.21-19.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_dovecot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-devel}"
SRC_URI[x86_64_v2_dovecot-devel.sha256sum] = "51fdbcd2d4d51ba532df306c058208cc2709eb9535af877de2a299a02ed3c9d9"

URI_x86_64_v2_dovecot-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-mysql-2.3.21-19.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_dovecot-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-mysql}"
SRC_URI[x86_64_v2_dovecot-mysql.sha256sum] = "99d43321e8cb84b4c06d2d1a9cb4deb1192e0356d32c7ed15b04221a6c2d094c"

URI_x86_64_v2_dovecot-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-pgsql-2.3.21-19.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_dovecot-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-pgsql}"
SRC_URI[x86_64_v2_dovecot-pgsql.sha256sum] = "cdc546a2e3fb28025497fed9daa51035b2961f33a1d35622f238c3ff8106a2c4"

URI_x86_64_v2_dovecot-pigeonhole = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-pigeonhole-2.3.21-19.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_dovecot-pigeonhole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-pigeonhole}"
SRC_URI[x86_64_v2_dovecot-pigeonhole.sha256sum] = "b9b3c6713abda18d9a888ed048ed35f164dda7108c0be701efde378cba325b89"

URI_aarch64_dovecot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-2.3.21-19.el10_2.1.aarch64.rpm;name=aarch64_dovecot;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot}"
SRC_URI[aarch64_dovecot.sha256sum] = "d3fd560d9cc1c11a4fac3b5b5bd64adc43ec44e1a7769d27efdab64bfd3030bc"

URI_aarch64_dovecot-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dovecot-devel-2.3.21-19.el10_2.1.aarch64.rpm;name=aarch64_dovecot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-devel}"
SRC_URI[aarch64_dovecot-devel.sha256sum] = "fcf793f83cc82107a60082de67713d100e24058c69116bb0ac32e1dfdc84f98a"

URI_aarch64_dovecot-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-mysql-2.3.21-19.el10_2.1.aarch64.rpm;name=aarch64_dovecot-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-mysql}"
SRC_URI[aarch64_dovecot-mysql.sha256sum] = "0cc4e82701328867ae5dcb30576004e3d0774b9e57304ffba3af60f269aceccd"

URI_aarch64_dovecot-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-pgsql-2.3.21-19.el10_2.1.aarch64.rpm;name=aarch64_dovecot-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-pgsql}"
SRC_URI[aarch64_dovecot-pgsql.sha256sum] = "58925838e6b2133845eea141d82a3739423e297b8cb19365cfad7d9456e2235b"

URI_aarch64_dovecot-pigeonhole = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-pigeonhole-2.3.21-19.el10_2.1.aarch64.rpm;name=aarch64_dovecot-pigeonhole;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-pigeonhole}"
SRC_URI[aarch64_dovecot-pigeonhole.sha256sum] = "1244e628fdd7b954d6cc961cb88115ce509e8c894a7af3d27332bb819b8f6885"

RDEPENDS:dovecot = " \
 bash \
 bzip2-libs \
 expat \
 glibc \
 krb5-libs \
 libcap \
 libcom_err \
 libicu \
 libxcrypt \
 libzstd \
 lz4-libs \
 openldap \
 openssl \
 openssl-libs \
 pam-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:dovecot-devel = " \
 dovecot \
 "
RDEPENDS:dovecot-mysql = " \
 dovecot \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:dovecot-pgsql = " \
 dovecot \
 glibc \
 libpq \
 "
RDEPENDS:dovecot-pigeonhole = " \
 dovecot \
 glibc \
 "
