# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-fdo-client"
PV = "1.0.0"
PR = "9.el10"
PACKAGES = " \
 go-fdo-client \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/go-fdo-client-1.0.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "824851954dc40c119de24ad13230b2d827b2a88e2d299c9efe72bd4e42bc0330"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-client-1.0.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_go-fdo-client;unpack=0"
SRC_URI[x86_64_v2_go-fdo-client.sha256sum] = "a33191b719cf4d57a5db3fb8545ae6cd7f7fa51cc79ad76fe1beb84318c48f49"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-client-1.0.0-9.el10.aarch64.rpm;name=aarch64_go-fdo-client;unpack=0"
SRC_URI[aarch64_go-fdo-client.sha256sum] = "fea9daa007f2be48f6ea019caedb259c007ad38ede067293ed3d1f9bac973184"

RDEPENDS:go-fdo-client = " \
 glibc \
 "
