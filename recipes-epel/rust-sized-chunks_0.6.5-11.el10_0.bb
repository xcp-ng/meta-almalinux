# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sized-chunks"
PV = "0.6.5"
PR = "11.el10_0"
PACKAGES = " \
 rust-sized-chunks+arbitrary-devel \
 rust-sized-chunks+default-devel \
 rust-sized-chunks+std-devel \
 rust-sized-chunks-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sized-chunks-0.6.5-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c81ade882e4e06e5fd550c13d55f9ed56442a82f6777a07a42da3363bcd42299"

URI_x86_64_v2_rust-sized-chunks+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sized-chunks+arbitrary-devel-0.6.5-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sized-chunks+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sized-chunks+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-sized-chunks+arbitrary-devel.sha256sum] = "15f0e418a1531e16e484cca7f2485e532d9574abe38255a00fb438e858280576"

URI_x86_64_v2_rust-sized-chunks+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sized-chunks+default-devel-0.6.5-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sized-chunks+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sized-chunks+default-devel}"
SRC_URI[x86_64_v2_rust-sized-chunks+default-devel.sha256sum] = "783b771b6f5b97c1fd5537c4e7289ac62f732d27759e85fc5cb21f67421abed5"

URI_x86_64_v2_rust-sized-chunks+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sized-chunks+std-devel-0.6.5-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sized-chunks+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sized-chunks+std-devel}"
SRC_URI[x86_64_v2_rust-sized-chunks+std-devel.sha256sum] = "2cf929898cf136c9a6dbe6bb154c4ab68834fc3928d6bc7350a4d39c146e7e88"

URI_x86_64_v2_rust-sized-chunks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sized-chunks-devel-0.6.5-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sized-chunks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sized-chunks-devel}"
SRC_URI[x86_64_v2_rust-sized-chunks-devel.sha256sum] = "e78c1c9387217a71f717bd193259d24e846418428088f4e0f262257125d68939"

URI_aarch64_rust-sized-chunks+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sized-chunks+arbitrary-devel-0.6.5-11.el10_0.noarch.rpm;name=aarch64_rust-sized-chunks+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sized-chunks+arbitrary-devel}"
SRC_URI[aarch64_rust-sized-chunks+arbitrary-devel.sha256sum] = "c72e561bba531e86b64d50de7e3cf97f8cdeefee1132b0eff13d80bb0f1f22ba"

URI_aarch64_rust-sized-chunks+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sized-chunks+default-devel-0.6.5-11.el10_0.noarch.rpm;name=aarch64_rust-sized-chunks+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sized-chunks+default-devel}"
SRC_URI[aarch64_rust-sized-chunks+default-devel.sha256sum] = "c1f5f468bf156fbe4e0743422bfebb48748a272eba5cb8169f26043ac11404fd"

URI_aarch64_rust-sized-chunks+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sized-chunks+std-devel-0.6.5-11.el10_0.noarch.rpm;name=aarch64_rust-sized-chunks+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sized-chunks+std-devel}"
SRC_URI[aarch64_rust-sized-chunks+std-devel.sha256sum] = "7cbd31f05b5234538fa04488dba5372d019c1e12622692dcb0121cb171eb0d69"

URI_aarch64_rust-sized-chunks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sized-chunks-devel-0.6.5-11.el10_0.noarch.rpm;name=aarch64_rust-sized-chunks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sized-chunks-devel}"
SRC_URI[aarch64_rust-sized-chunks-devel.sha256sum] = "c45881b9d0a5b4d2d8e04ce452cc15b6c7786d44036af11a26543a7c481002d7"

RDEPENDS:rust-sized-chunks+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-sized-chunks-devel \
 "
RDEPENDS:rust-sized-chunks+default-devel = " \
 cargo \
 rust-sized-chunks+std-devel \
 rust-sized-chunks-devel \
 "
RDEPENDS:rust-sized-chunks+std-devel = " \
 cargo \
 rust-sized-chunks-devel \
 "
RDEPENDS:rust-sized-chunks-devel = " \
 cargo \
 rust-bitmaps+default-devel \
 rust-typenum+default-devel \
 "
