# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx"
PV = "1.0.142"
PR = "1.el10_0"
PACKAGES = " \
 rust-cxx+alloc-devel \
 rust-cxx+c++14-devel \
 rust-cxx+c++17-devel \
 rust-cxx+c++20-devel \
 rust-cxx+default-devel \
 rust-cxx+std-devel \
 rust-cxx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-1.0.142-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fffcda5a8183c1677dbe2824dd7ecd90f4949ab757cd66776b70d2981915862"

URI_x86_64_v2_rust-cxx+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+alloc-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+alloc-devel}"
SRC_URI[x86_64_v2_rust-cxx+alloc-devel.sha256sum] = "a518227d9385d98032c12edecd300021f33409f585f03c055bdb2f7ab6b89028"

URI_x86_64_v2_rust-cxx+c++14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++14-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+c++14-devel}"
SRC_URI[x86_64_v2_rust-cxx+c++14-devel.sha256sum] = "aa715b98a85a0dc16eba1ab8ceab678dab6e233b3a49675a8458548a3bbe7a86"

URI_x86_64_v2_rust-cxx+c++17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++17-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+c++17-devel}"
SRC_URI[x86_64_v2_rust-cxx+c++17-devel.sha256sum] = "094a314a4e0ef24d91af03da62d86727334a48e73943ccdcff534727ecfe5b61"

URI_x86_64_v2_rust-cxx+c++20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++20-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+c++20-devel}"
SRC_URI[x86_64_v2_rust-cxx+c++20-devel.sha256sum] = "5f3b193c4887ff12fdd017530370f6cec038d7f6da189da64ac5f06d86eb68f2"

URI_x86_64_v2_rust-cxx+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+default-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+default-devel}"
SRC_URI[x86_64_v2_rust-cxx+default-devel.sha256sum] = "cea004391b826ed8af36c4020acad760cbd192fbc0bb016ad27aec4e51c12b0f"

URI_x86_64_v2_rust-cxx+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+std-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+std-devel}"
SRC_URI[x86_64_v2_rust-cxx+std-devel.sha256sum] = "bcc794a2b3295b3ae6d808c197c6076469bac2b9d56f66373f268886ba7e61fc"

URI_x86_64_v2_rust-cxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-devel}"
SRC_URI[x86_64_v2_rust-cxx-devel.sha256sum] = "e2180a1a7c1dd6239d57ef8a824427fae72c40ee37cdf507f464390e94b2a6b6"

URI_aarch64_rust-cxx+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+alloc-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxx+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+alloc-devel}"
SRC_URI[aarch64_rust-cxx+alloc-devel.sha256sum] = "69f9622c3a1278802b84846260873cbe618c2b87ed3a3cbcea945dab2a1a8c59"

URI_aarch64_rust-cxx+c++14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++14-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxx+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+c++14-devel}"
SRC_URI[aarch64_rust-cxx+c++14-devel.sha256sum] = "6aecb662a5b114ff29760ffd862063a3f25fd39164091a3aa5a395418b7e9c53"

URI_aarch64_rust-cxx+c++17-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++17-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxx+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+c++17-devel}"
SRC_URI[aarch64_rust-cxx+c++17-devel.sha256sum] = "5d302ce3e64b5777628bb02ae77f061ddd151a4618d601b50614db4681374f19"

URI_aarch64_rust-cxx+c++20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++20-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxx+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+c++20-devel}"
SRC_URI[aarch64_rust-cxx+c++20-devel.sha256sum] = "b327248061764b507e0fe1b7ae80a43651ba6d4ddb02b5aa714372fd897e1449"

URI_aarch64_rust-cxx+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+default-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxx+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+default-devel}"
SRC_URI[aarch64_rust-cxx+default-devel.sha256sum] = "f2d944d42936a32c8d1646e60f3c54187f51d39eff75f842770776df5ba3d7da"

URI_aarch64_rust-cxx+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+std-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxx+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+std-devel}"
SRC_URI[aarch64_rust-cxx+std-devel.sha256sum] = "b460a7cb619b7602e7b3c42780d5d4d5ed87779fea9d7d3b43ac410c97da7e91"

URI_aarch64_rust-cxx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-devel}"
SRC_URI[aarch64_rust-cxx-devel.sha256sum] = "5d181c892eea43afc9ef256a7db3803c38131e13ba813a5627911e16aac4fc2e"

RDEPENDS:rust-cxx+alloc-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++14-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++17-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++20-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+default-devel = " \
 cargo \
 rust-cxx+std-devel \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+std-devel = " \
 cargo \
 rust-cxx+alloc-devel \
 rust-cxx-devel \
 rust-foldhash+std-devel \
 "
RDEPENDS:rust-cxx-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-cxxbridge-flags-devel \
 rust-cxxbridge-macro+default-devel \
 rust-foldhash-devel \
 rust-link-cplusplus+default-devel \
 "
