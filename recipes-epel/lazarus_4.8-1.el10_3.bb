# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lazarus"
PV = "4.8"
PR = "1.el10_3"
PACKAGES = " \
 lazarus \
 lazarus-doc \
 lazarus-ide \
 lazarus-lcl \
 lazarus-lcl-gtk2 \
 lazarus-lcl-gtk3 \
 lazarus-lcl-nogui \
 lazarus-lcl-qt5 \
 lazarus-lcl-qt6 \
 lazarus-tools \
 qt5pas \
 qt5pas-devel \
 qt6pas \
 qt6pas-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lazarus-4.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "384277a045f6daccd8b698fc360850299ffc276ac29b6e52b508294080d0868f"

URI_aarch64_lazarus = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-4.8-1.el10_3.aarch64.rpm;name=aarch64_lazarus;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus}"
SRC_URI[aarch64_lazarus.sha256sum] = "e12087bec75a80733b076e461acf8b1331af2378cf46ee46bfeb0b04b04048d2"

URI_aarch64_lazarus-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-doc-4.8-1.el10_3.aarch64.rpm;name=aarch64_lazarus-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-doc}"
SRC_URI[aarch64_lazarus-doc.sha256sum] = "02f487a9cbb0f72b82ace6ea6abca5246f5024d1afc2493589f4264542151ca5"

URI_aarch64_lazarus-ide = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-ide-4.8-1.el10_3.aarch64.rpm;name=aarch64_lazarus-ide;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-ide}"
SRC_URI[aarch64_lazarus-ide.sha256sum] = "77eff4125b5b3d999f01e00f120e541194edf20c8bde4748657a5f50f610b3b0"

URI_aarch64_lazarus-lcl = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-4.8-1.el10_3.aarch64.rpm;name=aarch64_lazarus-lcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl}"
SRC_URI[aarch64_lazarus-lcl.sha256sum] = "87f81ea64e9eeee3fd3fa7742343128737adc2772465f90d7a584394bef57929"

URI_aarch64_lazarus-lcl-gtk2 = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-gtk2-4.8-1.el10_3.aarch64.rpm;name=aarch64_lazarus-lcl-gtk2;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-gtk2}"
SRC_URI[aarch64_lazarus-lcl-gtk2.sha256sum] = "2ca32d3caad88e0cb0051990bdac38817509ac90805621031d3e119975781266"

URI_aarch64_lazarus-lcl-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-gtk3-4.8-1.el10_3.aarch64.rpm;name=aarch64_lazarus-lcl-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-gtk3}"
SRC_URI[aarch64_lazarus-lcl-gtk3.sha256sum] = "f415a51163278839f47942e0e5121eddd1a532f939b24fe9b9d170539dab276c"

URI_aarch64_lazarus-lcl-nogui = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-nogui-4.8-1.el10_3.aarch64.rpm;name=aarch64_lazarus-lcl-nogui;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-nogui}"
SRC_URI[aarch64_lazarus-lcl-nogui.sha256sum] = "947238a3a784efc31c5fe61148a2ba860a465035c36bc9594845c2f0d6b3ae07"

URI_aarch64_lazarus-lcl-qt5 = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-qt5-4.8-1.el10_3.aarch64.rpm;name=aarch64_lazarus-lcl-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-qt5}"
SRC_URI[aarch64_lazarus-lcl-qt5.sha256sum] = "5f7ceba398794e8f90b0e6425cb513fc08b406006085586b1cd53f9f7d76884b"

URI_aarch64_lazarus-lcl-qt6 = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-qt6-4.8-1.el10_3.aarch64.rpm;name=aarch64_lazarus-lcl-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-qt6}"
SRC_URI[aarch64_lazarus-lcl-qt6.sha256sum] = "994bd97413d0862888f9ea8d626798c8933fccf5f17ee90156c736df9532f0c5"

URI_aarch64_lazarus-tools = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-tools-4.8-1.el10_3.aarch64.rpm;name=aarch64_lazarus-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-tools}"
SRC_URI[aarch64_lazarus-tools.sha256sum] = "7c561bdd31bade0a4c3bfad58297698d055def06fc3ddad4d7034615f0304279"

URI_aarch64_qt5pas = "${EPEL_MIRROR}/aarch64/Packages/q/qt5pas-2.16-40801.el10_3.aarch64.rpm;name=aarch64_qt5pas;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5pas}"
SRC_URI[aarch64_qt5pas.sha256sum] = "bd4d142bbdc4744305613abe5f42cd7aaee1c907c367146d0ded5fe260360821"

URI_aarch64_qt5pas-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5pas-devel-2.16-40801.el10_3.aarch64.rpm;name=aarch64_qt5pas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5pas-devel}"
SRC_URI[aarch64_qt5pas-devel.sha256sum] = "07e508005420f082b330172d3d8e85a650b2d8af82bd1b1cf36da29f15bcb69a"

URI_aarch64_qt6pas = "${EPEL_MIRROR}/aarch64/Packages/q/qt6pas-6.2.10-40801.el10_3.aarch64.rpm;name=aarch64_qt6pas;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6pas}"
SRC_URI[aarch64_qt6pas.sha256sum] = "78a18e97274f4c37008919ba663948c5c88f7942e82393a5842e7c7557c908a0"

URI_aarch64_qt6pas-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6pas-devel-6.2.10-40801.el10_3.aarch64.rpm;name=aarch64_qt6pas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6pas-devel}"
SRC_URI[aarch64_qt6pas-devel.sha256sum] = "e10542c0c9749f1332ba389d62f0d2e3e6b9652b88270de7b819757f88ca37fd"

RDEPENDS:lazarus = " \
 lazarus-ide \
 lazarus-lcl \
 lazarus-lcl-gtk2 \
 lazarus-lcl-nogui \
 lazarus-tools \
 "
RDEPENDS:lazarus-doc = " \
 bash \
 perl-File-Basename \
 perl-File-Find \
 perl-Getopt-Std \
 perl-interpreter \
 perl-vars \
 "
RDEPENDS:lazarus-ide = " \
 atk \
 bash \
 cairo \
 fpc-src \
 gdb \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 hicolor-icon-theme \
 lazarus-lcl \
 lazarus-tools \
 libX11 \
 make \
 pango \
 "
RDEPENDS:lazarus-lcl = " \
 atk \
 bash \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 libX11 \
 pango \
 "
RDEPENDS:lazarus-lcl-gtk2 = " \
 gtk2-devel \
 lazarus-lcl \
 "
RDEPENDS:lazarus-lcl-gtk3 = " \
 gtk3-devel \
 lazarus-lcl \
 "
RDEPENDS:lazarus-lcl-nogui = " \
 lazarus-lcl \
 "
RDEPENDS:lazarus-lcl-qt5 = " \
 lazarus-lcl \
 qt5pas \
 qt5pas-devel \
 "
RDEPENDS:lazarus-lcl-qt6 = " \
 lazarus-lcl \
 qt6pas \
 qt6pas-devel \
 "
RDEPENDS:lazarus-tools = " \
 bash \
 binutils \
 fpc \
 glibc \
 glibc-devel \
 lazarus-lcl \
 perl-Getopt-Std \
 perl-PathTools \
 perl-interpreter \
 perl-vars \
 "
RDEPENDS:qt5pas = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtx11extras \
 "
RDEPENDS:qt5pas-devel = " \
 qt5-qtbase-devel \
 qt5-qtx11extras-devel \
 qt5pas \
 "
RDEPENDS:qt6pas = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:qt6pas-devel = " \
 qt6-qtbase-devel \
 qt6pas \
 "
