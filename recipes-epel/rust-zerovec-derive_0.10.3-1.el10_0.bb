# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerovec-derive"
PV = "0.10.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-zerovec-derive+default-devel \
 rust-zerovec-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerovec-derive-0.10.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "035de1b2b89db14267fbf679400a63df308687553ac5be2d04fdbe8f011ab695"

URI_x86_64_v2_rust-zerovec-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-derive+default-devel-0.10.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec-derive+default-devel}"
SRC_URI[x86_64_v2_rust-zerovec-derive+default-devel.sha256sum] = "9415476fb7f3f5c44de376947a4474dbac2a815ee2657d54f61fe7396775c886"

URI_x86_64_v2_rust-zerovec-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-derive-devel-0.10.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec-derive-devel}"
SRC_URI[x86_64_v2_rust-zerovec-derive-devel.sha256sum] = "5021e05d38a3a558da8c966742e3d12f24be21ea2b58733d2acaf06b7b3daa55"

URI_aarch64_rust-zerovec-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-derive+default-devel-0.10.3-1.el10_0.noarch.rpm;name=aarch64_rust-zerovec-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec-derive+default-devel}"
SRC_URI[aarch64_rust-zerovec-derive+default-devel.sha256sum] = "ad103fcd4ff3d2381b21f51f20a2017f32237df452e477aa33a7adb3a87ff552"

URI_aarch64_rust-zerovec-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-derive-devel-0.10.3-1.el10_0.noarch.rpm;name=aarch64_rust-zerovec-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec-derive-devel}"
SRC_URI[aarch64_rust-zerovec-derive-devel.sha256sum] = "41c46e1530556213b4f5415b5eda98bf70476045fb3903070f9ec02425fc4bf3"

RDEPENDS:rust-zerovec-derive+default-devel = " \
 cargo \
 rust-zerovec-derive-devel \
 "
RDEPENDS:rust-zerovec-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 "
