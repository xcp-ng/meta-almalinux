# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-core"
PV = "0.3.31"
PR = "1.el10_0"
PACKAGES = " \
 rust-futures-core+alloc-devel \
 rust-futures-core+cfg-target-has-atomic-devel \
 rust-futures-core+default-devel \
 rust-futures-core+portable-atomic-devel \
 rust-futures-core+std-devel \
 rust-futures-core+unstable-devel \
 rust-futures-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-core-0.3.31-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9ebe0e19172c03d78233d2c736a02cc687e1029352f1cabb8f4bb827baf4d91"

URI_x86_64_v2_rust-futures-core+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+alloc-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-core+alloc-devel.sha256sum] = "1d6c0f2a550925e36da9ae82621bb80cbf55cf201865b24e9e49f16b33052eee"

URI_x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+cfg-target-has-atomic-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel.sha256sum] = "f9008e3f9ce67f6dba8ab763f668034223bf79d4b22d73ac6c5ea9b5e76009a7"

URI_x86_64_v2_rust-futures-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+default-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+default-devel}"
SRC_URI[x86_64_v2_rust-futures-core+default-devel.sha256sum] = "5c1557e29baa7976180cb000e9f18433f9aacc0a18f7fe3669a8c95e08ed429f"

URI_x86_64_v2_rust-futures-core+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+portable-atomic-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-core+portable-atomic-devel.sha256sum] = "88a47df479eefd5d792edeca074790ec22f9b2e138dde9f3921e26702eba3cad"

URI_x86_64_v2_rust-futures-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+std-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+std-devel}"
SRC_URI[x86_64_v2_rust-futures-core+std-devel.sha256sum] = "55dffb5560c9de331b1c78778c6f1d1b1ea5a1350403a544500d8d487e1d05cd"

URI_x86_64_v2_rust-futures-core+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+unstable-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-core+unstable-devel.sha256sum] = "94e745123b9c3f9bc29407d5ae99c00b9faa5367bd6443be3e59c2570253d525"

URI_x86_64_v2_rust-futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core-devel}"
SRC_URI[x86_64_v2_rust-futures-core-devel.sha256sum] = "7106db13493e7458dad943a89bcc37aa9c9a47c4864f3f62c035050a91787f3b"

URI_aarch64_rust-futures-core+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+alloc-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+alloc-devel}"
SRC_URI[aarch64_rust-futures-core+alloc-devel.sha256sum] = "99206727eaf3e2b5c2470fc0a956c96d2c53b7ba9a79a7b2aa212795874ea24d"

URI_aarch64_rust-futures-core+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+cfg-target-has-atomic-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-core+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures-core+cfg-target-has-atomic-devel.sha256sum] = "afc3b9048ca88ac757b18467dcb01ebee143981b8194b0d89b5d8fdeb9b215ff"

URI_aarch64_rust-futures-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+default-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+default-devel}"
SRC_URI[aarch64_rust-futures-core+default-devel.sha256sum] = "90b923fa820aee6ab2acd9a207fdeeedde8b9c8d40dab2b2f264e9e75c678a44"

URI_aarch64_rust-futures-core+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+portable-atomic-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-core+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+portable-atomic-devel}"
SRC_URI[aarch64_rust-futures-core+portable-atomic-devel.sha256sum] = "cf56b4f8445b6c99dc6802f3d1f3635cee91a57e7df2842c6d59bf56f816709a"

URI_aarch64_rust-futures-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+std-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+std-devel}"
SRC_URI[aarch64_rust-futures-core+std-devel.sha256sum] = "ca8c6f5ef7a138c4152b3e2d34ff592ac1ca5d1f6662403355c77e50f7d25e5f"

URI_aarch64_rust-futures-core+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+unstable-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-core+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+unstable-devel}"
SRC_URI[aarch64_rust-futures-core+unstable-devel.sha256sum] = "cbcd4453261b78896dbd8a8322bbb87d070a5e6dea6e6188389199a1d65c3e35"

URI_aarch64_rust-futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core-devel}"
SRC_URI[aarch64_rust-futures-core-devel.sha256sum] = "4bc170f3e9e4af28cb9a01859dea0187593cd70643b52fce00c248af882ad052"

RDEPENDS:rust-futures-core+alloc-devel = " \
 cargo \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+default-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+portable-atomic-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-futures-core+std-devel = " \
 cargo \
 rust-futures-core+alloc-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+unstable-devel = " \
 cargo \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core-devel = " \
 cargo \
 rust \
 "
