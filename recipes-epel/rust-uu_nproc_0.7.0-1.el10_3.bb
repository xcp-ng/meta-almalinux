# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_nproc"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_nproc+default-devel \
 rust-uu_nproc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_nproc-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3e74a5511da0d056dbdca6d78e72f070bfc9fe16bbb8b202c7ff55ff58b1979"

URI_x86_64_v2_rust-uu_nproc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_nproc+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_nproc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_nproc+default-devel}"
SRC_URI[x86_64_v2_rust-uu_nproc+default-devel.sha256sum] = "3810e7caabe6e716289af93966bd6957218c2ab7901a858b65475e88cbe0eedf"

URI_x86_64_v2_rust-uu_nproc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_nproc-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_nproc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_nproc-devel}"
SRC_URI[x86_64_v2_rust-uu_nproc-devel.sha256sum] = "73892e6df26bf3b170f3df0518b2ccd1df95eb33630c28518a1f6c04af08ab2d"

URI_aarch64_rust-uu_nproc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_nproc+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_nproc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_nproc+default-devel}"
SRC_URI[aarch64_rust-uu_nproc+default-devel.sha256sum] = "c4ec79458f82b7d2ddf4c4193ee08715b44f7cb48df2bc443b0a62fd959ef0f6"

URI_aarch64_rust-uu_nproc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_nproc-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_nproc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_nproc-devel}"
SRC_URI[aarch64_rust-uu_nproc-devel.sha256sum] = "0894dfead30a60358ecfbfbab408f34bab97e7ee8bf5659171085270fadb2a4e"

RDEPENDS:rust-uu_nproc+default-devel = " \
 cargo \
 rust-uu_nproc-devel \
 "
RDEPENDS:rust-uu_nproc-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-libc+default-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 "
