# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rav1e"
PV = "0.7.1"
PR = "4.el10_0"
PACKAGES = " \
 rav1e \
 rav1e-devel \
 rav1e-libs \
 rust-rav1e+asm-devel \
 rust-rav1e+av-metrics-devel \
 rust-rav1e+backtrace-devel \
 rust-rav1e+binaries-devel \
 rust-rav1e+capi-devel \
 rust-rav1e+cc-devel \
 rust-rav1e+channel-api-devel \
 rust-rav1e+check_asm-devel \
 rust-rav1e+clap-devel \
 rust-rav1e+clap_complete-devel \
 rust-rav1e+console-devel \
 rust-rav1e+crossbeam-devel \
 rust-rav1e+default-devel \
 rust-rav1e+desync_finder-devel \
 rust-rav1e+dump_ivf-devel \
 rust-rav1e+fern-devel \
 rust-rav1e+ivf-devel \
 rust-rav1e+nasm-rs-devel \
 rust-rav1e+nom-devel \
 rust-rav1e+quick_test-devel \
 rust-rav1e+scan_fmt-devel \
 rust-rav1e+scenechange-devel \
 rust-rav1e+serde-big-array-devel \
 rust-rav1e+serde-devel \
 rust-rav1e+serialize-devel \
 rust-rav1e+signal-hook-devel \
 rust-rav1e+signal_support-devel \
 rust-rav1e+threading-devel \
 rust-rav1e+toml-devel \
 rust-rav1e+unstable-devel \
 rust-rav1e+y4m-devel \
 rust-rav1e-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rav1e-0.7.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9fdbd43f392e3acb3d5f054ef6a2941710dd9cedb1a56d83a7bd7d5f81faea2"

URI_x86_64_v2_rav1e = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rav1e-0.7.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rav1e;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rav1e}"
SRC_URI[x86_64_v2_rav1e.sha256sum] = "bf94a7dcad95d4885fbecac920890d8588c41fd38aa0d5f1c2ed8ad64e8264db"

URI_x86_64_v2_rav1e-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rav1e-devel-0.7.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rav1e-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rav1e-devel}"
SRC_URI[x86_64_v2_rav1e-devel.sha256sum] = "07f61f78f860910b13b921855621755409286970e02c17849e1a6c53c4b229e7"

URI_x86_64_v2_rav1e-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rav1e-libs-0.7.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rav1e-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rav1e-libs}"
SRC_URI[x86_64_v2_rav1e-libs.sha256sum] = "0d96c7da4e514f82b375dd8904a49a89e4c57d4effc518cc5a03c8558b131420"

URI_x86_64_v2_rust-rav1e+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+asm-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+asm-devel}"
SRC_URI[x86_64_v2_rust-rav1e+asm-devel.sha256sum] = "29e2d61ff425729d83378fdd4137fc65aff0cda8575ab6a9b3e697fce9bb8b29"

URI_x86_64_v2_rust-rav1e+av-metrics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+av-metrics-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+av-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+av-metrics-devel}"
SRC_URI[x86_64_v2_rust-rav1e+av-metrics-devel.sha256sum] = "5c0af66f9db9606c1e7ed88e063329aa71aede8b8b08d801b171e049a2473efa"

URI_x86_64_v2_rust-rav1e+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+backtrace-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+backtrace-devel}"
SRC_URI[x86_64_v2_rust-rav1e+backtrace-devel.sha256sum] = "67fcc65c04364057e502ae472ba4ae9edac407b5a95917e1b5427120f4388a99"

URI_x86_64_v2_rust-rav1e+binaries-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+binaries-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+binaries-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+binaries-devel}"
SRC_URI[x86_64_v2_rust-rav1e+binaries-devel.sha256sum] = "de830321df346c62111fbf4ce1d25ca7f9d1581ca18809214cb780724c05c563"

URI_x86_64_v2_rust-rav1e+capi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+capi-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+capi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+capi-devel}"
SRC_URI[x86_64_v2_rust-rav1e+capi-devel.sha256sum] = "68221cc9b8de60a7d953f989dcba7a380e4492fbd2b0a213568e9f8e1f0a5d91"

URI_x86_64_v2_rust-rav1e+cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+cc-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+cc-devel}"
SRC_URI[x86_64_v2_rust-rav1e+cc-devel.sha256sum] = "c98da9ad7210e165311201ae222846dd75329b4993db44c87e7dada74528e668"

URI_x86_64_v2_rust-rav1e+channel-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+channel-api-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+channel-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+channel-api-devel}"
SRC_URI[x86_64_v2_rust-rav1e+channel-api-devel.sha256sum] = "9714b996c97600eed6c2683618e6d162adfc84ebc8bfc2a645f4025e5f1900be"

URI_x86_64_v2_rust-rav1e+check_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+check_asm-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+check_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+check_asm-devel}"
SRC_URI[x86_64_v2_rust-rav1e+check_asm-devel.sha256sum] = "c2dbd90ec29b32f13bec45f94852135788254948b3118d32059ed35d2c1d394a"

URI_x86_64_v2_rust-rav1e+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+clap-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+clap-devel}"
SRC_URI[x86_64_v2_rust-rav1e+clap-devel.sha256sum] = "a4def513eccc970c8338d8409e82c25c676e3a1ec1a01fb979e3c25adcf652cf"

URI_x86_64_v2_rust-rav1e+clap_complete-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+clap_complete-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+clap_complete-devel}"
SRC_URI[x86_64_v2_rust-rav1e+clap_complete-devel.sha256sum] = "9e449666790c5aeaf4d2aaebde89b123f7d23fdb13bcf9aed14cce5b57879780"

URI_x86_64_v2_rust-rav1e+console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+console-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+console-devel}"
SRC_URI[x86_64_v2_rust-rav1e+console-devel.sha256sum] = "4529ce9303d4e4c0f4b89738fbf2d66b2d0d8e40d8b908714a69a6ddcefcfe93"

URI_x86_64_v2_rust-rav1e+crossbeam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+crossbeam-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+crossbeam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+crossbeam-devel}"
SRC_URI[x86_64_v2_rust-rav1e+crossbeam-devel.sha256sum] = "0b248077046a3577b27bb43313fd938d6c82dbfc65f81efee357976e8126151f"

URI_x86_64_v2_rust-rav1e+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+default-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+default-devel}"
SRC_URI[x86_64_v2_rust-rav1e+default-devel.sha256sum] = "0691039c23c0ed697c6c21665822cce8dd9099b8afa7970a235ff6ac3fd82945"

URI_x86_64_v2_rust-rav1e+desync_finder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+desync_finder-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+desync_finder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+desync_finder-devel}"
SRC_URI[x86_64_v2_rust-rav1e+desync_finder-devel.sha256sum] = "dfa69e8f89b87f09b931467780ca49b2cc96b4589aab356bf7e86a0b863b9027"

URI_x86_64_v2_rust-rav1e+dump_ivf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+dump_ivf-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+dump_ivf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+dump_ivf-devel}"
SRC_URI[x86_64_v2_rust-rav1e+dump_ivf-devel.sha256sum] = "1620357f7a3913f647ac3925d2b0572f7f7f8363e05f528f9fc42fe4428adf0a"

URI_x86_64_v2_rust-rav1e+fern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+fern-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+fern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+fern-devel}"
SRC_URI[x86_64_v2_rust-rav1e+fern-devel.sha256sum] = "62e2ae652f766873aaa95558fbed329b2ccdf091a61afbad6c58881a57f857a1"

URI_x86_64_v2_rust-rav1e+ivf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+ivf-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+ivf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+ivf-devel}"
SRC_URI[x86_64_v2_rust-rav1e+ivf-devel.sha256sum] = "75c66f0312897bca359e4e8ab39ea930fbe9cae5e9aceeae4e05169fd0d38a64"

URI_x86_64_v2_rust-rav1e+nasm-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+nasm-rs-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+nasm-rs-devel}"
SRC_URI[x86_64_v2_rust-rav1e+nasm-rs-devel.sha256sum] = "8090bceba13f33d56f100d6a3ae6c3702c83f9ecdbfe4790f1782bd92ac9f721"

URI_x86_64_v2_rust-rav1e+nom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+nom-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+nom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+nom-devel}"
SRC_URI[x86_64_v2_rust-rav1e+nom-devel.sha256sum] = "42e368a489257beed14657acffa7cc00633b2f7be144165a0ad8ff5b27858978"

URI_x86_64_v2_rust-rav1e+quick_test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+quick_test-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+quick_test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+quick_test-devel}"
SRC_URI[x86_64_v2_rust-rav1e+quick_test-devel.sha256sum] = "25e9b821af4baf4a48db2aedfa0dfe66b4218765c61f266fc2dfee5530df93fc"

URI_x86_64_v2_rust-rav1e+scan_fmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+scan_fmt-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+scan_fmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+scan_fmt-devel}"
SRC_URI[x86_64_v2_rust-rav1e+scan_fmt-devel.sha256sum] = "bb52b0d2a9b8fb606da18720b3d3e2c06ed66ffb1d0a6e5c0a94abaed98619a0"

URI_x86_64_v2_rust-rav1e+scenechange-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+scenechange-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+scenechange-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+scenechange-devel}"
SRC_URI[x86_64_v2_rust-rav1e+scenechange-devel.sha256sum] = "72e8f9e3a4b65c0fc6b987f249ed27dfc433260d6359c691b7fe3fa81f002793"

URI_x86_64_v2_rust-rav1e+serde-big-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+serde-big-array-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+serde-big-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+serde-big-array-devel}"
SRC_URI[x86_64_v2_rust-rav1e+serde-big-array-devel.sha256sum] = "72f669d4b2d29023ffa779852e8ab98a2f60ec1f7e6414ead2ef9cc414dd23ec"

URI_x86_64_v2_rust-rav1e+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+serde-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+serde-devel}"
SRC_URI[x86_64_v2_rust-rav1e+serde-devel.sha256sum] = "148da283108eedcffc9fc9df3497838c0949ccfb49975a2582355ea3c2079ef0"

URI_x86_64_v2_rust-rav1e+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+serialize-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+serialize-devel}"
SRC_URI[x86_64_v2_rust-rav1e+serialize-devel.sha256sum] = "cc353266e4fc6dee370ac376a9be32c1d2632b973b13014d6db402619dd1c5f0"

URI_x86_64_v2_rust-rav1e+signal-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+signal-hook-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+signal-hook-devel}"
SRC_URI[x86_64_v2_rust-rav1e+signal-hook-devel.sha256sum] = "36ab75b21d85d091e09ec67ab9795bfcce614099ba3e550e6db3be49d569f9b7"

URI_x86_64_v2_rust-rav1e+signal_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+signal_support-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+signal_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+signal_support-devel}"
SRC_URI[x86_64_v2_rust-rav1e+signal_support-devel.sha256sum] = "d9a90f0a00b9d3255da8480693d25d61a217eb8a3a42128ab8a1c3dc3d946747"

URI_x86_64_v2_rust-rav1e+threading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+threading-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+threading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+threading-devel}"
SRC_URI[x86_64_v2_rust-rav1e+threading-devel.sha256sum] = "4ef7edd39eb36d80f7e3181ef024c8580da7e4d1f88616e31cd067f07f5c4174"

URI_x86_64_v2_rust-rav1e+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+toml-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+toml-devel}"
SRC_URI[x86_64_v2_rust-rav1e+toml-devel.sha256sum] = "2a5d460964f37c2e36ba17345d35bd917e1744245f854b29e7f9685e36c98075"

URI_x86_64_v2_rust-rav1e+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+unstable-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+unstable-devel}"
SRC_URI[x86_64_v2_rust-rav1e+unstable-devel.sha256sum] = "c9fcbbd06f4b450fb199fbee6151e14c546873cce5d884cf7f86e2e79d877041"

URI_x86_64_v2_rust-rav1e+y4m-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+y4m-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+y4m-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+y4m-devel}"
SRC_URI[x86_64_v2_rust-rav1e+y4m-devel.sha256sum] = "d3b75b3bcf9add13bfe1f0295de2a7287cc1d1c1559855a436d90551e80c2838"

URI_x86_64_v2_rust-rav1e-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e-devel-0.7.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e-devel}"
SRC_URI[x86_64_v2_rust-rav1e-devel.sha256sum] = "628b0ee2275c64229aea449824e738af0b80715c3337334b97214ca44a35d302"

URI_aarch64_rav1e = "${EPEL_MIRROR}/aarch64/Packages/r/rav1e-0.7.1-4.el10_0.aarch64.rpm;name=aarch64_rav1e;unpack=0"
SRC_URI:append = " ${URI_aarch64_rav1e}"
SRC_URI[aarch64_rav1e.sha256sum] = "b8cff1bdd20597434e0d35d34145e9d6b1b760026cc12507baddcbe8d6502bd9"

URI_aarch64_rav1e-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rav1e-devel-0.7.1-4.el10_0.aarch64.rpm;name=aarch64_rav1e-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rav1e-devel}"
SRC_URI[aarch64_rav1e-devel.sha256sum] = "43711a232e9d526d2e95f5d5ffe36dca3ca9522a1d4761b166506037e0d8262b"

URI_aarch64_rav1e-libs = "${EPEL_MIRROR}/aarch64/Packages/r/rav1e-libs-0.7.1-4.el10_0.aarch64.rpm;name=aarch64_rav1e-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rav1e-libs}"
SRC_URI[aarch64_rav1e-libs.sha256sum] = "48d92b59c8c7df9361e6c4a4c3f7f6416d2b01f5604db8bec6c557a021f88c96"

URI_aarch64_rust-rav1e+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+asm-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+asm-devel}"
SRC_URI[aarch64_rust-rav1e+asm-devel.sha256sum] = "a6626f38078361b150c0cfa3b2cdf3be94a52aee5cedea0dd199f4fe277b4284"

URI_aarch64_rust-rav1e+av-metrics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+av-metrics-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+av-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+av-metrics-devel}"
SRC_URI[aarch64_rust-rav1e+av-metrics-devel.sha256sum] = "80827ffa14815b44440af6d748de902fd71bfed3f79207021e0f236abe6fe1a7"

URI_aarch64_rust-rav1e+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+backtrace-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+backtrace-devel}"
SRC_URI[aarch64_rust-rav1e+backtrace-devel.sha256sum] = "571f7312f81556c97f0a78d68fa606c9c7b9d9035f1cf4738d0a3f2bc4affed3"

URI_aarch64_rust-rav1e+binaries-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+binaries-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+binaries-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+binaries-devel}"
SRC_URI[aarch64_rust-rav1e+binaries-devel.sha256sum] = "20cec46466e3d2c5e23b0810436f5aa0d20433e1a2a7b5609dcceb5f9e507086"

URI_aarch64_rust-rav1e+capi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+capi-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+capi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+capi-devel}"
SRC_URI[aarch64_rust-rav1e+capi-devel.sha256sum] = "46af5bfcecd160b5d576bff5823eec9e059decbe6db12e838c02f8dee500ca64"

URI_aarch64_rust-rav1e+cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+cc-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+cc-devel}"
SRC_URI[aarch64_rust-rav1e+cc-devel.sha256sum] = "267bef9520981b571529411b0a0351329e683eda0ce6cceac272b5ce5e5420eb"

URI_aarch64_rust-rav1e+channel-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+channel-api-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+channel-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+channel-api-devel}"
SRC_URI[aarch64_rust-rav1e+channel-api-devel.sha256sum] = "7dbcb1f83b48d691279147a201c5060a59a10f076898518532c2c3ee9b0eabc8"

URI_aarch64_rust-rav1e+check_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+check_asm-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+check_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+check_asm-devel}"
SRC_URI[aarch64_rust-rav1e+check_asm-devel.sha256sum] = "dab19c5781c25f1c65e468a8778c9fa8ff433c1995268f28c9c251a6c859a74b"

URI_aarch64_rust-rav1e+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+clap-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+clap-devel}"
SRC_URI[aarch64_rust-rav1e+clap-devel.sha256sum] = "48aa2db14ccad3521609af5f24c5a9dd475a06078c1de409ec5d4b4c76e69e9e"

URI_aarch64_rust-rav1e+clap_complete-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+clap_complete-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+clap_complete-devel}"
SRC_URI[aarch64_rust-rav1e+clap_complete-devel.sha256sum] = "da6385e3ff23d640c9d478d7a56bfc8c9f41fbc88e45481e8e7283da7d1becb0"

URI_aarch64_rust-rav1e+console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+console-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+console-devel}"
SRC_URI[aarch64_rust-rav1e+console-devel.sha256sum] = "c909f65e1ec265caf848002d7193807781bacce34ac7223b4d12e165bb7d4bd9"

URI_aarch64_rust-rav1e+crossbeam-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+crossbeam-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+crossbeam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+crossbeam-devel}"
SRC_URI[aarch64_rust-rav1e+crossbeam-devel.sha256sum] = "6bd36caf2a5a0da0716a0b76e9aa5d1cace0049bc80150251c0f35e41cae7276"

URI_aarch64_rust-rav1e+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+default-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+default-devel}"
SRC_URI[aarch64_rust-rav1e+default-devel.sha256sum] = "8343f6f227c828a3a45c8a3f0ffcc84132f23014601be17d36c5ddc78e84f6a2"

URI_aarch64_rust-rav1e+desync_finder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+desync_finder-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+desync_finder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+desync_finder-devel}"
SRC_URI[aarch64_rust-rav1e+desync_finder-devel.sha256sum] = "af9012b49662a23fc6fa23ea058a714676b41c46eb2f84d59517e8d985db46f1"

URI_aarch64_rust-rav1e+dump_ivf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+dump_ivf-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+dump_ivf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+dump_ivf-devel}"
SRC_URI[aarch64_rust-rav1e+dump_ivf-devel.sha256sum] = "80eed6eac9f18fa5cc31f2aa8348a6008014564cf8423905d4458c1fb735670f"

URI_aarch64_rust-rav1e+fern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+fern-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+fern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+fern-devel}"
SRC_URI[aarch64_rust-rav1e+fern-devel.sha256sum] = "f4e9bea7c1c03a62c32ffd03605e9c51383eeee075dac9217cdf61502a504488"

URI_aarch64_rust-rav1e+ivf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+ivf-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+ivf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+ivf-devel}"
SRC_URI[aarch64_rust-rav1e+ivf-devel.sha256sum] = "1612522b9c6f61670a729c76e91b7d94979abf094d222ce37b2ed7328aba3fb8"

URI_aarch64_rust-rav1e+nasm-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+nasm-rs-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+nasm-rs-devel}"
SRC_URI[aarch64_rust-rav1e+nasm-rs-devel.sha256sum] = "ca191469772e7516e5bd1590f4b8a31fc0bb71dce77b3ae2d897f613630732d5"

URI_aarch64_rust-rav1e+nom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+nom-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+nom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+nom-devel}"
SRC_URI[aarch64_rust-rav1e+nom-devel.sha256sum] = "d83c56fd8ed39ce799a4c968620072b52dd93e37a8671c4901b66af984d9041f"

URI_aarch64_rust-rav1e+quick_test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+quick_test-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+quick_test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+quick_test-devel}"
SRC_URI[aarch64_rust-rav1e+quick_test-devel.sha256sum] = "7c76eb861f35e3d33033137478e8893b6bc48ea1a9cf3b24d9c202f7da49121e"

URI_aarch64_rust-rav1e+scan_fmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+scan_fmt-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+scan_fmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+scan_fmt-devel}"
SRC_URI[aarch64_rust-rav1e+scan_fmt-devel.sha256sum] = "4faf96d5938a7139cd29be12aed3691ba6f074e58b2163e97617aa60b0bf6c04"

URI_aarch64_rust-rav1e+scenechange-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+scenechange-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+scenechange-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+scenechange-devel}"
SRC_URI[aarch64_rust-rav1e+scenechange-devel.sha256sum] = "2df2c7f4dc94d6b3b74bb56342e106c73f44d8bc19d16ff4c9baf05f504401ab"

URI_aarch64_rust-rav1e+serde-big-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+serde-big-array-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+serde-big-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+serde-big-array-devel}"
SRC_URI[aarch64_rust-rav1e+serde-big-array-devel.sha256sum] = "be006c06bb3dc7166a25810ced089793a1c03a1a345a687c705f05f0c95959fb"

URI_aarch64_rust-rav1e+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+serde-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+serde-devel}"
SRC_URI[aarch64_rust-rav1e+serde-devel.sha256sum] = "d2b2489446eb8613684e23313fd995e369c517f98794da3ae651ea1d19f1f0e3"

URI_aarch64_rust-rav1e+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+serialize-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+serialize-devel}"
SRC_URI[aarch64_rust-rav1e+serialize-devel.sha256sum] = "ac47ff735206b4cd0de40c8f21c7ea9377a7cdb6d8f6ec67ae2dc2312f78d833"

URI_aarch64_rust-rav1e+signal-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+signal-hook-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+signal-hook-devel}"
SRC_URI[aarch64_rust-rav1e+signal-hook-devel.sha256sum] = "e1d95034bfd1091014925491009a5fe0db64608443c7c899e1cdac3dba5c3bb6"

URI_aarch64_rust-rav1e+signal_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+signal_support-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+signal_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+signal_support-devel}"
SRC_URI[aarch64_rust-rav1e+signal_support-devel.sha256sum] = "55908ee4eb0de8da71d12b2c58ba078b170ee4440d05778f73aa7e0d3a9b63cc"

URI_aarch64_rust-rav1e+threading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+threading-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+threading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+threading-devel}"
SRC_URI[aarch64_rust-rav1e+threading-devel.sha256sum] = "10ea62d03d66d1527de58bed897ff105ad561d6ed7bf368c7cf1764ae8e4f2c9"

URI_aarch64_rust-rav1e+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+toml-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+toml-devel}"
SRC_URI[aarch64_rust-rav1e+toml-devel.sha256sum] = "a5bfa83a15a8cacf1781febf47977079ba115bd2f4f99faa40fd1ff8d1e8eef4"

URI_aarch64_rust-rav1e+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+unstable-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+unstable-devel}"
SRC_URI[aarch64_rust-rav1e+unstable-devel.sha256sum] = "2419ab6497b83c493e65041854315e0ff352302e018c87981b21abe2d9ed0838"

URI_aarch64_rust-rav1e+y4m-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+y4m-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e+y4m-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+y4m-devel}"
SRC_URI[aarch64_rust-rav1e+y4m-devel.sha256sum] = "345c76774c08aa937ccb70f8d7ef7725b18dfa094873dd24b0ec8e05b467b6db"

URI_aarch64_rust-rav1e-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e-devel-0.7.1-4.el10_0.noarch.rpm;name=aarch64_rust-rav1e-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e-devel}"
SRC_URI[aarch64_rust-rav1e-devel.sha256sum] = "f959a2dc4c7f5cc9ef47191497201cb32385de39eb3f2324611feea62932c8cc"

RDEPENDS:rav1e = " \
 glibc \
 libgcc \
 "
RDEPENDS:rav1e-devel = " \
 pkgconf-pkg-config \
 rav1e-libs \
 "
RDEPENDS:rav1e-libs = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-rav1e+asm-devel = " \
 cargo \
 rust-rav1e+cc-devel \
 rust-rav1e+nasm-rs-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+av-metrics-devel = " \
 cargo \
 rust-av-metrics-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+binaries-devel = " \
 cargo \
 rust-rav1e+av-metrics-devel \
 rust-rav1e+clap-devel \
 rust-rav1e+clap_complete-devel \
 rust-rav1e+console-devel \
 rust-rav1e+fern-devel \
 rust-rav1e+ivf-devel \
 rust-rav1e+nom-devel \
 rust-rav1e+scan_fmt-devel \
 rust-rav1e+y4m-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+capi-devel = " \
 cargo \
 rust-rav1e+scan_fmt-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+cc-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+channel-api-devel = " \
 cargo \
 rust-rav1e+crossbeam-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+check_asm-devel = " \
 cargo \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+clap-devel = " \
 cargo \
 rust-clap+color-devel \
 rust-clap+derive-devel \
 rust-clap+std-devel \
 rust-clap+wrap_help-devel \
 rust-clap-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+clap_complete-devel = " \
 cargo \
 rust-clap_complete+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+console-devel = " \
 cargo \
 rust-console+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+crossbeam-devel = " \
 cargo \
 rust-crossbeam+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+default-devel = " \
 cargo \
 rust-rav1e+asm-devel \
 rust-rav1e+binaries-devel \
 rust-rav1e+signal_support-devel \
 rust-rav1e+threading-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+desync_finder-devel = " \
 cargo \
 rust-rav1e+backtrace-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+dump_ivf-devel = " \
 cargo \
 rust-rav1e+ivf-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+fern-devel = " \
 cargo \
 rust-fern0.6+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+ivf-devel = " \
 cargo \
 rust-ivf+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+nasm-rs-devel = " \
 cargo \
 rust-nasm-rs+default-devel \
 rust-nasm-rs+parallel-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+nom-devel = " \
 cargo \
 rust-nom+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+quick_test-devel = " \
 cargo \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+scan_fmt-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-scan_fmt-devel \
 "
RDEPENDS:rust-rav1e+scenechange-devel = " \
 cargo \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+serde-big-array-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-serde-big-array+default-devel \
 "
RDEPENDS:rust-rav1e+serde-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rav1e+serialize-devel = " \
 cargo \
 rust-av1-grain+serialize-devel \
 rust-rav1e+serde-big-array-devel \
 rust-rav1e+serde-devel \
 rust-rav1e+toml-devel \
 rust-rav1e-devel \
 rust-v_frame+serialize-devel \
 "
RDEPENDS:rust-rav1e+signal-hook-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-signal-hook+default-devel \
 "
RDEPENDS:rust-rav1e+signal_support-devel = " \
 cargo \
 rust-rav1e+signal-hook-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+threading-devel = " \
 cargo \
 rust-maybe-rayon+threads-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+toml-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-toml+default-devel \
 "
RDEPENDS:rust-rav1e+unstable-devel = " \
 cargo \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+y4m-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-y4m+default-devel \
 "
RDEPENDS:rust-rav1e-devel = " \
 cargo \
 rust \
 rust-arg_enum_proc_macro+default-devel \
 rust-arrayvec+default-devel \
 rust-av1-grain+default-devel \
 rust-bitstream-io+default-devel \
 rust-cfg-if+default-devel \
 rust-itertools0.13+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-maybe-rayon-devel \
 rust-new_debug_unreachable+default-devel \
 rust-noop_proc_macro+default-devel \
 rust-num-derive+default-devel \
 rust-num-traits+default-devel \
 rust-once_cell+default-devel \
 rust-paste+default-devel \
 rust-simd_helpers+default-devel \
 rust-thiserror1+default-devel \
 rust-v_frame+default-devel \
 "
