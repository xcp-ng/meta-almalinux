# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "supernovas"
PV = "1.5.1"
PR = "2.el10_2"
PACKAGES = " \
 supernovas \
 supernovas-devel \
 supernovas-doc \
 supernovas-solsys-calceph \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/supernovas-1.5.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a152bbefd22370b81b90b8bcf1dba0245890dc83ea775f50c48c54d9fc3ac23"

URI_x86_64_v2_supernovas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-1.5.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_supernovas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas}"
SRC_URI[x86_64_v2_supernovas.sha256sum] = "f996b0eaaec23d2b59045de0484c463f4340fe3015b2c896642a55f00892d4de"

URI_x86_64_v2_supernovas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-devel-1.5.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_supernovas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas-devel}"
SRC_URI[x86_64_v2_supernovas-devel.sha256sum] = "917bf82d4dd55c22cf0705242d8571a17ad898cc4f36e1919cdd9d7a74446b17"

URI_x86_64_v2_supernovas-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-doc-1.5.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_supernovas-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas-doc}"
SRC_URI[x86_64_v2_supernovas-doc.sha256sum] = "bae871a0449be04d039888966ff01085d7d0e636d1a06e2f770fd57dd3ce80bd"

URI_x86_64_v2_supernovas-solsys-calceph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-solsys-calceph-1.5.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_supernovas-solsys-calceph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas-solsys-calceph}"
SRC_URI[x86_64_v2_supernovas-solsys-calceph.sha256sum] = "c44314a0340b9068f43e0f4b3395c0f447e2e4808cd8aee21a12b2566cb037ed"

URI_aarch64_supernovas = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-1.5.1-2.el10_2.aarch64.rpm;name=aarch64_supernovas;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas}"
SRC_URI[aarch64_supernovas.sha256sum] = "376a9c96952c421754303fb83b6b63cc036047e8ca7834951c564e739d4610cb"

URI_aarch64_supernovas-devel = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-devel-1.5.1-2.el10_2.aarch64.rpm;name=aarch64_supernovas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas-devel}"
SRC_URI[aarch64_supernovas-devel.sha256sum] = "c95055e06500b66f01e26706c13d93ba612e4df82ee186e43f86a2f597288b40"

URI_aarch64_supernovas-doc = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-doc-1.5.1-2.el10_2.noarch.rpm;name=aarch64_supernovas-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas-doc}"
SRC_URI[aarch64_supernovas-doc.sha256sum] = "63896a1b8b11ad11aa93362d60a941fb126cf12144ee3278173670184373815b"

URI_aarch64_supernovas-solsys-calceph = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-solsys-calceph-1.5.1-2.el10_2.aarch64.rpm;name=aarch64_supernovas-solsys-calceph;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas-solsys-calceph}"
SRC_URI[aarch64_supernovas-solsys-calceph.sha256sum] = "19b22f31bf2439e05c5385f754eb3a5bd8f825dc19927fa9b6d978793a0a9508"

RDEPENDS:supernovas = " \
 glibc \
 "
RDEPENDS:supernovas-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 supernovas \
 supernovas-solsys-calceph \
 "
RDEPENDS:supernovas-doc = " \
 "
RDEPENDS:supernovas-solsys-calceph = " \
 calceph-libs \
 glibc \
 supernovas \
 "
