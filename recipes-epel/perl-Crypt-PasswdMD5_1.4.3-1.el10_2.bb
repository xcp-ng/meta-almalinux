# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-PasswdMD5"
PV = "1.4.3"
PR = "1.el10_2"
PACKAGES = " \
 perl-Crypt-PasswdMD5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-PasswdMD5-1.4.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36a5f6f9f9b43a4985014cfee7191ae29629f2155e6e19846d0c745372461420"

URI_x86_64_v2_perl-Crypt-PasswdMD5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-PasswdMD5-1.4.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-PasswdMD5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-PasswdMD5}"
SRC_URI[x86_64_v2_perl-Crypt-PasswdMD5.sha256sum] = "6875fdc3d1796989577aa6a2c858c4d63b0afee67354d1ecc3c572f084e44bae"

URI_aarch64_perl-Crypt-PasswdMD5 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-PasswdMD5-1.4.3-1.el10_2.noarch.rpm;name=aarch64_perl-Crypt-PasswdMD5;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-PasswdMD5}"
SRC_URI[aarch64_perl-Crypt-PasswdMD5.sha256sum] = "bf699cdea93acb376071a9af5962e46bb3d11169124173338ab6a3cc6b8dd27d"

RDEPENDS:perl-Crypt-PasswdMD5 = " \
 perl-Crypt-URandom \
 perl-Digest-MD5 \
 perl-Encode \
 perl-Exporter \
 perl-libs \
 "
