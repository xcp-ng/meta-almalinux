# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akmods"
PV = "0.6.2"
PR = "1.el10_0"
PACKAGES = " \
 akmods \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akmods-0.6.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2151d9eeeab2bd585c3836102a916c37cf8405546ba22eba19751008f215613e"

URI_x86_64_v2_akmods = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akmods-0.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_akmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akmods}"
SRC_URI[x86_64_v2_akmods.sha256sum] = "7b0f6e2963f5be9cd39e70c9d1a40565d53fff88553454136979194d35d10341"

URI_aarch64_akmods = "${EPEL_MIRROR}/aarch64/Packages/a/akmods-0.6.2-1.el10_0.noarch.rpm;name=aarch64_akmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_akmods}"
SRC_URI[aarch64_akmods.sha256sum] = "2b1492541b74078b3a03b555900475ce96e2d04f11397ed38ab56b79c5390ead"

RDEPENDS:akmods = " \
 bash \
 bzip2 \
 diffutils \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 grubby \
 gzip \
 kernel-abi-stablelists \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmodtool \
 make \
 openssl \
 rpm-build \
 rpmdevtools \
 sed \
 systemd \
 tar \
 time \
 unzip \
 util-linux \
 util-linux-core \
 virtual/coreutils \
 virtual/kernel-devel-uname-r \
 "
