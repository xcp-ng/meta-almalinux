# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-palette"
PV = "0.7.5"
PR = "4.el10_1"
PACKAGES = " \
 rust-palette+alloc-devel \
 rust-palette+approx-devel \
 rust-palette+bytemuck-devel \
 rust-palette+default-devel \
 rust-palette+find-crate-devel \
 rust-palette+libm-devel \
 rust-palette+named-devel \
 rust-palette+named_from_str-devel \
 rust-palette+phf-devel \
 rust-palette+rand-devel \
 rust-palette+random-devel \
 rust-palette+serde-devel \
 rust-palette+serializing-devel \
 rust-palette+std-devel \
 rust-palette+wide-devel \
 rust-palette-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-palette-0.7.5-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56fd6085abeeb7cd5e8f414d75e28d46ab99089c7587a41d8c27a994bcb19df6"

URI_x86_64_v2_rust-palette+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+alloc-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+alloc-devel}"
SRC_URI[x86_64_v2_rust-palette+alloc-devel.sha256sum] = "dc98616906c78156e95c08a7914830651ae4bb64325006bd69d9b78d468bc9b7"

URI_x86_64_v2_rust-palette+approx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+approx-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+approx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+approx-devel}"
SRC_URI[x86_64_v2_rust-palette+approx-devel.sha256sum] = "9696c6b5aefa47a1f0fdcee3c2a752d005f87fee30815c2d806f400ab2c56b4e"

URI_x86_64_v2_rust-palette+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+bytemuck-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-palette+bytemuck-devel.sha256sum] = "46804e7601f290197b8b664ba83b080e1d445846a54a72034568435b9b6d00b6"

URI_x86_64_v2_rust-palette+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+default-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+default-devel}"
SRC_URI[x86_64_v2_rust-palette+default-devel.sha256sum] = "05de7422571d29f6e3d8f178b0956602ed4a67d755c83825c8b7c36dbfbc9117"

URI_x86_64_v2_rust-palette+find-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+find-crate-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+find-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+find-crate-devel}"
SRC_URI[x86_64_v2_rust-palette+find-crate-devel.sha256sum] = "2a769ae624329de16d340d6a2692ae5497d4cd5500226397bd29eea08ef7c593"

URI_x86_64_v2_rust-palette+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+libm-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+libm-devel}"
SRC_URI[x86_64_v2_rust-palette+libm-devel.sha256sum] = "474a18d2865623d961837019fd91a6e404415ced342c5f737dd432692a62506e"

URI_x86_64_v2_rust-palette+named-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+named-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+named-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+named-devel}"
SRC_URI[x86_64_v2_rust-palette+named-devel.sha256sum] = "2101a57f1bdc9baa9c031ebe2717debe06e0f9da0308995d8c30e71b52164ccb"

URI_x86_64_v2_rust-palette+named_from_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+named_from_str-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+named_from_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+named_from_str-devel}"
SRC_URI[x86_64_v2_rust-palette+named_from_str-devel.sha256sum] = "cfbd6011fb11607f12bf6cde96fcf713ab9b66df67946c7796a20a3db45675f9"

URI_x86_64_v2_rust-palette+phf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+phf-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+phf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+phf-devel}"
SRC_URI[x86_64_v2_rust-palette+phf-devel.sha256sum] = "ba38876c5a71949ef611f82e8c859639b2e07099e69ac3da25e772e4ff451f4b"

URI_x86_64_v2_rust-palette+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+rand-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+rand-devel}"
SRC_URI[x86_64_v2_rust-palette+rand-devel.sha256sum] = "f14e84413534af0389086c35013a4b9fed4b9bcf87acdd8981e7e8b07d2d5b65"

URI_x86_64_v2_rust-palette+random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+random-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+random-devel}"
SRC_URI[x86_64_v2_rust-palette+random-devel.sha256sum] = "b490ba6bb3725865be5738fa606633d953eb755b70cc0b789f1c922721e0818a"

URI_x86_64_v2_rust-palette+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+serde-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+serde-devel}"
SRC_URI[x86_64_v2_rust-palette+serde-devel.sha256sum] = "22f7bafd4e1214b6568e7a2cf123b4524aef23431b72f6d972ff9158055bfec4"

URI_x86_64_v2_rust-palette+serializing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+serializing-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+serializing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+serializing-devel}"
SRC_URI[x86_64_v2_rust-palette+serializing-devel.sha256sum] = "d268b0bdd64b5345f8e8acf1d3571b407122966d3174d905418f0d43f0292b04"

URI_x86_64_v2_rust-palette+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+std-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+std-devel}"
SRC_URI[x86_64_v2_rust-palette+std-devel.sha256sum] = "f1ed08462486c43b03affa606abd26a67193f63ca6c33432d75670b23626153e"

URI_x86_64_v2_rust-palette+wide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette+wide-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette+wide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette+wide-devel}"
SRC_URI[x86_64_v2_rust-palette+wide-devel.sha256sum] = "d173e2c24c799eb273b96f4c63ba66d690f62ea6bb762ab446402cc2ecf80f67"

URI_x86_64_v2_rust-palette-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-palette-devel-0.7.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-palette-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-palette-devel}"
SRC_URI[x86_64_v2_rust-palette-devel.sha256sum] = "53fc9ea2a96ca0f362a1f13a738a2153e28e42ac8cdfd0e233b395e854ad80b7"

URI_aarch64_rust-palette+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+alloc-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+alloc-devel}"
SRC_URI[aarch64_rust-palette+alloc-devel.sha256sum] = "cbfbeff23832de1c5337a05d9df4300854f163775e864345afcb3a0056bdb0e3"

URI_aarch64_rust-palette+approx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+approx-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+approx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+approx-devel}"
SRC_URI[aarch64_rust-palette+approx-devel.sha256sum] = "5d81f977584d6d0ab855a630319336518d5e770ec3571c811028bae39f3ae444"

URI_aarch64_rust-palette+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+bytemuck-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+bytemuck-devel}"
SRC_URI[aarch64_rust-palette+bytemuck-devel.sha256sum] = "2a1f87eb31b92858b1982ce06deddc16dc1b0db08beed81238c67b2a4351e4e9"

URI_aarch64_rust-palette+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+default-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+default-devel}"
SRC_URI[aarch64_rust-palette+default-devel.sha256sum] = "5a691c0bf9385e93ad9e4009dbd05974152295ddc63ea182daa8436fc6b410de"

URI_aarch64_rust-palette+find-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+find-crate-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+find-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+find-crate-devel}"
SRC_URI[aarch64_rust-palette+find-crate-devel.sha256sum] = "bdc22396bf0975eab4d5af7840729b679cf2b110dad2af751452fa7f2ebd9daf"

URI_aarch64_rust-palette+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+libm-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+libm-devel}"
SRC_URI[aarch64_rust-palette+libm-devel.sha256sum] = "98ea8846287bcc030bfb94cd4877328947c0f95982d85372353713993e297585"

URI_aarch64_rust-palette+named-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+named-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+named-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+named-devel}"
SRC_URI[aarch64_rust-palette+named-devel.sha256sum] = "2f3c49bc9cab74d29e559370704a9ae14688ed403eafa1afba48248b5807699d"

URI_aarch64_rust-palette+named_from_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+named_from_str-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+named_from_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+named_from_str-devel}"
SRC_URI[aarch64_rust-palette+named_from_str-devel.sha256sum] = "781ccc58173e767cb685f01e872174610e87049bf3372f4a540f341b72528f23"

URI_aarch64_rust-palette+phf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+phf-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+phf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+phf-devel}"
SRC_URI[aarch64_rust-palette+phf-devel.sha256sum] = "ac257769aefd5a38d04f4be0fd9bfebb742eb44c6725d7f5bd5e5ca1cb72fa5e"

URI_aarch64_rust-palette+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+rand-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+rand-devel}"
SRC_URI[aarch64_rust-palette+rand-devel.sha256sum] = "1af2dbf16d17b95274204706a71985da3b19c3145a8ed1fa59dd20590efc27d5"

URI_aarch64_rust-palette+random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+random-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+random-devel}"
SRC_URI[aarch64_rust-palette+random-devel.sha256sum] = "79f835473a56ac6da920c543d6deb09f9f30ec0ccc30e48bd25ff558b1ed7273"

URI_aarch64_rust-palette+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+serde-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+serde-devel}"
SRC_URI[aarch64_rust-palette+serde-devel.sha256sum] = "feddfae27c4bc114c01935724201b3ca1f219d1ace3c1ec7ad2a6d17e341537a"

URI_aarch64_rust-palette+serializing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+serializing-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+serializing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+serializing-devel}"
SRC_URI[aarch64_rust-palette+serializing-devel.sha256sum] = "0ce92eae82318a0883d68daf552a411f4629acd8d159ee6ae14f1642148e3c6d"

URI_aarch64_rust-palette+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+std-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+std-devel}"
SRC_URI[aarch64_rust-palette+std-devel.sha256sum] = "6eb696e45f5d05adfe6f04f185b71f711cc2a28aba19c4c3faf7fd5afdf989e7"

URI_aarch64_rust-palette+wide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette+wide-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette+wide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette+wide-devel}"
SRC_URI[aarch64_rust-palette+wide-devel.sha256sum] = "5956bdab1962ac739744c8952773991a660d1165a5c7844bfe990e253dcff8cd"

URI_aarch64_rust-palette-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-palette-devel-0.7.5-4.el10_1.noarch.rpm;name=aarch64_rust-palette-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-palette-devel}"
SRC_URI[aarch64_rust-palette-devel.sha256sum] = "167a8ebe5b86294da0ed50c8dd977b732d93067c8b44145812ee7767949052c6"

RDEPENDS:rust-palette+alloc-devel = " \
 cargo \
 rust-palette-devel \
 "
RDEPENDS:rust-palette+approx-devel = " \
 cargo \
 rust-approx-devel \
 rust-palette-devel \
 "
RDEPENDS:rust-palette+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-palette-devel \
 "
RDEPENDS:rust-palette+default-devel = " \
 cargo \
 rust-palette+approx-devel \
 rust-palette+named_from_str-devel \
 rust-palette+std-devel \
 rust-palette-devel \
 "
RDEPENDS:rust-palette+find-crate-devel = " \
 cargo \
 rust-palette-devel \
 rust-palette_derive+find-crate-devel \
 "
RDEPENDS:rust-palette+libm-devel = " \
 cargo \
 rust-libm-devel \
 rust-palette-devel \
 "
RDEPENDS:rust-palette+named-devel = " \
 cargo \
 rust-palette-devel \
 "
RDEPENDS:rust-palette+named_from_str-devel = " \
 cargo \
 rust-palette+named-devel \
 rust-palette+phf-devel \
 rust-palette-devel \
 "
RDEPENDS:rust-palette+phf-devel = " \
 cargo \
 rust-palette-devel \
 rust-phf0.11+macros-devel \
 rust-phf0.11-devel \
 "
RDEPENDS:rust-palette+rand-devel = " \
 cargo \
 rust-palette-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-palette+random-devel = " \
 cargo \
 rust-palette+rand-devel \
 rust-palette-devel \
 "
RDEPENDS:rust-palette+serde-devel = " \
 cargo \
 rust-palette-devel \
 rust-serde+default-devel \
 rust-serde+serde_derive-devel \
 "
RDEPENDS:rust-palette+serializing-devel = " \
 cargo \
 rust-palette+serde-devel \
 rust-palette+std-devel \
 rust-palette-devel \
 "
RDEPENDS:rust-palette+std-devel = " \
 cargo \
 rust-approx+std-devel \
 rust-approx-devel \
 rust-palette+alloc-devel \
 rust-palette-devel \
 "
RDEPENDS:rust-palette+wide-devel = " \
 cargo \
 rust-palette-devel \
 rust-wide-devel \
 "
RDEPENDS:rust-palette-devel = " \
 cargo \
 rust \
 rust-fast-srgb8+default-devel \
 rust-palette_derive+default-devel \
 "
