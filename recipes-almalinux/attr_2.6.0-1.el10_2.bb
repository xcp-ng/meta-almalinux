# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "attr"
PV = "2.6.0"
PR = "1.el10_2"
PACKAGES = " \
 attr \
 libattr \
 libattr-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/attr-2.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bf4dd40762555f1d37f863697c5bd8a5364290095ab432a7e4e53ae41c865413"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/attr-2.6.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_attr;unpack=0"
SRC_URI[x86_64_v2_attr.sha256sum] = "e1543ffd12b2fc48707d0dd824d49822a85e997516f2477e66e27a815675852b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libattr-2.6.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libattr;unpack=0"
SRC_URI[x86_64_v2_libattr.sha256sum] = "cdc8e19d1a1833dd79eed950d69d85d2579b0b261c71d303082c6c1739caf091"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libattr-devel-2.6.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libattr-devel;unpack=0"
SRC_URI[x86_64_v2_libattr-devel.sha256sum] = "94f0b9d2b4d83423a7fec6defe8bc07f659c28e2c51c167229eed854ea078fe6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/attr-2.6.0-1.el10_2.aarch64.rpm;name=aarch64_attr;unpack=0"
SRC_URI[aarch64_attr.sha256sum] = "4b89c2349801aa4b95e21999ac140c3eb1e94e602d441621e296e06f9f34fa9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libattr-2.6.0-1.el10_2.aarch64.rpm;name=aarch64_libattr;unpack=0"
SRC_URI[aarch64_libattr.sha256sum] = "e101ef8e324ffef193f374a93c0255bffb4743ffb135a56465529cd2d048ce73"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libattr-devel-2.6.0-1.el10_2.aarch64.rpm;name=aarch64_libattr-devel;unpack=0"
SRC_URI[aarch64_libattr-devel.sha256sum] = "b6629f41cdbf0130ea03eaea93ca98e4fa9c0e4b2241937b555638a8be9a3cda"

RDEPENDS:attr = " \
 glibc \
 libattr \
 "
RDEPENDS:libattr = " \
 glibc \
 "
RDEPENDS:libattr-devel = " \
 glibc-devel \
 libattr \
 pkgconf-pkg-config \
 "
