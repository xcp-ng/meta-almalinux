# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-iovec"
PV = "0.1.4"
PR = "14.el10_0"
PACKAGES = " \
 rust-iovec+default-devel \
 rust-iovec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-iovec-0.1.4-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "643f353dda6dd147663d69c90b400dd4e1482c8fb82c658d47f300386b405101"

URI_x86_64_v2_rust-iovec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iovec+default-devel-0.1.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iovec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iovec+default-devel}"
SRC_URI[x86_64_v2_rust-iovec+default-devel.sha256sum] = "7fb1c0b3a6b0a963a0ed7dfaf0e9c8651f753a5b6aa47c336405d6cec240fc26"

URI_x86_64_v2_rust-iovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iovec-devel-0.1.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iovec-devel}"
SRC_URI[x86_64_v2_rust-iovec-devel.sha256sum] = "f4fbb1ef78e6c32edabae4706fc4d676cf94173313a8e37e56bdb4bbe8bf43c7"

URI_aarch64_rust-iovec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iovec+default-devel-0.1.4-14.el10_0.noarch.rpm;name=aarch64_rust-iovec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iovec+default-devel}"
SRC_URI[aarch64_rust-iovec+default-devel.sha256sum] = "10df34b06c8a9d6e5ef8cea2a469422cc752f8eb40ba4fa83f0132f7dc2cc4c0"

URI_aarch64_rust-iovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iovec-devel-0.1.4-14.el10_0.noarch.rpm;name=aarch64_rust-iovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iovec-devel}"
SRC_URI[aarch64_rust-iovec-devel.sha256sum] = "ed7ab34418b87b662f20796ae57def98b61d62210391bdfab8e58ce6cef8bbe1"

RDEPENDS:rust-iovec+default-devel = " \
 cargo \
 rust-iovec-devel \
 "
RDEPENDS:rust-iovec-devel = " \
 cargo \
 rust-libc+default-devel \
 "
