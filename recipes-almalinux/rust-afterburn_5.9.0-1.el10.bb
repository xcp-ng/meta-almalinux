# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-afterburn"
PV = "5.9.0"
PR = "1.el10"
PACKAGES = " \
 afterburn \
 afterburn-dracut \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-afterburn-5.9.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "be743fc2a07a3b0e6ff1a66ac1fc73c54ff9b3587c64e5731acb32973dd7b80d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/afterburn-5.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_afterburn;unpack=0"
SRC_URI[x86_64_v2_afterburn.sha256sum] = "9cbe9d971d7921e5fc834b798dd19819780502f5195c2249ec12c3048d7f34d4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/afterburn-dracut-5.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_afterburn-dracut;unpack=0"
SRC_URI[x86_64_v2_afterburn-dracut.sha256sum] = "04f853bb79f88eda2c79294387b6250d2ea334194f05f08ebc7db9d9cd279dbc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/afterburn-5.9.0-1.el10.aarch64.rpm;name=aarch64_afterburn;unpack=0"
SRC_URI[aarch64_afterburn.sha256sum] = "bf82753deb51f7dba90c78221dea501c8d972ade8e244cbb0dbb48cd79d790d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/afterburn-dracut-5.9.0-1.el10.aarch64.rpm;name=aarch64_afterburn-dracut;unpack=0"
SRC_URI[aarch64_afterburn-dracut.sha256sum] = "3ff0736f75241b976b9415e31353493472193f2344944a075e7e184feb527a35"

RDEPENDS:afterburn = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 systemd \
 "
RDEPENDS:afterburn-dracut = " \
 afterburn \
 bash \
 dracut \
 dracut-network \
 "
