# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdf"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdf-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33f8c4df020dacd92ed889c601e85c5f638e452aee4e7061cb3909d2797a37e8"

URI_x86_64_v2_kdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdf-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdf}"
SRC_URI[x86_64_v2_kdf.sha256sum] = "cb89c91616159b0930a24edecac5d43835f9b04db69b96694f2b6da4785aceb2"

URI_aarch64_kdf = "${EPEL_MIRROR}/aarch64/Packages/k/kdf-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdf}"
SRC_URI[aarch64_kdf.sha256sum] = "494a6c7b59fe0c6c33022e8b3af743f7af30be25e56f93ea8775be3ae88512b0"

RDEPENDS:kdf = " \
 glibc \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
