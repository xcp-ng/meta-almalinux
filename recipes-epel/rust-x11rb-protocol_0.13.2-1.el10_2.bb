# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-x11rb-protocol"
PV = "0.13.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-x11rb-protocol+all-extensions-devel \
 rust-x11rb-protocol+composite-devel \
 rust-x11rb-protocol+damage-devel \
 rust-x11rb-protocol+dbe-devel \
 rust-x11rb-protocol+default-devel \
 rust-x11rb-protocol+dpms-devel \
 rust-x11rb-protocol+dri2-devel \
 rust-x11rb-protocol+dri3-devel \
 rust-x11rb-protocol+extra-traits-devel \
 rust-x11rb-protocol+glx-devel \
 rust-x11rb-protocol+present-devel \
 rust-x11rb-protocol+randr-devel \
 rust-x11rb-protocol+record-devel \
 rust-x11rb-protocol+render-devel \
 rust-x11rb-protocol+request-parsing-devel \
 rust-x11rb-protocol+res-devel \
 rust-x11rb-protocol+resource_manager-devel \
 rust-x11rb-protocol+screensaver-devel \
 rust-x11rb-protocol+serde-devel \
 rust-x11rb-protocol+shape-devel \
 rust-x11rb-protocol+shm-devel \
 rust-x11rb-protocol+std-devel \
 rust-x11rb-protocol+sync-devel \
 rust-x11rb-protocol+xevie-devel \
 rust-x11rb-protocol+xf86dri-devel \
 rust-x11rb-protocol+xf86vidmode-devel \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol+xinerama-devel \
 rust-x11rb-protocol+xinput-devel \
 rust-x11rb-protocol+xkb-devel \
 rust-x11rb-protocol+xprint-devel \
 rust-x11rb-protocol+xselinux-devel \
 rust-x11rb-protocol+xtest-devel \
 rust-x11rb-protocol+xv-devel \
 rust-x11rb-protocol+xvmc-devel \
 rust-x11rb-protocol-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-x11rb-protocol-0.13.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "560498d3481dbc092dd6f62725a1b7ad4abc00d0e4c05e6a946d3ca3e561a67e"

URI_x86_64_v2_rust-x11rb-protocol+all-extensions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+all-extensions-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+all-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+all-extensions-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+all-extensions-devel.sha256sum] = "39cfa5ee7c73f5d93617d1b0e8f47daf0c5e4663d7cb2cbf92da810e5438570d"

URI_x86_64_v2_rust-x11rb-protocol+composite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+composite-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+composite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+composite-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+composite-devel.sha256sum] = "8242c9c673e225927f40899503f28ae4ac17b14ea64d487cc0876d4b8cdef428"

URI_x86_64_v2_rust-x11rb-protocol+damage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+damage-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+damage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+damage-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+damage-devel.sha256sum] = "bec5b5ffa9ac3c231a848c9050b95fe5e074741f63e17443ea17de95dbab7644"

URI_x86_64_v2_rust-x11rb-protocol+dbe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+dbe-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+dbe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+dbe-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+dbe-devel.sha256sum] = "a68621647613ed8cd0605f29ae0d46876823b594c1adee7ff14e7978a252185c"

URI_x86_64_v2_rust-x11rb-protocol+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+default-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+default-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+default-devel.sha256sum] = "4a9f6aca797819f58ca22f37af896ec08013a77b1e23ecaf1dbb66758ce242ba"

URI_x86_64_v2_rust-x11rb-protocol+dpms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+dpms-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+dpms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+dpms-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+dpms-devel.sha256sum] = "b7098bb2d8f2b07068fd8251abe7a66a60d86d5c05d80c7c6e6b58cd0cf58a96"

URI_x86_64_v2_rust-x11rb-protocol+dri2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+dri2-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+dri2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+dri2-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+dri2-devel.sha256sum] = "942fcabc79cb4539515bd934a67f09cba2f8568ede21652049e07bd05a678c15"

URI_x86_64_v2_rust-x11rb-protocol+dri3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+dri3-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+dri3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+dri3-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+dri3-devel.sha256sum] = "1abed2dcbdf769e5589df0d7cab180b853d99cc6823e43204ca32cd881c828b6"

URI_x86_64_v2_rust-x11rb-protocol+extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+extra-traits-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+extra-traits-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+extra-traits-devel.sha256sum] = "2838c9f2ccbe0935d83b43935731911a91b3342890431c5ad12bcc3ca9941019"

URI_x86_64_v2_rust-x11rb-protocol+glx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+glx-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+glx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+glx-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+glx-devel.sha256sum] = "9572c5a7623c82345e73f30fcda64e61a951b917adeef1db8223d36b73a672c0"

URI_x86_64_v2_rust-x11rb-protocol+present-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+present-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+present-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+present-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+present-devel.sha256sum] = "19d97453e4ae599ca0ddc151ce4ae35770fa6badc02e5460cf187cdc2fc1ad94"

URI_x86_64_v2_rust-x11rb-protocol+randr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+randr-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+randr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+randr-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+randr-devel.sha256sum] = "0b8e68622f50b263cc362056d4830eae8df08d14495a8bd31534d7974457d487"

URI_x86_64_v2_rust-x11rb-protocol+record-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+record-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+record-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+record-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+record-devel.sha256sum] = "af1a6dc3144bc5bd13b3885e24b65782555666e0868c2916085ce5aab6cf0ac5"

URI_x86_64_v2_rust-x11rb-protocol+render-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+render-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+render-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+render-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+render-devel.sha256sum] = "a94efa139d3731ee18a91cde623bd38d6337ee1a1df1bb4eceba6317a36221ef"

URI_x86_64_v2_rust-x11rb-protocol+request-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+request-parsing-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+request-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+request-parsing-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+request-parsing-devel.sha256sum] = "215b60838d8eaa139a17d23ac81574b0733c4c17cd804b2c2204a7356e1215a5"

URI_x86_64_v2_rust-x11rb-protocol+res-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+res-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+res-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+res-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+res-devel.sha256sum] = "d6a1527408688b7ab51d06b77f3ff431a06f73ebbe06fd8997b5b5d9a1b760a6"

URI_x86_64_v2_rust-x11rb-protocol+resource_manager-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+resource_manager-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+resource_manager-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+resource_manager-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+resource_manager-devel.sha256sum] = "265d942e9cf3611f914ad0ca27ca8b7c64b6608bb8414759c474911bf776e8cf"

URI_x86_64_v2_rust-x11rb-protocol+screensaver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+screensaver-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+screensaver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+screensaver-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+screensaver-devel.sha256sum] = "ca2691523639a9a207dc10365716ce75816b33e0e7885054da960d514d166b66"

URI_x86_64_v2_rust-x11rb-protocol+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+serde-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+serde-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+serde-devel.sha256sum] = "7c272228253ffd1a95f73b0d0b49861620a6a6a184eac31c541a182d7100400a"

URI_x86_64_v2_rust-x11rb-protocol+shape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+shape-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+shape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+shape-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+shape-devel.sha256sum] = "84c5e070dfcf8d32b26ff905c407d3d908823c41a5d878511322445a68f3aed5"

URI_x86_64_v2_rust-x11rb-protocol+shm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+shm-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+shm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+shm-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+shm-devel.sha256sum] = "8a15d1e6055d9c6ef8931128e32e5b9542d34e5eceb3b7d5c576c389cfdb1b4d"

URI_x86_64_v2_rust-x11rb-protocol+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+std-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+std-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+std-devel.sha256sum] = "3510ddc06ab45b60f787129859961f06dc29f58e392b3a5dcdcf348f1d9df9ab"

URI_x86_64_v2_rust-x11rb-protocol+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+sync-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+sync-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+sync-devel.sha256sum] = "447113055cdfb6c15f3c76fa94ee423cede32c6466073448c7b116df8cbee6e7"

URI_x86_64_v2_rust-x11rb-protocol+xevie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xevie-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xevie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xevie-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xevie-devel.sha256sum] = "8865d7468220aab6c7d91a9dd3b2db38690b400f478946e6c16a9925405da831"

URI_x86_64_v2_rust-x11rb-protocol+xf86dri-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xf86dri-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xf86dri-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xf86dri-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xf86dri-devel.sha256sum] = "dc85822633797899a5399df29b0e2052af6a077e14d063572c77763fa2e470fa"

URI_x86_64_v2_rust-x11rb-protocol+xf86vidmode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xf86vidmode-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xf86vidmode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xf86vidmode-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xf86vidmode-devel.sha256sum] = "5d8322ca33fa5268629e217b1d4b00e78d8f6a439c02105067f99e30cc334285"

URI_x86_64_v2_rust-x11rb-protocol+xfixes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xfixes-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xfixes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xfixes-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xfixes-devel.sha256sum] = "91c9501c98534b99855ee6606de47e2a03cd571e3f0df0d9a9a0bdfe3183553c"

URI_x86_64_v2_rust-x11rb-protocol+xinerama-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xinerama-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xinerama-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xinerama-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xinerama-devel.sha256sum] = "796370cb61c2e3b6aa64a446a685d73685107e07281e2cd022d13fb3cd290b62"

URI_x86_64_v2_rust-x11rb-protocol+xinput-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xinput-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xinput-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xinput-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xinput-devel.sha256sum] = "a9c8ddaba49303d8c4d4db9ad9e059d90b6018793b665fbf99fa1e39c35130ae"

URI_x86_64_v2_rust-x11rb-protocol+xkb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xkb-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xkb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xkb-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xkb-devel.sha256sum] = "5453beae2ba62ddb46bd2196f2fcff33528f9053a6a474a234b9e12a2db5625f"

URI_x86_64_v2_rust-x11rb-protocol+xprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xprint-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xprint-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xprint-devel.sha256sum] = "6db92bc13a5e749a91924d98dc71eac484194dfb9cfdd11179aa5d9082313766"

URI_x86_64_v2_rust-x11rb-protocol+xselinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xselinux-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xselinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xselinux-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xselinux-devel.sha256sum] = "484e0106543411a4b9ce509bd77702bf32523b7ea341b9d242c99af6893fb802"

URI_x86_64_v2_rust-x11rb-protocol+xtest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xtest-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xtest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xtest-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xtest-devel.sha256sum] = "c2c8fdbd0332dfdf03bf7165ddf0a262e9125e1d858b1a58fdab22dbeff58c89"

URI_x86_64_v2_rust-x11rb-protocol+xv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xv-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xv-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xv-devel.sha256sum] = "dcaf5d48541ad9558f48107304d728a03fc4e1e39b8d37f06f43856cae1e5834"

URI_x86_64_v2_rust-x11rb-protocol+xvmc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol+xvmc-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol+xvmc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol+xvmc-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol+xvmc-devel.sha256sum] = "6904eedb995f171ed7d896662702333229041a78543000efe90c10ae20ad56b9"

URI_x86_64_v2_rust-x11rb-protocol-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-protocol-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-protocol-devel}"
SRC_URI[x86_64_v2_rust-x11rb-protocol-devel.sha256sum] = "dc2ae6e2d8a47527e99194b9d1d2cf848aab4dfb2858ed72240284afcdc89ef0"

URI_aarch64_rust-x11rb-protocol+all-extensions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+all-extensions-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+all-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+all-extensions-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+all-extensions-devel.sha256sum] = "2b7fe2449e474ba7c21400256c341669ae96b5d29779ddaf2339e161388565ee"

URI_aarch64_rust-x11rb-protocol+composite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+composite-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+composite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+composite-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+composite-devel.sha256sum] = "468d54fc524571c1fed7c307ddc142a11cf3041abca4b51a67cee08560461184"

URI_aarch64_rust-x11rb-protocol+damage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+damage-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+damage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+damage-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+damage-devel.sha256sum] = "6ede2dd3af010b3b9a2c4fd8a18a80a2648d145901acecc7a7053fb8a952ec27"

URI_aarch64_rust-x11rb-protocol+dbe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+dbe-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+dbe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+dbe-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+dbe-devel.sha256sum] = "207717f2293687a8f8cb1bf7f99a5795dbaad523f9a4208f6c5ad707aee7d1f9"

URI_aarch64_rust-x11rb-protocol+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+default-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+default-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+default-devel.sha256sum] = "67de2967eb240fc981e450c0e81c48ed7dc742f650a08d1223653b7cd6578a68"

URI_aarch64_rust-x11rb-protocol+dpms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+dpms-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+dpms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+dpms-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+dpms-devel.sha256sum] = "7d9773eabc509abaa417ec4cf0d419e2e388b9e7266e88fac964fc7fcbee9e1e"

URI_aarch64_rust-x11rb-protocol+dri2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+dri2-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+dri2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+dri2-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+dri2-devel.sha256sum] = "bd71f7b5f9061b80d6518c56d74ba9a789ac75e78eaeb830e19c0c9d3d0f826f"

URI_aarch64_rust-x11rb-protocol+dri3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+dri3-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+dri3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+dri3-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+dri3-devel.sha256sum] = "c65c0a776e04618ce792c3ba949939f4aa8f1cea1c7fdd628a0df6a14b17ac0f"

URI_aarch64_rust-x11rb-protocol+extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+extra-traits-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+extra-traits-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+extra-traits-devel.sha256sum] = "a9fc59659af1e6a838fafc353d9092e0736129b49c3473cb0a81c77b1a8ce145"

URI_aarch64_rust-x11rb-protocol+glx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+glx-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+glx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+glx-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+glx-devel.sha256sum] = "edaf60d211fb5f3affd1abdb610ddeec7aa6701af7fd5965d69bdb94ba854cb9"

URI_aarch64_rust-x11rb-protocol+present-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+present-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+present-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+present-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+present-devel.sha256sum] = "0db634a2417dc888552237d2659a03214e914c16667852bbe56f08b413a61154"

URI_aarch64_rust-x11rb-protocol+randr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+randr-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+randr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+randr-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+randr-devel.sha256sum] = "06818487ce44ac0f69aae79fe60dac1c2c0aaf5d10964ea0125d87969798de9a"

URI_aarch64_rust-x11rb-protocol+record-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+record-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+record-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+record-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+record-devel.sha256sum] = "dfee808408fe77727c4bf38776f0b42bc859ab15ce0c61f37b24c2a29381e559"

URI_aarch64_rust-x11rb-protocol+render-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+render-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+render-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+render-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+render-devel.sha256sum] = "9d44c71c487b2d56d10e59986faa3f00f3bf3c01a363273d99fc64c83c3bc073"

URI_aarch64_rust-x11rb-protocol+request-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+request-parsing-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+request-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+request-parsing-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+request-parsing-devel.sha256sum] = "8a4f12b6b84a8e0158259b79fbf7784ff209296af43e45c0dc35679a2fc5752f"

URI_aarch64_rust-x11rb-protocol+res-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+res-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+res-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+res-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+res-devel.sha256sum] = "f0968e84b8c3e3bd44a078140b9233eef858fc0de00444d929c034975655d71b"

URI_aarch64_rust-x11rb-protocol+resource_manager-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+resource_manager-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+resource_manager-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+resource_manager-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+resource_manager-devel.sha256sum] = "f212768d10d2cdb837bd2937293cce37f77cf2d131b4d41911e3b9a59d0b6d72"

URI_aarch64_rust-x11rb-protocol+screensaver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+screensaver-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+screensaver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+screensaver-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+screensaver-devel.sha256sum] = "ba69e89ba857a48089b44aac21a896042f9234fe3c93db309c0a0f408e8a4996"

URI_aarch64_rust-x11rb-protocol+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+serde-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+serde-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+serde-devel.sha256sum] = "720da12064d52affbb43e40bb1f20250b1f4189c4b0d29ddbddf9c677e260beb"

URI_aarch64_rust-x11rb-protocol+shape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+shape-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+shape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+shape-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+shape-devel.sha256sum] = "ef528922b9913fc863285f644df2478804fc25def791bbdac4482aad8e382341"

URI_aarch64_rust-x11rb-protocol+shm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+shm-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+shm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+shm-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+shm-devel.sha256sum] = "213c6bca75ce5c245a00ec3051cd7223b9b41440ad1a1926c9875cf79f0f7ec4"

URI_aarch64_rust-x11rb-protocol+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+std-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+std-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+std-devel.sha256sum] = "360949d4ee0f6b98026d45fa96e8ebe7de025092d4e16513d22b325c4d51fd31"

URI_aarch64_rust-x11rb-protocol+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+sync-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+sync-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+sync-devel.sha256sum] = "4ba81bb515b971137c8d3648a7d273eee5f24c94bc979f3b2d8f1ab180e641f5"

URI_aarch64_rust-x11rb-protocol+xevie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xevie-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+xevie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xevie-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xevie-devel.sha256sum] = "89154b2e9d225a1492e3ea8089d664b85d9290be9aed375b2c9f11a6184e5964"

URI_aarch64_rust-x11rb-protocol+xf86dri-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xf86dri-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+xf86dri-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xf86dri-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xf86dri-devel.sha256sum] = "905dc6dbed15520fd7ec62a7f2cf6e9a81703765e6786a6445fa662a3b275a99"

URI_aarch64_rust-x11rb-protocol+xf86vidmode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xf86vidmode-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+xf86vidmode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xf86vidmode-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xf86vidmode-devel.sha256sum] = "0c2bd71c20d54b32696be714770bb6605bc11730fccd0c8ad9d14863685e28e3"

URI_aarch64_rust-x11rb-protocol+xfixes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xfixes-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+xfixes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xfixes-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xfixes-devel.sha256sum] = "e820cabb167f8be5245b1f498a6c4862b790c786d242f822054e78e3f4be9721"

URI_aarch64_rust-x11rb-protocol+xinerama-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xinerama-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+xinerama-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xinerama-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xinerama-devel.sha256sum] = "b8dab156be12f59f392fcfee4060076b36dd7279aebadd72ff14f44e7221802e"

URI_aarch64_rust-x11rb-protocol+xinput-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xinput-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+xinput-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xinput-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xinput-devel.sha256sum] = "7e4661438f3884356c5d066c1593d02aa1ecbbb014eb6d23721999c8401ba652"

URI_aarch64_rust-x11rb-protocol+xkb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xkb-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+xkb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xkb-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xkb-devel.sha256sum] = "4ba1a3f1001889f22a473e957a43aa9970311cfd832c0280fd8bca0780dca910"

URI_aarch64_rust-x11rb-protocol+xprint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xprint-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+xprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xprint-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xprint-devel.sha256sum] = "2c2cb8345591911eefd7a00a7c805ad53c4ccaee093d6a1b0cdb39803de56eed"

URI_aarch64_rust-x11rb-protocol+xselinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xselinux-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+xselinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xselinux-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xselinux-devel.sha256sum] = "698a33a1fe06b5aa84fa3ff145bfc3407f23f82dc3aa23731eab26dc7f34fffc"

URI_aarch64_rust-x11rb-protocol+xtest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xtest-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+xtest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xtest-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xtest-devel.sha256sum] = "bb41fa33f7baf2b97d74f4fc5ab0d294d00374631cee16493d98fca8f03d33bb"

URI_aarch64_rust-x11rb-protocol+xv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xv-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+xv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xv-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xv-devel.sha256sum] = "5b11a9fd0e06d359d63352a5a628da88286c3300a538762029a96944ecd6e9fe"

URI_aarch64_rust-x11rb-protocol+xvmc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol+xvmc-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol+xvmc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol+xvmc-devel}"
SRC_URI[aarch64_rust-x11rb-protocol+xvmc-devel.sha256sum] = "6b1aeed83411b1d9a0c7273d471421cc46ddf409ac07d5506c063b46676da4e7"

URI_aarch64_rust-x11rb-protocol-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-protocol-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-protocol-devel}"
SRC_URI[aarch64_rust-x11rb-protocol-devel.sha256sum] = "9dcfd5cc36fb9c2bf255511edd71f0e28450657894dc94311616900adef2d153"

RDEPENDS:rust-x11rb-protocol+all-extensions-devel = " \
 cargo \
 rust-x11rb-protocol+composite-devel \
 rust-x11rb-protocol+damage-devel \
 rust-x11rb-protocol+dbe-devel \
 rust-x11rb-protocol+dpms-devel \
 rust-x11rb-protocol+dri2-devel \
 rust-x11rb-protocol+dri3-devel \
 rust-x11rb-protocol+glx-devel \
 rust-x11rb-protocol+present-devel \
 rust-x11rb-protocol+randr-devel \
 rust-x11rb-protocol+record-devel \
 rust-x11rb-protocol+render-devel \
 rust-x11rb-protocol+res-devel \
 rust-x11rb-protocol+screensaver-devel \
 rust-x11rb-protocol+shape-devel \
 rust-x11rb-protocol+shm-devel \
 rust-x11rb-protocol+sync-devel \
 rust-x11rb-protocol+xevie-devel \
 rust-x11rb-protocol+xf86dri-devel \
 rust-x11rb-protocol+xf86vidmode-devel \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol+xinerama-devel \
 rust-x11rb-protocol+xinput-devel \
 rust-x11rb-protocol+xkb-devel \
 rust-x11rb-protocol+xprint-devel \
 rust-x11rb-protocol+xselinux-devel \
 rust-x11rb-protocol+xtest-devel \
 rust-x11rb-protocol+xv-devel \
 rust-x11rb-protocol+xvmc-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+composite-devel = " \
 cargo \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+damage-devel = " \
 cargo \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+dbe-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+default-devel = " \
 cargo \
 rust-x11rb-protocol+std-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+dpms-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+dri2-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+dri3-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+extra-traits-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+glx-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+present-devel = " \
 cargo \
 rust-x11rb-protocol+dri3-devel \
 rust-x11rb-protocol+randr-devel \
 rust-x11rb-protocol+sync-devel \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+randr-devel = " \
 cargo \
 rust-x11rb-protocol+render-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+record-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+render-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+request-parsing-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+res-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+resource_manager-devel = " \
 cargo \
 rust-x11rb-protocol+std-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+screensaver-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+shape-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+shm-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+std-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+sync-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xevie-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xf86dri-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xf86vidmode-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xfixes-devel = " \
 cargo \
 rust-x11rb-protocol+render-devel \
 rust-x11rb-protocol+shape-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xinerama-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xinput-devel = " \
 cargo \
 rust-x11rb-protocol+xfixes-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xkb-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xprint-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xselinux-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xtest-devel = " \
 cargo \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xv-devel = " \
 cargo \
 rust-x11rb-protocol+shm-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol+xvmc-devel = " \
 cargo \
 rust-x11rb-protocol+xv-devel \
 rust-x11rb-protocol-devel \
 "
RDEPENDS:rust-x11rb-protocol-devel = " \
 cargo \
 rust \
 "
