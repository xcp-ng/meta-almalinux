# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libwhirlpool"
PV = "1.1"
PR = "8.el10_0"
PACKAGES = " \
 libwhirlpool \
 libwhirlpool-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libwhirlpool-1.1-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3601e5208d33e8e8d572aa383a6b6a737658f25f569f204cdfacde1fd20f872b"

URI_x86_64_v2_libwhirlpool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwhirlpool-1.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwhirlpool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwhirlpool}"
SRC_URI[x86_64_v2_libwhirlpool.sha256sum] = "8850703434435e4294845a10222fe48dd1413c90b88e49faef695ee0adea4841"

URI_x86_64_v2_libwhirlpool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwhirlpool-devel-1.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwhirlpool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwhirlpool-devel}"
SRC_URI[x86_64_v2_libwhirlpool-devel.sha256sum] = "2399db77c10de15485b85e1fef6f7fb5bf7de820a4305d77afd5b03242103144"

URI_aarch64_libwhirlpool = "${EPEL_MIRROR}/aarch64/Packages/l/libwhirlpool-1.1-8.el10_0.aarch64.rpm;name=aarch64_libwhirlpool;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwhirlpool}"
SRC_URI[aarch64_libwhirlpool.sha256sum] = "88605410eda10f07770965fe4e8cf2f2abb4ee955592d9f01c5196f7c449f332"

URI_aarch64_libwhirlpool-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libwhirlpool-devel-1.1-8.el10_0.aarch64.rpm;name=aarch64_libwhirlpool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwhirlpool-devel}"
SRC_URI[aarch64_libwhirlpool-devel.sha256sum] = "aed6aed302ba8a18df950c935acdb8fd951ca6ed1d876efaa16f2d34feffbaec"

RDEPENDS:libwhirlpool = " \
 glibc \
 "
RDEPENDS:libwhirlpool-devel = " \
 libwhirlpool \
 "
