# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fs2"
PV = "0.4.3"
PR = "27.el10_1"
PACKAGES = " \
 rust-fs2+default-devel \
 rust-fs2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fs2-0.4.3-27.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d89975ce44a29669d39ea1b5b2ffcd4c71943b8ed244133f074de56a0b835053"

URI_x86_64_v2_rust-fs2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs2+default-devel-0.4.3-27.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs2+default-devel}"
SRC_URI[x86_64_v2_rust-fs2+default-devel.sha256sum] = "6b12925d4aca84861b674edab844b9136a5f5ca3e42e4d50a14bd3f364839847"

URI_x86_64_v2_rust-fs2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs2-devel-0.4.3-27.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs2-devel}"
SRC_URI[x86_64_v2_rust-fs2-devel.sha256sum] = "91f5540ff1a3ca3e3f36c63d7470e239083dc903a19e403d0f21550c7e343eb2"

URI_aarch64_rust-fs2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs2+default-devel-0.4.3-27.el10_1.noarch.rpm;name=aarch64_rust-fs2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs2+default-devel}"
SRC_URI[aarch64_rust-fs2+default-devel.sha256sum] = "91bec06d41608ffd561bf610fc365fcc899875754aeaf35c5dbd09195383074b"

URI_aarch64_rust-fs2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs2-devel-0.4.3-27.el10_1.noarch.rpm;name=aarch64_rust-fs2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs2-devel}"
SRC_URI[aarch64_rust-fs2-devel.sha256sum] = "ed4f31358f08d84c342875d3042ef7f679e13cc9729d25594c30bb6959b4a78b"

RDEPENDS:rust-fs2+default-devel = " \
 cargo \
 rust-fs2-devel \
 "
RDEPENDS:rust-fs2-devel = " \
 cargo \
 rust-libc+default-devel \
 "
