# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kanagram"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kanagram \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kanagram-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4e2754dd63b104d24b092fb6fb88756e2085fef8f5a1083c96de3f8107926d0"

URI_x86_64_v2_kanagram = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kanagram-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kanagram;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kanagram}"
SRC_URI[x86_64_v2_kanagram.sha256sum] = "5324e015996d1ccd4c750f6ec06efdd2a9e030b1813798da74e6f4fd410fd811"

URI_aarch64_kanagram = "${EPEL_MIRROR}/aarch64/Packages/k/kanagram-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kanagram;unpack=0"
SRC_URI:append = " ${URI_aarch64_kanagram}"
SRC_URI[aarch64_kanagram.sha256sum] = "df01168e2c2bcddcc00a1b35b83e501655b15466b4dba250307a165334283cdb"

RDEPENDS:kanagram = " \
 glibc \
 kdeedu-data \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libkeduvocdocument \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtspeech \
 "
