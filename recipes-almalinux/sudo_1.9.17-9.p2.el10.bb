# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sudo"
PV = "1.9.17"
PR = "9.p2.el10"
PACKAGES = " \
 sudo \
 sudo-python-plugin \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sudo-1.9.17-9.p2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "387edd556aa5d0ddf2ab410461bd42ae9c3cceae807061f20b81920c617749e6"

URI_x86_64_v2_sudo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sudo-1.9.17-9.p2.el10.x86_64_v2.rpm;name=x86_64_v2_sudo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sudo}"
SRC_URI[x86_64_v2_sudo.sha256sum] = "50abc9e01b22797aec8aeb1746a543b4fcb60d43a9978ce9d1e36a2fe8d88125"

URI_x86_64_v2_sudo-python-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sudo-python-plugin-1.9.17-9.p2.el10.x86_64_v2.rpm;name=x86_64_v2_sudo-python-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sudo-python-plugin}"
SRC_URI[x86_64_v2_sudo-python-plugin.sha256sum] = "e24df2189ba9fdd3dee437341e3b571d8fcf780caaad29eb88ab376bc22cdf84"

URI_aarch64_sudo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sudo-1.9.17-9.p2.el10.aarch64.rpm;name=aarch64_sudo;unpack=0"
SRC_URI:append = " ${URI_aarch64_sudo}"
SRC_URI[aarch64_sudo.sha256sum] = "bf2081b0f4ceaffe1e7961cfdd5fbc94e98da82881072d3601aeb21231774647"

URI_aarch64_sudo-python-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sudo-python-plugin-1.9.17-9.p2.el10.aarch64.rpm;name=aarch64_sudo-python-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_sudo-python-plugin}"
SRC_URI[aarch64_sudo-python-plugin.sha256sum] = "e331551fa821600e2aee6fd1be92abdf87e483be8c79507f31ba78c38d873227"

RDEPENDS:sudo = " \
 audit-libs \
 glibc \
 libselinux \
 openldap \
 pam \
 pam-libs \
 zlib-ng-compat \
 "
RDEPENDS:sudo-python-plugin = " \
 glibc \
 python3-libs \
 sudo \
 "
