# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libseccomp"
PV = "2.5.3"
PR = "10.el10"
PACKAGES = " \
 libseccomp \
 libseccomp-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libseccomp-2.5.3-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3764401413327ba5a4f24bca82d553798476e731df39dad1ba96c53a28f8f6ec"

URI_x86_64_v2_libseccomp = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libseccomp-2.5.3-10.el10.x86_64_v2.rpm;name=x86_64_v2_libseccomp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libseccomp}"
SRC_URI[x86_64_v2_libseccomp.sha256sum] = "36539f11ec9d00b07d7c23bfe94c5462ee4b465c4e4a2a77eeb64f438c0c7d18"

URI_x86_64_v2_libseccomp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libseccomp-devel-2.5.3-10.el10.x86_64_v2.rpm;name=x86_64_v2_libseccomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libseccomp-devel}"
SRC_URI[x86_64_v2_libseccomp-devel.sha256sum] = "b871d84cf5fdef8768c96af199109dfa1930e9b7244cd6cbeee722992b2a1598"

URI_aarch64_libseccomp = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libseccomp-2.5.3-10.el10.aarch64.rpm;name=aarch64_libseccomp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libseccomp}"
SRC_URI[aarch64_libseccomp.sha256sum] = "415371dff2c906dfa17f7604861a2b4d0d24b580daf3bb00dc237fcb2295ac0b"

URI_aarch64_libseccomp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libseccomp-devel-2.5.3-10.el10.aarch64.rpm;name=aarch64_libseccomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libseccomp-devel}"
SRC_URI[aarch64_libseccomp-devel.sha256sum] = "282365edc96f67034a0b12bbf5374f68f529db27227bdba5a7aa55e8ccbb8786"

RDEPENDS:libseccomp = " \
 glibc \
 "
RDEPENDS:libseccomp-devel = " \
 glibc \
 libseccomp \
 pkgconf-pkg-config \
 "
