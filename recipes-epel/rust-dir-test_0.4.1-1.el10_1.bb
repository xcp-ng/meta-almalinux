# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dir-test"
PV = "0.4.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-dir-test+default-devel \
 rust-dir-test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dir-test-0.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b6e0a52be63e98f54a7261ae9e09d1acf1e71befef5cb4d3fe7973a243f5a9c"

URI_x86_64_v2_rust-dir-test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dir-test+default-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dir-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dir-test+default-devel}"
SRC_URI[x86_64_v2_rust-dir-test+default-devel.sha256sum] = "48eb86f5b1e18f938746e0bea3884ffbd5f29274b974e517e99fe87d66027989"

URI_x86_64_v2_rust-dir-test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dir-test-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dir-test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dir-test-devel}"
SRC_URI[x86_64_v2_rust-dir-test-devel.sha256sum] = "b7f757dd1b102ccdfc51da734ed21ed967b0f9513e88b403cfd1dbb045f16138"

URI_aarch64_rust-dir-test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dir-test+default-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-dir-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dir-test+default-devel}"
SRC_URI[aarch64_rust-dir-test+default-devel.sha256sum] = "16fcaa14b595d357862d7df6a19c6f5fe59d6a88630ec689f8d6041c3ba7be37"

URI_aarch64_rust-dir-test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dir-test-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-dir-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dir-test-devel}"
SRC_URI[aarch64_rust-dir-test-devel.sha256sum] = "0bbc9ca8511a9cd5955b07396eb4e01d4ce762c8795e8d1fdcf2e6f6565679a4"

RDEPENDS:rust-dir-test+default-devel = " \
 cargo \
 rust-dir-test-devel \
 "
RDEPENDS:rust-dir-test-devel = " \
 cargo \
 rust-dir-test-macros+default-devel \
 "
