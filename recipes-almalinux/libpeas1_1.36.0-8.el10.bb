# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpeas1"
PV = "1.36.0"
PR = "8.el10"
PACKAGES = " \
 libpeas1 \
 libpeas1-devel \
 libpeas1-gtk \
 libpeas1-loader-python3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libpeas1-1.36.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8f05ccc2d9fb39c5a47a926ca5597fc4382f9cd868d8de312bc9e01806c3109"

URI_x86_64_v2_libpeas1 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpeas1-1.36.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_libpeas1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpeas1}"
SRC_URI[x86_64_v2_libpeas1.sha256sum] = "6117ddcbe151109b1f77a391922f6301ae182473167979f7b50ed2c1912df6e8"

URI_x86_64_v2_libpeas1-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libpeas1-devel-1.36.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_libpeas1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpeas1-devel}"
SRC_URI[x86_64_v2_libpeas1-devel.sha256sum] = "f748b1fb4c4a532b13a2a79bd9fdbcf27527d9e2009376e039e2f97893f162d1"

URI_x86_64_v2_libpeas1-gtk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpeas1-gtk-1.36.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_libpeas1-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpeas1-gtk}"
SRC_URI[x86_64_v2_libpeas1-gtk.sha256sum] = "01f83cb7df6a0d80aa34bebbb2c749fb8fbf73623710591363ad9c045959b6a4"

URI_x86_64_v2_libpeas1-loader-python3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpeas1-loader-python3-1.36.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_libpeas1-loader-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpeas1-loader-python3}"
SRC_URI[x86_64_v2_libpeas1-loader-python3.sha256sum] = "6f983ddb29cea16b3fa691a3630450a97262d1c0c1069a9539c14dae442d1b4f"

URI_aarch64_libpeas1 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpeas1-1.36.0-8.el10.aarch64.rpm;name=aarch64_libpeas1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpeas1}"
SRC_URI[aarch64_libpeas1.sha256sum] = "ac1d6a79cec262ddf6ec2f4c53f40caaf3666a121a7d7538ccb59b968b915943"

URI_aarch64_libpeas1-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libpeas1-devel-1.36.0-8.el10.aarch64.rpm;name=aarch64_libpeas1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpeas1-devel}"
SRC_URI[aarch64_libpeas1-devel.sha256sum] = "f429ad928a66d62381b3aaf16e23f41e7101ce51862b11673eca7556311443cc"

URI_aarch64_libpeas1-gtk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpeas1-gtk-1.36.0-8.el10.aarch64.rpm;name=aarch64_libpeas1-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpeas1-gtk}"
SRC_URI[aarch64_libpeas1-gtk.sha256sum] = "71a7ea20a508a58424259834b7a6264126dfa756020f0d3ec0e654198e17a43c"

URI_aarch64_libpeas1-loader-python3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpeas1-loader-python3-1.36.0-8.el10.aarch64.rpm;name=aarch64_libpeas1-loader-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpeas1-loader-python3}"
SRC_URI[aarch64_libpeas1-loader-python3.sha256sum] = "db322371c8d68e1acd1f6ddc46087a60bbcdf67f1a98e8ebd22784d53ff05640"

RDEPENDS:libpeas1 = " \
 glib2 \
 glibc \
 gobject-introspection \
 "
RDEPENDS:libpeas1-devel = " \
 glib2-devel \
 gobject-introspection-devel \
 gtk3-devel \
 libpeas1 \
 libpeas1-devel \
 libpeas1-gtk \
 pkgconf-pkg-config \
 "
RDEPENDS:libpeas1-gtk = " \
 glib2 \
 glibc \
 gobject-introspection \
 gtk3 \
 libpeas1 \
 "
RDEPENDS:libpeas1-loader-python3 = " \
 glib2 \
 glibc \
 libpeas1 \
 python3-gobject \
 python3-libs \
 "
