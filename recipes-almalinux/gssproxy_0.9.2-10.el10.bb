# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gssproxy"
PV = "0.9.2"
PR = "10.el10"
PACKAGES = " \
 gssproxy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gssproxy-0.9.2-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bb5f03189587d5d8722c4f3a20a133c7e0702f411bfd64b4843c50074b740ac"

URI_x86_64_v2_gssproxy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gssproxy-0.9.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_gssproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gssproxy}"
SRC_URI[x86_64_v2_gssproxy.sha256sum] = "5e084d73094f2018898c71eeeed8a23af5481732edae754c42f3c382c619f5f6"

URI_aarch64_gssproxy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gssproxy-0.9.2-10.el10.aarch64.rpm;name=aarch64_gssproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_gssproxy}"
SRC_URI[aarch64_gssproxy.sha256sum] = "a92c68d59e63309e19b0b53964a03b033a7e9eba38aca449e4b826d949472220"

RDEPENDS:gssproxy = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 libini_config \
 libref_array \
 libselinux \
 libverto \
 libverto-libev \
 popt \
 systemd \
 systemd-libs \
 "
