# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-atpublic"
PV = "4.1.0"
PR = "8.el10_2"
PACKAGES = " \
 python3-atpublic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-atpublic-4.1.0-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52ab2554339b984ca46cf66891803788b26861845eadffb11f08176f6fc816a6"

URI_x86_64_v2_python3-atpublic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-atpublic-4.1.0-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-atpublic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-atpublic}"
SRC_URI[x86_64_v2_python3-atpublic.sha256sum] = "5ed94b515cd6c81719bcf99621a425cd14c8a4c0f676cb653c164b112d3f4adb"

URI_aarch64_python3-atpublic = "${EPEL_MIRROR}/aarch64/Packages/p/python3-atpublic-4.1.0-8.el10_2.aarch64.rpm;name=aarch64_python3-atpublic;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-atpublic}"
SRC_URI[aarch64_python3-atpublic.sha256sum] = "90eb7c3af3486fb60d43fb0f63d9b1372840b13674046aa3d8c52eeda2604cd4"

RDEPENDS:python3-atpublic = " \
 python3 \
 python3-setuptools \
 "
