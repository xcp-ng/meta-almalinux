# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-issues"
PV = "5.0.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-sphinx-issues \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-issues-5.0.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87b76f71fce753aa28bb8b4e07ee56a14e31b4cb650df5abcd68b574b91c78c6"

URI_x86_64_v2_python3-sphinx-issues = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-issues-5.0.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-issues;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-issues}"
SRC_URI[x86_64_v2_python3-sphinx-issues.sha256sum] = "99f3390e2edc42645ca3c79636150e772782f3751f5352ef41591b10eaaed3d3"

URI_aarch64_python3-sphinx-issues = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-issues-5.0.0-2.el10_1.noarch.rpm;name=aarch64_python3-sphinx-issues;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-issues}"
SRC_URI[aarch64_python3-sphinx-issues.sha256sum] = "aebf32f42749612fa5a8915d4769f2b1f24d171fbdd3a64a3ff11a0f4a39f885"

RDEPENDS:python3-sphinx-issues = " \
 python3 \
 python3-sphinx \
 "
