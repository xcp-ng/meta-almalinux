# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv"
PV = "0.8.15"
PR = "1.el10_2"
PACKAGES = " \
 rust-rkyv+aligned-devel \
 rust-rkyv+alloc-devel \
 rust-rkyv+big_endian-devel \
 rust-rkyv+bytecheck-devel \
 rust-rkyv+default-devel \
 rust-rkyv+little_endian-devel \
 rust-rkyv+pointer_width_16-devel \
 rust-rkyv+pointer_width_32-devel \
 rust-rkyv+pointer_width_64-devel \
 rust-rkyv+smallvec-1-devel \
 rust-rkyv+std-devel \
 rust-rkyv+unaligned-devel \
 rust-rkyv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv-0.8.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7aff3445b494abd4245d3476564d5ef80b97c7a16a1ac58c2a35db03eb3f66e"

URI_x86_64_v2_rust-rkyv+aligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+aligned-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+aligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+aligned-devel}"
SRC_URI[x86_64_v2_rust-rkyv+aligned-devel.sha256sum] = "0f83081dcb4708033b9329bdb3a65b36edfb369b3b9b98caab8f519cc98f2d9e"

URI_x86_64_v2_rust-rkyv+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+alloc-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+alloc-devel}"
SRC_URI[x86_64_v2_rust-rkyv+alloc-devel.sha256sum] = "6da0cb14931319b2b91b78d020987157ba699722234dcd23e761c16b3e3c1458"

URI_x86_64_v2_rust-rkyv+big_endian-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+big_endian-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+big_endian-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+big_endian-devel}"
SRC_URI[x86_64_v2_rust-rkyv+big_endian-devel.sha256sum] = "294f5c82984ca46a752bae17eaec4799af3367e62fb84013cfa3e2f5c08e71b9"

URI_x86_64_v2_rust-rkyv+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+bytecheck-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rkyv+bytecheck-devel.sha256sum] = "8ef7eeee0c28a695f50246dcf95e0f91f525a40581ee8f8477e82bd16824c343"

URI_x86_64_v2_rust-rkyv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+default-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv+default-devel.sha256sum] = "f74ac91017535e7b04d28e598c1c2d7cbfcabe598c8e4a5c9cffd596188bd062"

URI_x86_64_v2_rust-rkyv+little_endian-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+little_endian-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+little_endian-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+little_endian-devel}"
SRC_URI[x86_64_v2_rust-rkyv+little_endian-devel.sha256sum] = "712f6025e5a92dc677005d297fbf7d08a2daa1d7de1a8b7ef7082be3417c1a9a"

URI_x86_64_v2_rust-rkyv+pointer_width_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+pointer_width_16-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+pointer_width_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+pointer_width_16-devel}"
SRC_URI[x86_64_v2_rust-rkyv+pointer_width_16-devel.sha256sum] = "5a7136d18484b78a1ce22a6eed31763adca8c8f1b54858a42c77fc14b8e149cd"

URI_x86_64_v2_rust-rkyv+pointer_width_32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+pointer_width_32-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+pointer_width_32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+pointer_width_32-devel}"
SRC_URI[x86_64_v2_rust-rkyv+pointer_width_32-devel.sha256sum] = "1e3bc804c57ee66430bea5b1100dae4452bf80d17277a9bfa3848ed67598aaea"

URI_x86_64_v2_rust-rkyv+pointer_width_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+pointer_width_64-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+pointer_width_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+pointer_width_64-devel}"
SRC_URI[x86_64_v2_rust-rkyv+pointer_width_64-devel.sha256sum] = "56ba5e027277cf0b1c472281638b79386deddc39fa5e5b21e6e627cc86d2838c"

URI_x86_64_v2_rust-rkyv+smallvec-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+smallvec-1-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+smallvec-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+smallvec-1-devel}"
SRC_URI[x86_64_v2_rust-rkyv+smallvec-1-devel.sha256sum] = "3245577a9d322ab6b78ce8d6b4c1a0e5ddef1e23a8a4750ee23ba3922b4e9dd0"

URI_x86_64_v2_rust-rkyv+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+std-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+std-devel}"
SRC_URI[x86_64_v2_rust-rkyv+std-devel.sha256sum] = "50eb0f6961b7c32a72791bc7dddce52c074a9a4c0f03cfe79460d02556545d7e"

URI_x86_64_v2_rust-rkyv+unaligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+unaligned-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+unaligned-devel}"
SRC_URI[x86_64_v2_rust-rkyv+unaligned-devel.sha256sum] = "9bbc8defaa81e2f07e223f8436f4d3daa3e1fe26df7147429a2abbba0de0bb11"

URI_x86_64_v2_rust-rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv-devel}"
SRC_URI[x86_64_v2_rust-rkyv-devel.sha256sum] = "fc29aad01357ea2803c12c2e97a9c81653fbaf3a522e493de875bcba4507c008"

URI_aarch64_rust-rkyv+aligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+aligned-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv+aligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+aligned-devel}"
SRC_URI[aarch64_rust-rkyv+aligned-devel.sha256sum] = "7c880ab285aebd834937edf876dc0a723b1164d49f5a9ad7ad63fd44c738fb57"

URI_aarch64_rust-rkyv+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+alloc-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+alloc-devel}"
SRC_URI[aarch64_rust-rkyv+alloc-devel.sha256sum] = "b89f232bcebe7848a6f84789d966dbaea36239bfb59d9e7149ebd392a947b51b"

URI_aarch64_rust-rkyv+big_endian-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+big_endian-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv+big_endian-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+big_endian-devel}"
SRC_URI[aarch64_rust-rkyv+big_endian-devel.sha256sum] = "986b71ff150a6809a8586ec4a3af0ef3d499b70444da204febfd897b3441ae85"

URI_aarch64_rust-rkyv+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+bytecheck-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+bytecheck-devel}"
SRC_URI[aarch64_rust-rkyv+bytecheck-devel.sha256sum] = "72a8bd5f9b21e11468bf2e13484e949d2f0e4f0c59310c7ca985c481abe37165"

URI_aarch64_rust-rkyv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+default-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+default-devel}"
SRC_URI[aarch64_rust-rkyv+default-devel.sha256sum] = "94abf564db04ad28ed707aace94ff4a0a97be5b7aa26b8c5bf1cf216f5c2c7c0"

URI_aarch64_rust-rkyv+little_endian-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+little_endian-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv+little_endian-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+little_endian-devel}"
SRC_URI[aarch64_rust-rkyv+little_endian-devel.sha256sum] = "d8a586c0219840ba2f06fd9c8104117550f63894e3652b648bbb79671d15618a"

URI_aarch64_rust-rkyv+pointer_width_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+pointer_width_16-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv+pointer_width_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+pointer_width_16-devel}"
SRC_URI[aarch64_rust-rkyv+pointer_width_16-devel.sha256sum] = "4d6637d3275e2eb9fe37fcb0cdb7d26028ebda5d3eff8ae86d8cac099eed989a"

URI_aarch64_rust-rkyv+pointer_width_32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+pointer_width_32-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv+pointer_width_32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+pointer_width_32-devel}"
SRC_URI[aarch64_rust-rkyv+pointer_width_32-devel.sha256sum] = "889de48afa334cd8805638c436889f2a91c0b4547425cac00710639a2abcdcae"

URI_aarch64_rust-rkyv+pointer_width_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+pointer_width_64-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv+pointer_width_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+pointer_width_64-devel}"
SRC_URI[aarch64_rust-rkyv+pointer_width_64-devel.sha256sum] = "2516ce220e0f512f4d67da29cf53667de7aac61fb83a74da6ff396948da4ba4d"

URI_aarch64_rust-rkyv+smallvec-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+smallvec-1-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv+smallvec-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+smallvec-1-devel}"
SRC_URI[aarch64_rust-rkyv+smallvec-1-devel.sha256sum] = "1ba3662262f2d94fc7e8f50173721e706b78a13736c08aa53d2f245bc92861ec"

URI_aarch64_rust-rkyv+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+std-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+std-devel}"
SRC_URI[aarch64_rust-rkyv+std-devel.sha256sum] = "210e3e0c8f9c35c61b3dad13d854ae5f14636883945147045d097b49e350b8ff"

URI_aarch64_rust-rkyv+unaligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+unaligned-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+unaligned-devel}"
SRC_URI[aarch64_rust-rkyv+unaligned-devel.sha256sum] = "0e035b77bc4a5628a065251719d11af281e6aa54aefe65d885b767c129b31043"

URI_aarch64_rust-rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv-devel}"
SRC_URI[aarch64_rust-rkyv-devel.sha256sum] = "1974080ca43ec00e04ec6e431c642bfad52eeac8dc85e132aa07feaa1971ad16"

RDEPENDS:rust-rkyv+aligned-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+alloc-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-rancor+alloc-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+big_endian-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+bytecheck-devel = " \
 cargo \
 rust-bytecheck+simdutf8-devel \
 rust-bytecheck-devel \
 rust-rend+bytecheck-devel \
 rust-rkyv-devel \
 rust-rkyv_derive+bytecheck-devel \
 "
RDEPENDS:rust-rkyv+default-devel = " \
 cargo \
 rust-rkyv+bytecheck-devel \
 rust-rkyv+std-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+little_endian-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+pointer_width_16-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+pointer_width_32-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+pointer_width_64-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+smallvec-1-devel = " \
 cargo \
 rust-rkyv-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-rkyv+std-devel = " \
 cargo \
 rust-ptr_meta+std-devel \
 rust-rkyv+alloc-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+unaligned-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv-devel = " \
 cargo \
 rust \
 rust-munge-devel \
 rust-ptr_meta-devel \
 rust-rancor-devel \
 rust-rend-devel \
 rust-rkyv_derive-devel \
 "
