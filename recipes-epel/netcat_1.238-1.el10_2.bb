# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netcat"
PV = "1.238"
PR = "1.el10_2"
PACKAGES = " \
 netcat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netcat-1.238-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca90aca84fc588006204bd29ede864467fa9eb97042f3e8c494eaa3112cdce2b"

URI_x86_64_v2_netcat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcat-1.238-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcat}"
SRC_URI[x86_64_v2_netcat.sha256sum] = "fb5673fd9b0d8025355520c612d3f7a1fb7e9833c41b9225268419bbf28ce854"

URI_aarch64_netcat = "${EPEL_MIRROR}/aarch64/Packages/n/netcat-1.238-1.el10_2.aarch64.rpm;name=aarch64_netcat;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcat}"
SRC_URI[aarch64_netcat.sha256sum] = "1694c34e1937b315aa1a98e9b8929e66c7a7bb21a8a538b71bc4031abc619483"

RDEPENDS:netcat = " \
 alternatives \
 bash \
 glibc \
 libbsd \
 libretls \
 "
