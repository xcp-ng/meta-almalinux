# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sudo"
PV = "1.9.15"
PR = "10.p5.el10_1"
PACKAGES = " \
 sudo \
 sudo-python-plugin \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sudo-1.9.15-10.p5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "895861c18c52c4c4fab4dde965b5490880b11b28049bc81f9de87138d0c0726e"

URI_x86_64_v2_sudo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sudo-1.9.15-10.p5.el10_1.x86_64_v2.rpm;name=x86_64_v2_sudo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sudo}"
SRC_URI[x86_64_v2_sudo.sha256sum] = "3696049622206de027ed2f400c9b14ebf8e265d7af8908e8713e7a7ab5bbdca1"

URI_x86_64_v2_sudo-python-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sudo-python-plugin-1.9.15-10.p5.el10_1.x86_64_v2.rpm;name=x86_64_v2_sudo-python-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sudo-python-plugin}"
SRC_URI[x86_64_v2_sudo-python-plugin.sha256sum] = "f51ece472305b603df9e1b171c3569d3535acd869677fe3bf165642ad8158b5c"

URI_aarch64_sudo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sudo-1.9.15-10.p5.el10_1.aarch64.rpm;name=aarch64_sudo;unpack=0"
SRC_URI:append = " ${URI_aarch64_sudo}"
SRC_URI[aarch64_sudo.sha256sum] = "a68fb2f04cc5e2d18f4fd17df8fa96bbeedac16081e75fdbc0581d53083ae84a"

URI_aarch64_sudo-python-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sudo-python-plugin-1.9.15-10.p5.el10_1.aarch64.rpm;name=aarch64_sudo-python-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_sudo-python-plugin}"
SRC_URI[aarch64_sudo-python-plugin.sha256sum] = "0f094b540aeb36bdf928f57b9552df7c3c7aab667991aa0cf82d394b46b2f8c2"

RDEPENDS:sudo = " \
 audit-libs \
 glibc \
 libselinux \
 openldap \
 pam \
 pam-libs \
 zlib-ng-compat \
 "
RDEPENDS:sudo-python-plugin = " \
 glibc \
 python3-libs \
 sudo \
 "
