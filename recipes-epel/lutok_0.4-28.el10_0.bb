# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lutok"
PV = "0.4"
PR = "28.el10_0"
PACKAGES = " \
 lutok \
 lutok-devel \
 lutok-doc \
 lutok-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lutok-0.4-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85ef9ff5027d2468512a1dd954e4cde24d1b9059cf158165645c4df5528512dc"

URI_x86_64_v2_lutok = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lutok-0.4-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lutok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lutok}"
SRC_URI[x86_64_v2_lutok.sha256sum] = "387dc8dfd6c88c3848560ca0b60c5f80e1b580b99ca23cd22f510a3c84ce9279"

URI_x86_64_v2_lutok-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lutok-devel-0.4-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lutok-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lutok-devel}"
SRC_URI[x86_64_v2_lutok-devel.sha256sum] = "8e36365c039188a0535b94f99f1ccf787044795f3d1d8dec783f724d8e12b1c5"

URI_x86_64_v2_lutok-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lutok-doc-0.4-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lutok-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lutok-doc}"
SRC_URI[x86_64_v2_lutok-doc.sha256sum] = "724e055c695a096d139544f0718412a8e300e71e13787737571f00e4f909e767"

URI_x86_64_v2_lutok-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lutok-tests-0.4-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lutok-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lutok-tests}"
SRC_URI[x86_64_v2_lutok-tests.sha256sum] = "1311435966c21afd9a6a51b36595bf08ea96eb38a0378238629aad99c8402026"

URI_aarch64_lutok = "${EPEL_MIRROR}/aarch64/Packages/l/lutok-0.4-28.el10_0.aarch64.rpm;name=aarch64_lutok;unpack=0"
SRC_URI:append = " ${URI_aarch64_lutok}"
SRC_URI[aarch64_lutok.sha256sum] = "e35d89bbb4fac1cf982c86da6654cf90a546393476068ad1c8931f5fe1d0f3f3"

URI_aarch64_lutok-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lutok-devel-0.4-28.el10_0.aarch64.rpm;name=aarch64_lutok-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lutok-devel}"
SRC_URI[aarch64_lutok-devel.sha256sum] = "f1c0fb6ca958a7f60524c8c069b866cfe6bc5b1348f781c2c54596bddbe30765"

URI_aarch64_lutok-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lutok-doc-0.4-28.el10_0.noarch.rpm;name=aarch64_lutok-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lutok-doc}"
SRC_URI[aarch64_lutok-doc.sha256sum] = "bfbad99794bc18f1d6965b5f05644c8d22fb90c3415e9228d3f84778a319acfe"

URI_aarch64_lutok-tests = "${EPEL_MIRROR}/aarch64/Packages/l/lutok-tests-0.4-28.el10_0.aarch64.rpm;name=aarch64_lutok-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_lutok-tests}"
SRC_URI[aarch64_lutok-tests.sha256sum] = "1e8bc66bd476f00ab1573fb46dabc896264c805b2973156670b2d7875c96b689"

RDEPENDS:lutok = " \
 glibc \
 libgcc \
 libstdc++ \
 lua \
 lua-libs \
 "
RDEPENDS:lutok-devel = " \
 lua-devel \
 lutok \
 pkgconf-pkg-config \
 "
RDEPENDS:lutok-doc = " \
 lutok \
 "
RDEPENDS:lutok-tests = " \
 glibc \
 libatf-c++ \
 libgcc \
 libstdc++ \
 lua-libs \
 lutok \
 lutok-devel \
 "
