# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtgamepad"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtgamepad \
 qt5-qtgamepad-devel \
 qt5-qtgamepad-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtgamepad-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e090b138c65d24006afea70faedf316c8552109f6ea8ab13e90d13340146a113"

URI_x86_64_v2_qt5-qtgamepad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgamepad-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtgamepad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgamepad}"
SRC_URI[x86_64_v2_qt5-qtgamepad.sha256sum] = "75d4c8664b7cc5a4851c4d5a9dc33f7da78b588ad4d02d558bec9ee3cbdc12e7"

URI_x86_64_v2_qt5-qtgamepad-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgamepad-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtgamepad-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgamepad-devel}"
SRC_URI[x86_64_v2_qt5-qtgamepad-devel.sha256sum] = "0aada4cb041e292b8c87491ada79b7d95b576836ac59e032f63bff683bd72dc2"

URI_x86_64_v2_qt5-qtgamepad-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgamepad-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtgamepad-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgamepad-examples}"
SRC_URI[x86_64_v2_qt5-qtgamepad-examples.sha256sum] = "120e989427b1a2ef1e0e9c4e79a877f34b04f243737b3ca463ec804ae6e5e7ed"

URI_aarch64_qt5-qtgamepad = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgamepad-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtgamepad;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgamepad}"
SRC_URI[aarch64_qt5-qtgamepad.sha256sum] = "e8b2320d452816108394924013670f64d01630fa0a8d471d8db3fa824851707e"

URI_aarch64_qt5-qtgamepad-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgamepad-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtgamepad-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgamepad-devel}"
SRC_URI[aarch64_qt5-qtgamepad-devel.sha256sum] = "297f8dc418415738f78d36f4a798d9b0d0fb4a60703e39fa9796be33bf682652"

URI_aarch64_qt5-qtgamepad-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgamepad-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtgamepad-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgamepad-examples}"
SRC_URI[aarch64_qt5-qtgamepad-examples.sha256sum] = "61dfc4db2610869547b2e3d722760b7ea3f19cc95e5a34f77eb70f8fadec28ca"

RDEPENDS:qt5-qtgamepad = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 sdl2-compat \
 systemd-libs \
 "
RDEPENDS:qt5-qtgamepad-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtgamepad \
 "
RDEPENDS:qt5-qtgamepad-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtgamepad \
 "
