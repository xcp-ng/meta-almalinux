# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-dlist"
PV = "1.0"
PR = "13.el10_0"
PACKAGES = " \
 ghc-dlist \
 ghc-dlist-devel \
 ghc-dlist-doc \
 ghc-dlist-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-dlist-1.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7d6ae71bec5bdb6af9ac919842961e90eada86443a071e9bc216d529f3444081"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dlist-1.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dlist;unpack=0"
SRC_URI[x86_64_v2_ghc-dlist.sha256sum] = "1c82cf42c851097db69f1f720ac24b9992ed3269094cf12a5a7c4ab4d0c6deb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dlist-devel-1.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dlist-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-dlist-devel.sha256sum] = "46f6ac1f3e97623ab46230786d98f5b1a7581cc4953a1bb978bc505092a63321"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dlist-doc-1.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-dlist-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-dlist-doc.sha256sum] = "8ad4c74b961b69e6a53461847a1be9aa754bfea8117e8b403bb5f001e8f78581"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dlist-prof-1.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dlist-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-dlist-prof.sha256sum] = "6e3d65cce650c62c6d7f832ea6dc313fa1ec1100fc0370096cfc94a92b13bde8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-dlist-1.0-13.el10_0.aarch64.rpm;name=aarch64_ghc-dlist;unpack=0"
SRC_URI[aarch64_ghc-dlist.sha256sum] = "2fa013d0580c2cb2bc2ca472fd77d3c6dcacb5db906ba980f436e65903c1586b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-dlist-devel-1.0-13.el10_0.aarch64.rpm;name=aarch64_ghc-dlist-devel;unpack=0"
SRC_URI[aarch64_ghc-dlist-devel.sha256sum] = "3f27bdc5f56cdabe648672d05eb084a0596f3e933da40e85d762d994eeb4ddf5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-dlist-doc-1.0-13.el10_0.noarch.rpm;name=aarch64_ghc-dlist-doc;unpack=0"
SRC_URI[aarch64_ghc-dlist-doc.sha256sum] = "66f7e046d6d20a55cd36cb54404f2ba8eefc9e9a51269be8c8a5c65888580733"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-dlist-prof-1.0-13.el10_0.aarch64.rpm;name=aarch64_ghc-dlist-prof;unpack=0"
SRC_URI[aarch64_ghc-dlist-prof.sha256sum] = "42c7969aad449e89126cac57d3a35ef8b79fd090ee3cdc20cab962c6cbacd580"

RDEPENDS:ghc-dlist = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-dlist-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-dlist \
 "
RDEPENDS:ghc-dlist-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-dlist-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-dlist-devel \
 "
