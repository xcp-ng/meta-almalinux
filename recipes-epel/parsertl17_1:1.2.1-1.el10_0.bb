# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "parsertl17"
PE = "1"
PV = "1.2.1"
PR = "1.el10_0"
PACKAGES = " \
 parsertl17-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/parsertl17-1.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6eb48370fbb274a6b79ecb81f6f0dd69b3a3daadb52a17ad2cc8084188154269"

URI_x86_64_v2_parsertl17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parsertl17-devel-1.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parsertl17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parsertl17-devel}"
SRC_URI[x86_64_v2_parsertl17-devel.sha256sum] = "70bf1f24d82e06f6cf98ab6e57dd9220a8f655f5c936f6ce6dc3161613b15ad6"

URI_aarch64_parsertl17-devel = "${EPEL_MIRROR}/aarch64/Packages/p/parsertl17-devel-1.2.1-1.el10_0.aarch64.rpm;name=aarch64_parsertl17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_parsertl17-devel}"
SRC_URI[aarch64_parsertl17-devel.sha256sum] = "4fa2abe0031e4d742af83607f6a2af332480da8e6835491abbe8fa4f892c97dd"

RDEPENDS:parsertl17-devel = " \
 cmake-filesystem \
 lexertl17-devel \
 "
