# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "desktop-file-utils"
PV = "0.26"
PR = "15.el10_1"
PACKAGES = " \
 desktop-file-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/desktop-file-utils-0.26-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49814f7d1ee918e076232b1cf9670a3f56bbef1e1045141701b91ac0d4bf0b4f"

URI_x86_64_v2_desktop-file-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/desktop-file-utils-0.26-15.el10_1.x86_64_v2.rpm;name=x86_64_v2_desktop-file-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-file-utils}"
SRC_URI[x86_64_v2_desktop-file-utils.sha256sum] = "89e81e1822d413f0529f05a8ae95c85a936ca7a9c18d353775030395de4b055c"

URI_aarch64_desktop-file-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/desktop-file-utils-0.26-15.el10_1.aarch64.rpm;name=aarch64_desktop-file-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-file-utils}"
SRC_URI[aarch64_desktop-file-utils.sha256sum] = "185cb8b3a800aaa57f5b12a14a5581730064eb36edb0a21ee34dc4769016dfb5"

RDEPENDS:desktop-file-utils = " \
 bash \
 emacs-filesystem \
 glib2 \
 glibc \
 "
