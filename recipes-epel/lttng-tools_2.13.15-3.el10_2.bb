# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lttng-tools"
PV = "2.13.15"
PR = "3.el10_2"
PACKAGES = " \
 lttng-tools \
 lttng-tools-devel \
 python3-lttng \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lttng-tools-2.13.15-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53236d781a6d48f25fea3ceb13db234b90330e75d707c20185b8004c6529e5c1"

URI_x86_64_v2_lttng-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lttng-tools-2.13.15-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lttng-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lttng-tools}"
SRC_URI[x86_64_v2_lttng-tools.sha256sum] = "20e81b1c99343cfdeb424e0ebe2523cc1e4bd5a4147f82dfdcab812c89b3d2de"

URI_x86_64_v2_lttng-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lttng-tools-devel-2.13.15-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lttng-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lttng-tools-devel}"
SRC_URI[x86_64_v2_lttng-tools-devel.sha256sum] = "d7de2eaba4bfca7ec19a755a0fe0f881bd5c7e3f34941dc22cff3a8cb3a4e7d2"

URI_x86_64_v2_python3-lttng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lttng-2.13.15-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lttng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lttng}"
SRC_URI[x86_64_v2_python3-lttng.sha256sum] = "83c8a9cc8bdaaaed2748743c073c27a37d78e45231b64b0ceb4edcea36ad9a7d"

URI_aarch64_lttng-tools = "${EPEL_MIRROR}/aarch64/Packages/l/lttng-tools-2.13.15-3.el10_2.aarch64.rpm;name=aarch64_lttng-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_lttng-tools}"
SRC_URI[aarch64_lttng-tools.sha256sum] = "84549f0fdad70fecff498b54c79b08e7e61baeb66f53aa9608c870aa0a3bc42a"

URI_aarch64_lttng-tools-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lttng-tools-devel-2.13.15-3.el10_2.aarch64.rpm;name=aarch64_lttng-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lttng-tools-devel}"
SRC_URI[aarch64_lttng-tools-devel.sha256sum] = "287f4ec2bfb73ba55e21578293278c85406a201e3249792ce9c0b08ca9a1db3a"

URI_aarch64_python3-lttng = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lttng-2.13.15-3.el10_2.aarch64.rpm;name=aarch64_python3-lttng;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lttng}"
SRC_URI[aarch64_python3-lttng.sha256sum] = "7b67bc13596a3ab7708d6d84940ff828447b46e41cacb4c63a7019446fe3ff8b"

RDEPENDS:lttng-tools = " \
 bash \
 glibc \
 libgcc \
 libxml2 \
 lttng-ust \
 popt \
 systemd \
 userspace-rcu \
 "
RDEPENDS:lttng-tools-devel = " \
 lttng-tools \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-lttng = " \
 glibc \
 libxml2 \
 lttng-tools \
 python3 \
 userspace-rcu \
 "
