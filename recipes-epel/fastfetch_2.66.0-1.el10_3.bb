# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fastfetch"
PV = "2.66.0"
PR = "1.el10_3"
PACKAGES = " \
 fastfetch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fastfetch-2.66.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71881a2aa512cb4a33065f21c4c4fde53ffe4099fbe9629f0764ad66f4d94069"

URI_x86_64_v2_fastfetch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fastfetch-2.66.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fastfetch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fastfetch}"
SRC_URI[x86_64_v2_fastfetch.sha256sum] = "b91f956691d331e24e83ffa2e8f8b8d3066e951ed0c61f11c0b6e3e5b42c8f67"

URI_aarch64_fastfetch = "${EPEL_MIRROR}/aarch64/Packages/f/fastfetch-2.66.0-1.el10_3.aarch64.rpm;name=aarch64_fastfetch;unpack=0"
SRC_URI:append = " ${URI_aarch64_fastfetch}"
SRC_URI[aarch64_fastfetch.sha256sum] = "ac5405da8114d7134ade9677ba5d93e219e4753e44551aec7f823c320907997d"

RDEPENDS:fastfetch = " \
 glibc \
 libgcc \
 yyjson \
 "
