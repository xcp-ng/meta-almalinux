# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-graphviz"
PE = "1"
PV = "0.20.1"
PR = "11.el10_0"
PACKAGES = " \
 python-graphviz-doc \
 python3-graphviz \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-graphviz-0.20.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe582d662470d0396a2c5ef48c249d6b6e1c81ee9021d2bf923ff1a522b6be67"

URI_x86_64_v2_python-graphviz-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-graphviz-doc-0.20.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-graphviz-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-graphviz-doc}"
SRC_URI[x86_64_v2_python-graphviz-doc.sha256sum] = "d59e72e4c54b32b425ec7d8965ea41d4dc96b333bbcebd89bd2cf5ad62307608"

URI_x86_64_v2_python3-graphviz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-graphviz-0.20.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-graphviz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-graphviz}"
SRC_URI[x86_64_v2_python3-graphviz.sha256sum] = "48f4aa75c472defa3fda0b673fb8648841b63c155d79c4678a8a563eb2239925"

URI_aarch64_python-graphviz-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-graphviz-doc-0.20.1-11.el10_0.noarch.rpm;name=aarch64_python-graphviz-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-graphviz-doc}"
SRC_URI[aarch64_python-graphviz-doc.sha256sum] = "e3f4a45c744668dbec0e40603f21c922c618548aad2dd91c6b96ff0a92914723"

URI_aarch64_python3-graphviz = "${EPEL_MIRROR}/aarch64/Packages/p/python3-graphviz-0.20.1-11.el10_0.noarch.rpm;name=aarch64_python3-graphviz;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-graphviz}"
SRC_URI[aarch64_python3-graphviz.sha256sum] = "3d3ca112d31123389aabef75f4d1da1ab408b1b6707225b445f14024cc922fa1"

RDEPENDS:python-graphviz-doc = " \
 "
RDEPENDS:python3-graphviz = " \
 graphviz \
 python3 \
 "
