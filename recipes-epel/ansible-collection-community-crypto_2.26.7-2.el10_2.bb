# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-community-crypto"
PV = "2.26.7"
PR = "2.el10_2"
PACKAGES = " \
 ansible-collection-community-crypto \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-community-crypto-2.26.7-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5ace8f08b3d01682322dd6cb3f712d9adba1a79b10206e43dce7963103197ef"

URI_x86_64_v2_ansible-collection-community-crypto = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-community-crypto-2.26.7-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-community-crypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-community-crypto}"
SRC_URI[x86_64_v2_ansible-collection-community-crypto.sha256sum] = "5f7e900c509d421b908914638f5084d96213f8638ef2c80543d7e845aba5c7af"

URI_aarch64_ansible-collection-community-crypto = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-community-crypto-2.26.7-2.el10_2.noarch.rpm;name=aarch64_ansible-collection-community-crypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-community-crypto}"
SRC_URI[aarch64_ansible-collection-community-crypto.sha256sum] = "ba092e0633f926c36e3a4d6d606d953650c4ee443a0827132bf95ec072a2be27"

RDEPENDS:ansible-collection-community-crypto = " \
 ansible-core \
 "
