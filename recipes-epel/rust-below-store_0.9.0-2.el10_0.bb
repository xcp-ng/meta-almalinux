# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-store"
PV = "0.9.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-below-store+default-devel \
 rust-below-store+no-vendor-devel \
 rust-below-store-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-store-0.9.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ce99907c5dec71ca6365ff3c92f2d636ec22f89827eac23789e2d9a1023532a"

URI_x86_64_v2_rust-below-store+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-store+default-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-store+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-store+default-devel}"
SRC_URI[x86_64_v2_rust-below-store+default-devel.sha256sum] = "42698c00123af2807476386f4939bbecffb2ee2e834874ac6d76960e85022949"

URI_x86_64_v2_rust-below-store+no-vendor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-store+no-vendor-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-store+no-vendor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-store+no-vendor-devel}"
SRC_URI[x86_64_v2_rust-below-store+no-vendor-devel.sha256sum] = "60806a4eec1ab3c4feff99faf1359799b73baa4051e6757b4978521a0ca59274"

URI_x86_64_v2_rust-below-store-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-store-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-store-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-store-devel}"
SRC_URI[x86_64_v2_rust-below-store-devel.sha256sum] = "dc11e6831a08cd6c3b0010b17b120747ef08fa7acf44467c9ee963af2db5d135"

URI_aarch64_rust-below-store+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-store+default-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-below-store+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-store+default-devel}"
SRC_URI[aarch64_rust-below-store+default-devel.sha256sum] = "e2e727d14a35cf898433f622e6a754d8a3298839e3c57948d35c6b2135436dac"

URI_aarch64_rust-below-store+no-vendor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-store+no-vendor-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-below-store+no-vendor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-store+no-vendor-devel}"
SRC_URI[aarch64_rust-below-store+no-vendor-devel.sha256sum] = "b36fdab2b449660cba4485a10c39d917e4a3070dccaccba2d6c52e074b2f702b"

URI_aarch64_rust-below-store-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-store-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-below-store-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-store-devel}"
SRC_URI[aarch64_rust-below-store-devel.sha256sum] = "0ffd84f0ff511092d016b6bd39b5eb4c8574627759bcb6f568634679b61eec9e"

RDEPENDS:rust-below-store+default-devel = " \
 cargo \
 rust-below-store+no-vendor-devel \
 rust-below-store-devel \
 "
RDEPENDS:rust-below-store+no-vendor-devel = " \
 cargo \
 rust-below-store-devel \
 rust-zstd+pkg-config-devel \
 rust-zstd-safe+pkg-config-devel \
 "
RDEPENDS:rust-below-store-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-below-common+default-devel \
 rust-below-model+default-devel \
 rust-bitflags+default-devel \
 rust-bitflags+serde-devel \
 rust-bytes+default-devel \
 rust-bytes+serde-devel \
 rust-humantime+default-devel \
 rust-maplit+default-devel \
 rust-memmap2+default-devel \
 rust-nix+default-devel \
 rust-nix+dir-devel \
 rust-nix+event-devel \
 rust-nix+hostname-devel \
 rust-nix+inotify-devel \
 rust-nix+ioctl-devel \
 rust-nix+mman-devel \
 rust-nix+mount-devel \
 rust-nix+net-devel \
 rust-nix+poll-devel \
 rust-nix+ptrace-devel \
 rust-nix+reboot-devel \
 rust-nix+resource-devel \
 rust-nix+sched-devel \
 rust-nix+signal-devel \
 rust-nix+term-devel \
 rust-nix+time-devel \
 rust-nix+user-devel \
 rust-nix+zerocopy-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_cbor+default-devel \
 rust-slog+default-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+nested-values-devel \
 rust-static_assertions+default-devel \
 rust-zstd+default-devel \
 rust-zstd+experimental-devel \
 rust-zstd+zstdmt-devel \
 rust-zstd-safe+default-devel \
 rust-zstd-safe+std-devel \
 "
