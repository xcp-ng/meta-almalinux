# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lazarus"
PV = "4.4"
PR = "1.el10_2"
PACKAGES = " \
 lazarus \
 lazarus-doc \
 lazarus-ide \
 lazarus-lcl \
 lazarus-lcl-gtk2 \
 lazarus-lcl-gtk3 \
 lazarus-lcl-nogui \
 lazarus-lcl-qt5 \
 lazarus-lcl-qt6 \
 lazarus-tools \
 qt5pas \
 qt5pas-devel \
 qt6pas \
 qt6pas-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lazarus-4.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "139eb391aeb5d2b5ff321d11228f72a4cb4b5853159c3a04b26f0a35151ace1f"

URI_aarch64_lazarus = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-4.4-1.el10_2.aarch64.rpm;name=aarch64_lazarus;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus}"
SRC_URI[aarch64_lazarus.sha256sum] = "1d722cab98680ae83219fb8ecdb22339f488c2095b378d7edb48ed333cdb4c59"

URI_aarch64_lazarus-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-doc-4.4-1.el10_2.aarch64.rpm;name=aarch64_lazarus-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-doc}"
SRC_URI[aarch64_lazarus-doc.sha256sum] = "55990e2f1bba0d34230ea6b334781cc64db02cc787de809692895d6dfb0497ad"

URI_aarch64_lazarus-ide = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-ide-4.4-1.el10_2.aarch64.rpm;name=aarch64_lazarus-ide;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-ide}"
SRC_URI[aarch64_lazarus-ide.sha256sum] = "a500960760f170334bd9c34cc3bf9470027845b5afdc6c0c8ef9d999bd858cd3"

URI_aarch64_lazarus-lcl = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-4.4-1.el10_2.aarch64.rpm;name=aarch64_lazarus-lcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl}"
SRC_URI[aarch64_lazarus-lcl.sha256sum] = "f9d950c4fe316cbb34e9468d951420f28b693f12819c78ce1d135181d0793608"

URI_aarch64_lazarus-lcl-gtk2 = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-gtk2-4.4-1.el10_2.aarch64.rpm;name=aarch64_lazarus-lcl-gtk2;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-gtk2}"
SRC_URI[aarch64_lazarus-lcl-gtk2.sha256sum] = "383a75153223f45cfd9319c0eefed2b19c2820bc15fdde29de3c05db278a7dd9"

URI_aarch64_lazarus-lcl-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-gtk3-4.4-1.el10_2.aarch64.rpm;name=aarch64_lazarus-lcl-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-gtk3}"
SRC_URI[aarch64_lazarus-lcl-gtk3.sha256sum] = "877130898a6d97d40902c4b00db9729f09da1cc77a1c3177842c313d64191650"

URI_aarch64_lazarus-lcl-nogui = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-nogui-4.4-1.el10_2.aarch64.rpm;name=aarch64_lazarus-lcl-nogui;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-nogui}"
SRC_URI[aarch64_lazarus-lcl-nogui.sha256sum] = "c3254b2204da05a8886da997f02770b94d51ecb8bb121d62af10f0d2b723dbc4"

URI_aarch64_lazarus-lcl-qt5 = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-qt5-4.4-1.el10_2.aarch64.rpm;name=aarch64_lazarus-lcl-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-qt5}"
SRC_URI[aarch64_lazarus-lcl-qt5.sha256sum] = "169da3d8e17ad0e47f7efa41492141bb71fef50be91b57345f8cdca91651168d"

URI_aarch64_lazarus-lcl-qt6 = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-qt6-4.4-1.el10_2.aarch64.rpm;name=aarch64_lazarus-lcl-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-qt6}"
SRC_URI[aarch64_lazarus-lcl-qt6.sha256sum] = "60688bbd8d4bacf575d5a5fa4fd9f18f5311c5aa3156fa28286abdafab788581"

URI_aarch64_lazarus-tools = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-tools-4.4-1.el10_2.aarch64.rpm;name=aarch64_lazarus-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-tools}"
SRC_URI[aarch64_lazarus-tools.sha256sum] = "6158e8701bb06bd14a102fae9c68a23367ba5cb0ae488a48fcc6b31cc680c002"

URI_aarch64_qt5pas = "${EPEL_MIRROR}/aarch64/Packages/q/qt5pas-2.16-40401.el10_2.aarch64.rpm;name=aarch64_qt5pas;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5pas}"
SRC_URI[aarch64_qt5pas.sha256sum] = "cb19dcb412abc59d1cc107971bcae1b7f4f601e019bd0ccc5c8cb99849d51926"

URI_aarch64_qt5pas-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5pas-devel-2.16-40401.el10_2.aarch64.rpm;name=aarch64_qt5pas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5pas-devel}"
SRC_URI[aarch64_qt5pas-devel.sha256sum] = "e251074e2bce5b8f8b64ba4c36f796d0b62300c6055738bdd9d9b171714c9f1c"

URI_aarch64_qt6pas = "${EPEL_MIRROR}/aarch64/Packages/q/qt6pas-6.2.10-40401.el10_2.aarch64.rpm;name=aarch64_qt6pas;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6pas}"
SRC_URI[aarch64_qt6pas.sha256sum] = "ba7e1e88270ec0cb0cd95a784e214b9303acf7c85ca31c16e2553d4a8e586aeb"

URI_aarch64_qt6pas-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6pas-devel-6.2.10-40401.el10_2.aarch64.rpm;name=aarch64_qt6pas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6pas-devel}"
SRC_URI[aarch64_qt6pas-devel.sha256sum] = "7e22cd5f7a734b364faa4df145552ff3baa22df530724b7455917057d92c40bc"

RDEPENDS:lazarus = " \
 lazarus-ide \
 lazarus-lcl \
 lazarus-lcl-gtk2 \
 lazarus-lcl-nogui \
 lazarus-tools \
 "
RDEPENDS:lazarus-doc = " \
 bash \
 perl-File-Basename \
 perl-File-Find \
 perl-Getopt-Std \
 perl-interpreter \
 perl-vars \
 "
RDEPENDS:lazarus-ide = " \
 atk \
 bash \
 cairo \
 fpc-src \
 gdb \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 hicolor-icon-theme \
 lazarus-lcl \
 lazarus-tools \
 libX11 \
 make \
 pango \
 "
RDEPENDS:lazarus-lcl = " \
 atk \
 bash \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 libX11 \
 pango \
 "
RDEPENDS:lazarus-lcl-gtk2 = " \
 gtk2-devel \
 lazarus-lcl \
 "
RDEPENDS:lazarus-lcl-gtk3 = " \
 gtk3-devel \
 lazarus-lcl \
 "
RDEPENDS:lazarus-lcl-nogui = " \
 lazarus-lcl \
 "
RDEPENDS:lazarus-lcl-qt5 = " \
 lazarus-lcl \
 qt5pas \
 qt5pas-devel \
 "
RDEPENDS:lazarus-lcl-qt6 = " \
 lazarus-lcl \
 qt6pas \
 qt6pas-devel \
 "
RDEPENDS:lazarus-tools = " \
 bash \
 binutils \
 fpc \
 glibc \
 glibc-devel \
 lazarus-lcl \
 perl-Getopt-Std \
 perl-PathTools \
 perl-interpreter \
 perl-vars \
 "
RDEPENDS:qt5pas = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtx11extras \
 "
RDEPENDS:qt5pas-devel = " \
 qt5-qtbase-devel \
 qt5-qtx11extras-devel \
 qt5pas \
 "
RDEPENDS:qt6pas = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:qt6pas-devel = " \
 qt6-qtbase-devel \
 qt6pas \
 "
