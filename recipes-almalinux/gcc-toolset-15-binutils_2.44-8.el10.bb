# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc-toolset-15-binutils"
PV = "2.44"
PR = "8.el10"
PACKAGES = " \
 gcc-toolset-15-binutils \
 gcc-toolset-15-binutils-devel \
 gcc-toolset-15-binutils-gold \
 gcc-toolset-15-binutils-gprofng \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gcc-toolset-15-binutils-2.44-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc5374d653f63a4a49f4645ffa2610a241894ef5fbd89a4b030f96e46924d308"

URI_x86_64_v2_gcc-toolset-15-binutils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-binutils-2.44-8.el10.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-binutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-binutils}"
SRC_URI[x86_64_v2_gcc-toolset-15-binutils.sha256sum] = "fd674d3570b72c5eb9d872d501072f659bccfd3086d20dca6dd3c38c07b17b29"
RPROVIDES:gcc-toolset-15-binutils:x86_64_v2 = "virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_ virtual/libsframe.so.1___64bit_"

URI_x86_64_v2_gcc-toolset-15-binutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-binutils-devel-2.44-8.el10.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-binutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-binutils-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-binutils-devel.sha256sum] = "adcf30e79146bf82fb0760fca5d8b47cd18d8edd783be86d1c2484cc0936d783"

URI_x86_64_v2_gcc-toolset-15-binutils-gold = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-binutils-gold-2.44-8.el10.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-binutils-gold;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-binutils-gold}"
SRC_URI[x86_64_v2_gcc-toolset-15-binutils-gold.sha256sum] = "fb6d19aaaaa50bada17140cc0457839c50b032007290ba10eb3c8318d0d71e9d"

URI_x86_64_v2_gcc-toolset-15-binutils-gprofng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-binutils-gprofng-2.44-8.el10.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-binutils-gprofng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-binutils-gprofng}"
SRC_URI[x86_64_v2_gcc-toolset-15-binutils-gprofng.sha256sum] = "5f1ef6a5075eb51cad64444fd907825c2bec778523466bc451a3b47dbddb93dd"
RPROVIDES:gcc-toolset-15-binutils-gprofng:x86_64_v2 = "virtual/libgprofng.so.0___64bit_"

URI_aarch64_gcc-toolset-15-binutils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-binutils-2.44-8.el10.aarch64.rpm;name=aarch64_gcc-toolset-15-binutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-binutils}"
SRC_URI[aarch64_gcc-toolset-15-binutils.sha256sum] = "1537ee2456104552f892440c7ae43448f27dd134592b2a5209bda644374a08af"
RPROVIDES:gcc-toolset-15-binutils:aarch64 = "virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_ virtual/libsframe.so.1___64bit_"

URI_aarch64_gcc-toolset-15-binutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-binutils-devel-2.44-8.el10.aarch64.rpm;name=aarch64_gcc-toolset-15-binutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-binutils-devel}"
SRC_URI[aarch64_gcc-toolset-15-binutils-devel.sha256sum] = "8e261c4aadc0c4aa58ffa7c001a67d37942af8119ab8fdd266288306c3580077"

URI_aarch64_gcc-toolset-15-binutils-gold = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-binutils-gold-2.44-8.el10.aarch64.rpm;name=aarch64_gcc-toolset-15-binutils-gold;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-binutils-gold}"
SRC_URI[aarch64_gcc-toolset-15-binutils-gold.sha256sum] = "3932d47fff2f40817aba00729d1b47db399a6fcd75af4a9d9dfe53a079fd3a29"

URI_aarch64_gcc-toolset-15-binutils-gprofng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-binutils-gprofng-2.44-8.el10.aarch64.rpm;name=aarch64_gcc-toolset-15-binutils-gprofng;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-binutils-gprofng}"
SRC_URI[aarch64_gcc-toolset-15-binutils-gprofng.sha256sum] = "ad7aeb54e912d5600f0329705328f74ea725f8a09c9896b277621d6561ffbd57"
RPROVIDES:gcc-toolset-15-binutils-gprofng:aarch64 = "virtual/libgprofng.so.0___64bit_"

RDEPENDS:gcc-toolset-15-binutils = " \
 alternatives \
 bash \
 elfutils-debuginfod-client \
 gcc-toolset-15-runtime \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-15-binutils-devel = " \
 bash \
 gcc-toolset-15-binutils \
 virtual/coreutils \
 zlib-ng-compat-devel \
 "
RDEPENDS:gcc-toolset-15-binutils-gold = " \
 bash \
 gcc-toolset-15-binutils \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-15-binutils-gprofng = " \
 bash \
 gcc-toolset-15-binutils \
 glibc \
 libgcc \
 libstdc++ \
 virtual//usr/bin/env \
 virtual/libsframe.so.1___64bit_ \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libctf.so.0_LIBCTF_1.0__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.1__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.2__64bit_ rpm/virtual/libctf.so.0___64bit_ rpm/virtual/libgprofng.so.0___64bit_ rpm/virtual/libsframe.so.1___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libctf.so.0_LIBCTF_1.0__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.1__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.2__64bit_ rpm/virtual/libctf.so.0___64bit_ rpm/virtual/libgprofng.so.0___64bit_ rpm/virtual/libsframe.so.1___64bit_"
