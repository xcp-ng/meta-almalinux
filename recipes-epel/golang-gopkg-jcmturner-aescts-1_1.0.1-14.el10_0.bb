# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-jcmturner-aescts-1"
PV = "1.0.1"
PR = "14.el10_0"
PACKAGES = " \
 golang-gopkg-jcmturner-aescts-1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-jcmturner-aescts-1-1.0.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5f8d09a016a39eaab9632078e7cf6d051095afdc5b19b968ca2b95db3eea999"

URI_x86_64_v2_golang-gopkg-jcmturner-aescts-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-jcmturner-aescts-1-devel-1.0.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-jcmturner-aescts-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-jcmturner-aescts-1-devel}"
SRC_URI[x86_64_v2_golang-gopkg-jcmturner-aescts-1-devel.sha256sum] = "f6329397cd4b700d26aaeafe8c5bea07f9f79ef2ece4ee875b210a425c7fd4ba"

URI_aarch64_golang-gopkg-jcmturner-aescts-1-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-jcmturner-aescts-1-devel-1.0.1-14.el10_0.noarch.rpm;name=aarch64_golang-gopkg-jcmturner-aescts-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-jcmturner-aescts-1-devel}"
SRC_URI[aarch64_golang-gopkg-jcmturner-aescts-1-devel.sha256sum] = "fd758160d64f2077190bff8d65a91429514b55f744cc685cce80df4063598ae9"

RDEPENDS:golang-gopkg-jcmturner-aescts-1-devel = " \
 go-filesystem \
 "
