# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "PackageKit"
PV = "1.2.8"
PR = "9.el10"
PACKAGES = " \
 PackageKit \
 PackageKit-command-not-found \
 PackageKit-glib \
 PackageKit-glib-devel \
 PackageKit-gstreamer-plugin \
 PackageKit-gtk3-module \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/PackageKit-1.2.8-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1a167af0fdd881e5b6d7563a4fc13defa27dc6b9b1f1e447c8df011d215f6885"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-1.2.8-9.el10.x86_64_v2.rpm;name=x86_64_v2_PackageKit;unpack=0"
SRC_URI[x86_64_v2_PackageKit.sha256sum] = "09b286368e79b67fe245f242e987cdef546d322dcd602381e7ce2d9a84aa6879"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-command-not-found-1.2.8-9.el10.x86_64_v2.rpm;name=x86_64_v2_PackageKit-command-not-found;unpack=0"
SRC_URI[x86_64_v2_PackageKit-command-not-found.sha256sum] = "71bbed055aa4fbba672a728194b57e699414644a3ef29b496569d5d5ccc0a499"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-glib-1.2.8-9.el10.x86_64_v2.rpm;name=x86_64_v2_PackageKit-glib;unpack=0"
SRC_URI[x86_64_v2_PackageKit-glib.sha256sum] = "2d857a1741bb329e82494412bc97169e95d8df8e597c279e8ba0dc298d14d752"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/PackageKit-glib-devel-1.2.8-9.el10.x86_64_v2.rpm;name=x86_64_v2_PackageKit-glib-devel;unpack=0"
SRC_URI[x86_64_v2_PackageKit-glib-devel.sha256sum] = "3e23cdef62d9f34ad42d0b41a7e18b85c01dd0756589f4df20263c9ff58a75c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-gstreamer-plugin-1.2.8-9.el10.x86_64_v2.rpm;name=x86_64_v2_PackageKit-gstreamer-plugin;unpack=0"
SRC_URI[x86_64_v2_PackageKit-gstreamer-plugin.sha256sum] = "36939ff832883ff7f5458c01b63dec0f52908ba1a335f7b87c61bfd9e905b0a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-gtk3-module-1.2.8-9.el10.x86_64_v2.rpm;name=x86_64_v2_PackageKit-gtk3-module;unpack=0"
SRC_URI[x86_64_v2_PackageKit-gtk3-module.sha256sum] = "8f42c927f56da670bae0f1164a28a39730165249dc01b11b0c26370aff6661bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-1.2.8-9.el10.aarch64.rpm;name=aarch64_PackageKit;unpack=0"
SRC_URI[aarch64_PackageKit.sha256sum] = "1486119a024aa81bef7f868caa75de8a8a27a4883a9f0e914cdcd665a2d24238"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-command-not-found-1.2.8-9.el10.aarch64.rpm;name=aarch64_PackageKit-command-not-found;unpack=0"
SRC_URI[aarch64_PackageKit-command-not-found.sha256sum] = "b76a6041781e2d4268ebf4cb0340e81f4ad3f30368e182e8ba5d8f2778adf64f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-glib-1.2.8-9.el10.aarch64.rpm;name=aarch64_PackageKit-glib;unpack=0"
SRC_URI[aarch64_PackageKit-glib.sha256sum] = "9a43a632c649a68433a7e4ebdb94fa4e4226c294a4638d727f5bfec8d7f2b856"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/PackageKit-glib-devel-1.2.8-9.el10.aarch64.rpm;name=aarch64_PackageKit-glib-devel;unpack=0"
SRC_URI[aarch64_PackageKit-glib-devel.sha256sum] = "9c2a2ebf4dee7b7581debe94ef58a7915b0c7f091b3825f7ffdb4cc094e52928"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-gstreamer-plugin-1.2.8-9.el10.aarch64.rpm;name=aarch64_PackageKit-gstreamer-plugin;unpack=0"
SRC_URI[aarch64_PackageKit-gstreamer-plugin.sha256sum] = "34cf1d7cc1b454bd6ae16d1c1076ec9a2213992660704aba41c7c30d8d1a83a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-gtk3-module-1.2.8-9.el10.aarch64.rpm;name=aarch64_PackageKit-gtk3-module;unpack=0"
SRC_URI[aarch64_PackageKit-gtk3-module.sha256sum] = "af25210d8aae2b7fd23bba9c3dca36d2bd79047280219ad86dd5eb604bdcdeaa"

RDEPENDS:PackageKit = " \
 PackageKit-glib \
 appstream \
 bash \
 glib2 \
 glibc \
 libdnf \
 libgcc \
 polkit-libs \
 python3 \
 rpm-libs \
 shared-mime-info \
 sqlite-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:PackageKit-command-not-found = " \
 PackageKit \
 PackageKit-glib \
 bash \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:PackageKit-glib = " \
 dbus \
 glib2 \
 glibc \
 gobject-introspection \
 libgcc \
 "
RDEPENDS:PackageKit-glib-devel = " \
 PackageKit-glib \
 dbus-devel \
 glib2-devel \
 pkgconf-pkg-config \
 sqlite-devel \
 "
RDEPENDS:PackageKit-gstreamer-plugin = " \
 PackageKit-glib \
 glib2 \
 glibc \
 gstreamer1 \
 libgcc \
 "
RDEPENDS:PackageKit-gtk3-module = " \
 PackageKit-glib \
 fontconfig \
 glib2 \
 glibc \
 libgcc \
 pango \
 "
