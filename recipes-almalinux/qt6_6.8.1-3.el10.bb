# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6"
PV = "6.8.1"
PR = "3.el10"
PACKAGES = " \
 qt6-filesystem \
 qt6-rpm-macros \
 qt6-srpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-6.8.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1f6285375fe12a510c34fb766a2d979dd86d4c35c3d86d243b075bb41384452"

URI_x86_64_v2_qt6-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-filesystem-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-filesystem}"
SRC_URI[x86_64_v2_qt6-filesystem.sha256sum] = "861aeafaca69e407b4c46691dd68dc440883aedd4261bcdcb3e6dd9224e2f780"

URI_x86_64_v2_qt6-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-rpm-macros-6.8.1-3.el10.noarch.rpm;name=x86_64_v2_qt6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-rpm-macros}"
SRC_URI[x86_64_v2_qt6-rpm-macros.sha256sum] = "395f9800a0728d5d3fae3896b680b7f8609aa3a5e87f802e0057dec42217d435"

URI_x86_64_v2_qt6-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-srpm-macros-6.8.1-3.el10.noarch.rpm;name=x86_64_v2_qt6-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-srpm-macros}"
SRC_URI[x86_64_v2_qt6-srpm-macros.sha256sum] = "e7a6facecee4dbd7a103036eec5509a070faac0895ce9a5cbecd91cfdbd6d82a"

URI_aarch64_qt6-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-filesystem-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-filesystem}"
SRC_URI[aarch64_qt6-filesystem.sha256sum] = "d5030d4676c55c1537bfa6086d5b53aecc7007ab2a1dd3a597c02f75c683caf3"

URI_aarch64_qt6-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-rpm-macros-6.8.1-3.el10.noarch.rpm;name=aarch64_qt6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-rpm-macros}"
SRC_URI[aarch64_qt6-rpm-macros.sha256sum] = "395f9800a0728d5d3fae3896b680b7f8609aa3a5e87f802e0057dec42217d435"

URI_aarch64_qt6-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-srpm-macros-6.8.1-3.el10.noarch.rpm;name=aarch64_qt6-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-srpm-macros}"
SRC_URI[aarch64_qt6-srpm-macros.sha256sum] = "e7a6facecee4dbd7a103036eec5509a070faac0895ce9a5cbecd91cfdbd6d82a"

RDEPENDS:qt6-filesystem = " \
 "
RDEPENDS:qt6-rpm-macros = " \
 bash \
 chrpath \
 cmake \
 gcc-c++ \
 "
RDEPENDS:qt6-srpm-macros = " \
 "
