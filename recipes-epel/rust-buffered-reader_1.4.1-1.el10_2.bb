# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-buffered-reader"
PV = "1.4.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-buffered-reader+bzip2-devel \
 rust-buffered-reader+compression-bzip2-devel \
 rust-buffered-reader+compression-deflate-devel \
 rust-buffered-reader+compression-devel \
 rust-buffered-reader+default-devel \
 rust-buffered-reader+flate2-devel \
 rust-buffered-reader-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-buffered-reader-1.4.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95476d9daf8d1222fad47b97f0fa9d4bcb9ab8a2a98b4ee7154facd50128902f"

URI_x86_64_v2_rust-buffered-reader+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader+bzip2-devel-1.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader+bzip2-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader+bzip2-devel.sha256sum] = "60734a803a67876258e6e077f1e9fa348224882a7678bd25282532cb26badf04"

URI_x86_64_v2_rust-buffered-reader+compression-bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader+compression-bzip2-devel-1.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader+compression-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader+compression-bzip2-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader+compression-bzip2-devel.sha256sum] = "cc51f46fb94750cee3e4854372c7a57802201a3712c40afc09f7957475a8aa4b"

URI_x86_64_v2_rust-buffered-reader+compression-deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader+compression-deflate-devel-1.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader+compression-deflate-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader+compression-deflate-devel.sha256sum] = "45c1793c8a49430983eab1a457ad06e4810503a21865928a60c7371351af080b"

URI_x86_64_v2_rust-buffered-reader+compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader+compression-devel-1.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader+compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader+compression-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader+compression-devel.sha256sum] = "fe3dd6d462c94b8003deab3661e8264e663437e96076d4b64d05c0bdcda81dda"

URI_x86_64_v2_rust-buffered-reader+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader+default-devel-1.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader+default-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader+default-devel.sha256sum] = "ff99d17dcea476a7da3ae601755a4b1dd2ea9cd4c02ed3f2691a5cd6ca600da4"

URI_x86_64_v2_rust-buffered-reader+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader+flate2-devel-1.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader+flate2-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader+flate2-devel.sha256sum] = "ee7997e19d3ab8a96080837485e48fa4080de732e794e5970edf46a97da6659f"

URI_x86_64_v2_rust-buffered-reader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buffered-reader-devel-1.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buffered-reader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buffered-reader-devel}"
SRC_URI[x86_64_v2_rust-buffered-reader-devel.sha256sum] = "5a5026083d8c2b2356f14fafb10776043c40649427da97192f4ba2481c3e41eb"

URI_aarch64_rust-buffered-reader+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader+bzip2-devel-1.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-buffered-reader+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader+bzip2-devel}"
SRC_URI[aarch64_rust-buffered-reader+bzip2-devel.sha256sum] = "411ee092465ae612442a3705e7c3e6bacb000df591f0746c6a35d226dfcc8549"

URI_aarch64_rust-buffered-reader+compression-bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader+compression-bzip2-devel-1.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-buffered-reader+compression-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader+compression-bzip2-devel}"
SRC_URI[aarch64_rust-buffered-reader+compression-bzip2-devel.sha256sum] = "dac053bd17d9743a8f721ebfccf2ea1bb8009f70832f6be9804fa1cdebf62224"

URI_aarch64_rust-buffered-reader+compression-deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader+compression-deflate-devel-1.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-buffered-reader+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader+compression-deflate-devel}"
SRC_URI[aarch64_rust-buffered-reader+compression-deflate-devel.sha256sum] = "f71d0528f51744519bdf5d2c8b97da5c76dcced93136f63a4e0cf7c328255938"

URI_aarch64_rust-buffered-reader+compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader+compression-devel-1.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-buffered-reader+compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader+compression-devel}"
SRC_URI[aarch64_rust-buffered-reader+compression-devel.sha256sum] = "f26bc13f6dee3cfb2e7dd6347a1724b08ce17ddaded385e73d34c0542637ce02"

URI_aarch64_rust-buffered-reader+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader+default-devel-1.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-buffered-reader+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader+default-devel}"
SRC_URI[aarch64_rust-buffered-reader+default-devel.sha256sum] = "efc4bbb8e847ae81918988c51798a9396cedcd1d603d5c7c323459b443b94ca2"

URI_aarch64_rust-buffered-reader+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader+flate2-devel-1.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-buffered-reader+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader+flate2-devel}"
SRC_URI[aarch64_rust-buffered-reader+flate2-devel.sha256sum] = "f50bca6bee360f2ba9cf14ef3c098d37d0ab5f0043a86f2465bbb4420b05777b"

URI_aarch64_rust-buffered-reader-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buffered-reader-devel-1.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-buffered-reader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buffered-reader-devel}"
SRC_URI[aarch64_rust-buffered-reader-devel.sha256sum] = "d56ecb9f527ea279e19311996fdbee18cf2737f5a4556f04b1cba097cfd17fc4"

RDEPENDS:rust-buffered-reader+bzip2-devel = " \
 cargo \
 rust-buffered-reader-devel \
 rust-bzip2+default-devel \
 "
RDEPENDS:rust-buffered-reader+compression-bzip2-devel = " \
 cargo \
 rust-buffered-reader+bzip2-devel \
 rust-buffered-reader-devel \
 "
RDEPENDS:rust-buffered-reader+compression-deflate-devel = " \
 cargo \
 rust-buffered-reader+flate2-devel \
 rust-buffered-reader-devel \
 "
RDEPENDS:rust-buffered-reader+compression-devel = " \
 cargo \
 rust-buffered-reader+compression-bzip2-devel \
 rust-buffered-reader+compression-deflate-devel \
 rust-buffered-reader-devel \
 "
RDEPENDS:rust-buffered-reader+default-devel = " \
 cargo \
 rust-buffered-reader+compression-devel \
 rust-buffered-reader-devel \
 "
RDEPENDS:rust-buffered-reader+flate2-devel = " \
 cargo \
 rust-buffered-reader-devel \
 rust-flate2+default-devel \
 "
RDEPENDS:rust-buffered-reader-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
