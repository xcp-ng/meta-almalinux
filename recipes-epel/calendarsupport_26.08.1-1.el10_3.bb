# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "calendarsupport"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 calendarsupport \
 calendarsupport-devel \
 calendarsupport-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/calendarsupport-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "41ba1d748fd8b63cbe658a44d2cb0156f76a95040f869ea723e84eba00f701bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calendarsupport;unpack=0"
SRC_URI[x86_64_v2_calendarsupport.sha256sum] = "5dfd77de91089c365468ed0bf3d15607864685a5b7190a5952ee80dfcb208201"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calendarsupport-devel;unpack=0"
SRC_URI[x86_64_v2_calendarsupport-devel.sha256sum] = "891dae6e3a1a294bdb1a858a0a9694516351854e40d8df19f94f58c31a37f392"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_calendarsupport-doc;unpack=0"
SRC_URI[x86_64_v2_calendarsupport-doc.sha256sum] = "30c8c3dcb8600d792f825bce36ace5bd3e281eebae196d0ce3ee5afcd8296855"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_calendarsupport;unpack=0"
SRC_URI[aarch64_calendarsupport.sha256sum] = "afec66278506ed5121869ee2a4537918957f1e6d74d79531c48bc8329bb72fda"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_calendarsupport-devel;unpack=0"
SRC_URI[aarch64_calendarsupport-devel.sha256sum] = "21aeda4f42699562218759275665c03eb677bf006151bdada0e5f1757c61f3df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_calendarsupport-doc;unpack=0"
SRC_URI[aarch64_calendarsupport-doc.sha256sum] = "4b057d4ea2d52e058537e60c1bb93d66ff372a36c48d49eac4a93354354b0a8e"

RDEPENDS:calendarsupport = " \
 akonadi-calendar \
 akonadi-server \
 glibc \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kmime \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:calendarsupport-devel = " \
 akonadi-calendar-devel \
 calendarsupport \
 cmake-filesystem \
 kf6-kmime-devel \
 kidentitymanagement-devel \
 "
RDEPENDS:calendarsupport-doc = " \
 "
