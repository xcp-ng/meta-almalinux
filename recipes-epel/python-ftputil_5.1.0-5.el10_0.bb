# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ftputil"
PV = "5.1.0"
PR = "5.el10_0"
PACKAGES = " \
 python3-ftputil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ftputil-5.1.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f42cd159aaea21098d56dd8f693fe374f3c8e8b8f9bedac19c30aeb19e80369b"

URI_x86_64_v2_python3-ftputil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ftputil-5.1.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ftputil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ftputil}"
SRC_URI[x86_64_v2_python3-ftputil.sha256sum] = "4bb36326c14d0c4853c21e59922a888d27cd206f2f0439086d526186eea751fe"

URI_aarch64_python3-ftputil = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ftputil-5.1.0-5.el10_0.noarch.rpm;name=aarch64_python3-ftputil;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ftputil}"
SRC_URI[aarch64_python3-ftputil.sha256sum] = "61435e47e13f63999109153fb4b459b663834427a2eb97994305368e56ef4685"

RDEPENDS:python3-ftputil = " \
 ftp \
 python3 \
 "
