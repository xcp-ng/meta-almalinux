# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bonnie++"
PV = "2.00a"
PR = "23.el10_2"
PACKAGES = " \
 bonnie++ \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bonnie++-2.00a-23.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7eb62ca1076e23e33f7e29c6147b539d2f3ab6bbb89b74c1e461b5a6faeca9a0"

URI_x86_64_v2_bonnie++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bonnie++-2.00a-23.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bonnie++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bonnie++}"
SRC_URI[x86_64_v2_bonnie++.sha256sum] = "11e89ebed91cfb3b66b81e97e3f25e67229dbac688d53f118980bc317d63211e"

URI_aarch64_bonnie++ = "${EPEL_MIRROR}/aarch64/Packages/b/bonnie++-2.00a-23.el10_2.aarch64.rpm;name=aarch64_bonnie++;unpack=0"
SRC_URI:append = " ${URI_aarch64_bonnie++}"
SRC_URI[aarch64_bonnie++.sha256sum] = "a91e58b5fb9010ef1f3733837c52325f98fc2bacd9bb17aa14476ab580091b74"

RDEPENDS:bonnie++ = " \
 glibc \
 libgcc \
 libstdc++ \
 perl-interpreter \
 "
