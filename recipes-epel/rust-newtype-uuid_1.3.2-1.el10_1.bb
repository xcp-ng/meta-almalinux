# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-newtype-uuid"
PV = "1.3.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-newtype-uuid+alloc-devel \
 rust-newtype-uuid+default-devel \
 rust-newtype-uuid+proptest1-devel \
 rust-newtype-uuid+schemars08-devel \
 rust-newtype-uuid+serde-devel \
 rust-newtype-uuid+std-devel \
 rust-newtype-uuid+v4-devel \
 rust-newtype-uuid+v7-devel \
 rust-newtype-uuid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-newtype-uuid-1.3.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "193104165373a1b5bfbca810a1ad7cadd35a1d63c8ae3b57a318173b307e10de"

URI_x86_64_v2_rust-newtype-uuid+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+alloc-devel-1.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+alloc-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+alloc-devel.sha256sum] = "9b33b9ea8c00553599cd03cbdcfc5473ee80df9e6ca2c01b91c6b5e1c84dee9d"

URI_x86_64_v2_rust-newtype-uuid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+default-devel-1.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+default-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+default-devel.sha256sum] = "d5bbbfe5502b34c43591ea9e889f420c8d867269a9d55286d14d51c022933aaa"

URI_x86_64_v2_rust-newtype-uuid+proptest1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+proptest1-devel-1.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+proptest1-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+proptest1-devel.sha256sum] = "770d245076ae31aa232e9e35a05023610f46ff38be57314b175a6c39908b22ff"

URI_x86_64_v2_rust-newtype-uuid+schemars08-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+schemars08-devel-1.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+schemars08-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+schemars08-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+schemars08-devel.sha256sum] = "c85acca32dde37b475bb8b0fe0b762a56b4b1dba93b8f7f1fe9aefadf2f85476"

URI_x86_64_v2_rust-newtype-uuid+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+serde-devel-1.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+serde-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+serde-devel.sha256sum] = "21183ab7bca0b3d36268f52704f907ba6776dcdafdcb264c0de21fc2d0bd08f2"

URI_x86_64_v2_rust-newtype-uuid+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+std-devel-1.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+std-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+std-devel.sha256sum] = "dc887225f8197a5cd270285ca6c2926324f2d2a11a44856a913096e431f352b5"

URI_x86_64_v2_rust-newtype-uuid+v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+v4-devel-1.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+v4-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+v4-devel.sha256sum] = "66d7aac9f02daba50773e57177f66ff669d26341af772750f857f0e87c10feb5"

URI_x86_64_v2_rust-newtype-uuid+v7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+v7-devel-1.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+v7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid+v7-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid+v7-devel.sha256sum] = "ca1b499ea7076f3d4d41f039378580fc4b75d8bfa5f49922c21475ab1c42387c"

URI_x86_64_v2_rust-newtype-uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid-devel-1.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-newtype-uuid-devel}"
SRC_URI[x86_64_v2_rust-newtype-uuid-devel.sha256sum] = "e8eaed4478c193cb6a51782aa4d0d63c13a89ff43c7b8fb1a25f6d6cb02b6260"

URI_aarch64_rust-newtype-uuid+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+alloc-devel-1.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-newtype-uuid+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+alloc-devel}"
SRC_URI[aarch64_rust-newtype-uuid+alloc-devel.sha256sum] = "1530e23ae85df85361b668a8387b23ef3d46095e24bed4aea64102f9d0f83f34"

URI_aarch64_rust-newtype-uuid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+default-devel-1.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-newtype-uuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+default-devel}"
SRC_URI[aarch64_rust-newtype-uuid+default-devel.sha256sum] = "57ca94f4330fec76cb402186883600d4acf0d15d6973b330e48e1f9e1ab4b6a2"

URI_aarch64_rust-newtype-uuid+proptest1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+proptest1-devel-1.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-newtype-uuid+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+proptest1-devel}"
SRC_URI[aarch64_rust-newtype-uuid+proptest1-devel.sha256sum] = "56836be67881c513e8842bde6a4518a4e250555f496cced9a71269b7d68197f3"

URI_aarch64_rust-newtype-uuid+schemars08-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+schemars08-devel-1.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-newtype-uuid+schemars08-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+schemars08-devel}"
SRC_URI[aarch64_rust-newtype-uuid+schemars08-devel.sha256sum] = "8baf1702416c0f55f14cb50ab2b966f3c654b351ebf370308a3601315b5384b1"

URI_aarch64_rust-newtype-uuid+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+serde-devel-1.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-newtype-uuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+serde-devel}"
SRC_URI[aarch64_rust-newtype-uuid+serde-devel.sha256sum] = "0c88b4336f3a5da6fafb0e0c65645c935760a2bf1dc0f94b210b58321fe3be1c"

URI_aarch64_rust-newtype-uuid+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+std-devel-1.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-newtype-uuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+std-devel}"
SRC_URI[aarch64_rust-newtype-uuid+std-devel.sha256sum] = "9c259e60a797876484d9e2bc3f19b8e2a4792feddfd3fd66b0c6e603dfc8b881"

URI_aarch64_rust-newtype-uuid+v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+v4-devel-1.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-newtype-uuid+v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+v4-devel}"
SRC_URI[aarch64_rust-newtype-uuid+v4-devel.sha256sum] = "8b0cf118edb8417919d32295bd09e3b0e2b7a2f6e253abdd17647472c847c88b"

URI_aarch64_rust-newtype-uuid+v7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+v7-devel-1.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-newtype-uuid+v7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid+v7-devel}"
SRC_URI[aarch64_rust-newtype-uuid+v7-devel.sha256sum] = "b9d1c80c031060056f91525f1379e3881368ea34fcede4843e9d8fe07605687c"

URI_aarch64_rust-newtype-uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid-devel-1.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-newtype-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-newtype-uuid-devel}"
SRC_URI[aarch64_rust-newtype-uuid-devel.sha256sum] = "c435bb4e35b74482caecb9cbbbd28dd215d6669a122457367ac9fd15d1864b20"

RDEPENDS:rust-newtype-uuid+alloc-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 "
RDEPENDS:rust-newtype-uuid+default-devel = " \
 cargo \
 rust-newtype-uuid+std-devel \
 rust-newtype-uuid-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-newtype-uuid+proptest1-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-newtype-uuid+schemars08-devel = " \
 cargo \
 rust-newtype-uuid+std-devel \
 rust-newtype-uuid-devel \
 rust-schemars0.8+default-devel \
 rust-schemars0.8+uuid1-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-newtype-uuid+serde-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-uuid+serde-devel \
 "
RDEPENDS:rust-newtype-uuid+std-devel = " \
 cargo \
 rust-newtype-uuid+alloc-devel \
 rust-newtype-uuid-devel \
 rust-uuid+std-devel \
 "
RDEPENDS:rust-newtype-uuid+v4-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-uuid+v4-devel \
 "
RDEPENDS:rust-newtype-uuid+v7-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-uuid+v7-devel \
 "
RDEPENDS:rust-newtype-uuid-devel = " \
 cargo \
 rust \
 rust-uuid-devel \
 "
