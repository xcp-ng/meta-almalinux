# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-yarl"
PV = "1.18.3"
PR = "1.el10_0"
PACKAGES = " \
 python3-yarl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-yarl-1.18.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56beef665a3bd1965ff722553ee25aead7a6aa6952b13798ceac69bf5f2d1e3b"

URI_x86_64_v2_python3-yarl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-yarl-1.18.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-yarl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-yarl}"
SRC_URI[x86_64_v2_python3-yarl.sha256sum] = "fb877da28b4da15d9ae8a09ddf06fb015f8fb75c1d071e155919abbdaadd5acb"

URI_aarch64_python3-yarl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-yarl-1.18.3-1.el10_0.aarch64.rpm;name=aarch64_python3-yarl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-yarl}"
SRC_URI[aarch64_python3-yarl.sha256sum] = "ac72318f8f872e3c90406adb0601625f0904380d50b47ec05830b1e0d9e643f1"

RDEPENDS:python3-yarl = " \
 glibc \
 python3 \
 python3-idna \
 python3-multidict \
 python3-propcache \
 "
