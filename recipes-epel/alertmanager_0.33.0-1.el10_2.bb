# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alertmanager"
PV = "0.33.0"
PR = "1.el10_2"
PACKAGES = " \
 alertmanager \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/alertmanager-0.33.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "86aea593d21ec1a5a5952264ceefd5e37e0aa0c9f4e7245a529f2a2e7b11c1bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alertmanager-0.33.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alertmanager;unpack=0"
SRC_URI[x86_64_v2_alertmanager.sha256sum] = "caf304244d086853cb9c54b7077bd4d5842349068c572c37b0b731094d74a29f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/alertmanager-0.33.0-1.el10_2.aarch64.rpm;name=aarch64_alertmanager;unpack=0"
SRC_URI[aarch64_alertmanager.sha256sum] = "85660487f4bccf2437191e64c2f8623d2d3a29567375f0c4dd3fde8d507e8b75"

RDEPENDS:alertmanager = " \
 bash \
 glibc \
 shadow-utils \
 "
