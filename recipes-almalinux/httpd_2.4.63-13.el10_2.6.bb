# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "httpd"
PV = "2.4.63"
PR = "13.el10_2.6"
PACKAGES = " \
 httpd \
 httpd-core \
 httpd-devel \
 httpd-filesystem \
 httpd-manual \
 httpd-tools \
 mod_ldap \
 mod_lua \
 mod_proxy_html \
 mod_session \
 mod_ssl \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/httpd-2.4.63-13.el10_2.6.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "82111176920f4e7c92e9b20b68ef8b1ad534bb738e3699d90ed5cf22031888f1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-2.4.63-13.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_httpd;unpack=0"
SRC_URI[x86_64_v2_httpd.sha256sum] = "ddfa9895482fe3316717bee4190d89f23af12062fd891249b241a322dbcebbdf"
RPROVIDES:httpd:append:x86_64_v2 = " virtual/httpd_or_nginx virtual/webserver"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-core-2.4.63-13.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_httpd-core;unpack=0"
SRC_URI[x86_64_v2_httpd-core.sha256sum] = "321e8df915e47e7933d12ac194455a5055daef2a11e93bcdcb871176b13aeca4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-devel-2.4.63-13.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_httpd-devel;unpack=0"
SRC_URI[x86_64_v2_httpd-devel.sha256sum] = "01f2fb5070151f4c24dda816a7cef9eeae72eb015fe5ab7bb4317d42dc26fa8f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-filesystem-2.4.63-13.el10_2.6.noarch.rpm;name=x86_64_v2_httpd-filesystem;unpack=0"
SRC_URI[x86_64_v2_httpd-filesystem.sha256sum] = "2d887c9658de80e5f018347a72ff0e89acbb079bbd7a748b53ca6594ecae718a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-manual-2.4.63-13.el10_2.6.noarch.rpm;name=x86_64_v2_httpd-manual;unpack=0"
SRC_URI[x86_64_v2_httpd-manual.sha256sum] = "69567bdd1024b64882fe35313f7a8f2549cab4b9a577ea66ad31608c30f9ff84"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-tools-2.4.63-13.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_httpd-tools;unpack=0"
SRC_URI[x86_64_v2_httpd-tools.sha256sum] = "6cdaad7c70f23c03f21825d82be93cd016c1d69f4b41fb29aea88c70d1f4127b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_ldap-2.4.63-13.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_mod_ldap;unpack=0"
SRC_URI[x86_64_v2_mod_ldap.sha256sum] = "4e86d009194f23426a66b102985d9d6d334f67980ba2160e9a57d7025b3ccd29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_lua-2.4.63-13.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_mod_lua;unpack=0"
SRC_URI[x86_64_v2_mod_lua.sha256sum] = "62a0801734e88d682cc428a07428a66e7990afdc5aed185826c8ddcfbdf5f078"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_proxy_html-2.4.63-13.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_mod_proxy_html;unpack=0"
SRC_URI[x86_64_v2_mod_proxy_html.sha256sum] = "ca2e6b3591f48c641a0616de1184be0fbce371d8f0dc25cdff914df4ecb73867"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_session-2.4.63-13.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_mod_session;unpack=0"
SRC_URI[x86_64_v2_mod_session.sha256sum] = "c72c9c605553fd3d56a656ce03ab915c314f53365f4423083dfc8faf8714943c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_ssl-2.4.63-13.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_mod_ssl;unpack=0"
SRC_URI[x86_64_v2_mod_ssl.sha256sum] = "391ab704c56f04a0ca0f7b3f02bf2e6b745269c468138820e7ce18566a1e5790"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-2.4.63-13.el10_2.6.aarch64.rpm;name=aarch64_httpd;unpack=0"
SRC_URI[aarch64_httpd.sha256sum] = "198c66452f481c3d6101a4099990df9ee6485ab35f72655f3ca5af1fe7d9128e"
RPROVIDES:httpd:append:aarch64 = " virtual/httpd_or_nginx virtual/webserver"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-core-2.4.63-13.el10_2.6.aarch64.rpm;name=aarch64_httpd-core;unpack=0"
SRC_URI[aarch64_httpd-core.sha256sum] = "6c8ead4b871f20855d02e72e3bef0ad42cd0246b88767a4196daf0ab58ffcfe8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-devel-2.4.63-13.el10_2.6.aarch64.rpm;name=aarch64_httpd-devel;unpack=0"
SRC_URI[aarch64_httpd-devel.sha256sum] = "57cfe372e635bd50ba0b39e448403c87c6a1269d7345a1fdaa70b0881247bdda"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-filesystem-2.4.63-13.el10_2.6.noarch.rpm;name=aarch64_httpd-filesystem;unpack=0"
SRC_URI[aarch64_httpd-filesystem.sha256sum] = "2d887c9658de80e5f018347a72ff0e89acbb079bbd7a748b53ca6594ecae718a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-manual-2.4.63-13.el10_2.6.noarch.rpm;name=aarch64_httpd-manual;unpack=0"
SRC_URI[aarch64_httpd-manual.sha256sum] = "69567bdd1024b64882fe35313f7a8f2549cab4b9a577ea66ad31608c30f9ff84"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-tools-2.4.63-13.el10_2.6.aarch64.rpm;name=aarch64_httpd-tools;unpack=0"
SRC_URI[aarch64_httpd-tools.sha256sum] = "944b1862bcf6257090cfefa5cd00b37a90d1031c852480d14f91077882a08e14"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_ldap-2.4.63-13.el10_2.6.aarch64.rpm;name=aarch64_mod_ldap;unpack=0"
SRC_URI[aarch64_mod_ldap.sha256sum] = "4ecc7a48b3e111f4a016dbf5337cc77ecc8865172fb1b456be3f91bf38e848aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_lua-2.4.63-13.el10_2.6.aarch64.rpm;name=aarch64_mod_lua;unpack=0"
SRC_URI[aarch64_mod_lua.sha256sum] = "8dab8b4cca2423c47eed9b84ff69b0691ba43213cedcc94df8b6439dc0201de9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_proxy_html-2.4.63-13.el10_2.6.aarch64.rpm;name=aarch64_mod_proxy_html;unpack=0"
SRC_URI[aarch64_mod_proxy_html.sha256sum] = "91fc6dc1080c5c6c8cf5cbc4166dc0dc077f6c63d9eeccb3fddd10dd34aa1316"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_session-2.4.63-13.el10_2.6.aarch64.rpm;name=aarch64_mod_session;unpack=0"
SRC_URI[aarch64_mod_session.sha256sum] = "05ea8783a6ae6770ebc3bd254eb828758cdfa1023e7fb281ad67fdac093e60ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_ssl-2.4.63-13.el10_2.6.aarch64.rpm;name=aarch64_mod_ssl;unpack=0"
SRC_URI[aarch64_mod_ssl.sha256sum] = "c0216e3b0c6b8b2f5959eb3cdf4ca3e90d138906aee15f5aabcc0bb63b7e43b7"

RDEPENDS:httpd = " \
 almalinux-logos-httpd \
 bash \
 glibc \
 httpd-core \
 libbrotli \
 libselinux \
 systemd \
 systemd-libs \
 "
RDEPENDS:httpd-core = " \
 apr \
 apr-util \
 apr-util-lmdb \
 bash \
 glibc \
 httpd-filesystem \
 httpd-tools \
 mailcap \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:httpd-devel = " \
 apr-devel \
 apr-util-devel \
 bash \
 httpd-core \
 libtool \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:httpd-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:httpd-manual = " \
 httpd-core \
 "
RDEPENDS:httpd-tools = " \
 apr \
 apr-util \
 glibc \
 libxcrypt \
 openssl-libs \
 "
RDEPENDS:mod_ldap = " \
 apr-util-ldap \
 glibc \
 httpd-core \
 openldap \
 "
RDEPENDS:mod_lua = " \
 glibc \
 httpd-core \
 libxcrypt \
 lua-libs \
 "
RDEPENDS:mod_proxy_html = " \
 glibc \
 httpd-core \
 libxml2 \
 "
RDEPENDS:mod_session = " \
 glibc \
 httpd-core \
 "
RDEPENDS:mod_ssl = " \
 bash \
 glibc \
 hostname \
 httpd-core \
 httpd-filesystem \
 openssl-libs \
 sscg \
 "
