# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "smartmontools"
PE = "1"
PV = "7.4"
PR = "9.el10"
PACKAGES = " \
 smartmontools \
 smartmontools-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/smartmontools-7.4-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "73ce656e84ffef3449780a88c89711aa448e3ff02d71a30210b520ba11a7fb13"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/smartmontools-7.4-9.el10.x86_64_v2.rpm;name=x86_64_v2_smartmontools;unpack=0"
SRC_URI[x86_64_v2_smartmontools.sha256sum] = "da01b6aed1f4e5a28c56b4771489936eb75f1e3f5e91bf9669ac2dd2468ddba9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/smartmontools-selinux-7.4-9.el10.noarch.rpm;name=x86_64_v2_smartmontools-selinux;unpack=0"
SRC_URI[x86_64_v2_smartmontools-selinux.sha256sum] = "3f0f8b52c89e380e7d601a78fc9561467bb2da277a58d533cc590629921302b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/smartmontools-7.4-9.el10.aarch64.rpm;name=aarch64_smartmontools;unpack=0"
SRC_URI[aarch64_smartmontools.sha256sum] = "9488f927e53eafa99a130617cfdb6c901708b6bc3514a36a10c0d2617630d64b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/smartmontools-selinux-7.4-9.el10.noarch.rpm;name=aarch64_smartmontools-selinux;unpack=0"
SRC_URI[aarch64_smartmontools-selinux.sha256sum] = "3f0f8b52c89e380e7d601a78fc9561467bb2da277a58d533cc590629921302b2"

RDEPENDS:smartmontools = " \
 bash \
 glibc \
 libcap-ng \
 libgcc \
 libselinux \
 libstdc++ \
 smartmontools-selinux \
 systemd-libs \
 "
RDEPENDS:smartmontools-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 selinux-policy \
 selinux-policy-targeted \
 "
