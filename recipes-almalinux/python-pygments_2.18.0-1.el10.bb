# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pygments"
PV = "2.18.0"
PR = "1.el10"
PACKAGES = " \
 python3-pygments \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-pygments-2.18.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e19ad2c946257227c2f803e8c079e679507ae727ae7ff4d91ee24566ebd4ba1"

URI_x86_64_v2_python3-pygments = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-pygments-2.18.0-1.el10.noarch.rpm;name=x86_64_v2_python3-pygments;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pygments}"
SRC_URI[x86_64_v2_python3-pygments.sha256sum] = "0aa5135cbcd64ca51b1db4c3a093720490c54e5ce0f02ef249356855f1b9133a"

URI_aarch64_python3-pygments = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-pygments-2.18.0-1.el10.noarch.rpm;name=aarch64_python3-pygments;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pygments}"
SRC_URI[aarch64_python3-pygments.sha256sum] = "0aa5135cbcd64ca51b1db4c3a093720490c54e5ce0f02ef249356855f1b9133a"

RDEPENDS:python3-pygments = " \
 python3 \
 "
