# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dotenvy"
PV = "0.15.7"
PR = "6.el10_0"
PACKAGES = " \
 dotenvy \
 rust-dotenvy+clap-devel \
 rust-dotenvy+cli-devel \
 rust-dotenvy+default-devel \
 rust-dotenvy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dotenvy-0.15.7-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1303940e6a992b659a0d1f794f455e4b9713ec46fad44161653d5e814fb70b0f"

URI_x86_64_v2_dotenvy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dotenvy-0.15.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dotenvy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotenvy}"
SRC_URI[x86_64_v2_dotenvy.sha256sum] = "c26afd3a50edf5e064899a2607c5fc4534cd489e7fa06b346edc3d65c24bd919"

URI_x86_64_v2_rust-dotenvy+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dotenvy+clap-devel-0.15.7-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dotenvy+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dotenvy+clap-devel}"
SRC_URI[x86_64_v2_rust-dotenvy+clap-devel.sha256sum] = "42c48d3612444333e5bab00971f3b17b4e1734a74722634ab951f2f74d80138d"

URI_x86_64_v2_rust-dotenvy+cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dotenvy+cli-devel-0.15.7-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dotenvy+cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dotenvy+cli-devel}"
SRC_URI[x86_64_v2_rust-dotenvy+cli-devel.sha256sum] = "39464a3315b30d8db758d30934d3a19a3547fbe05ab3408a2af5a3b80fe4eca3"

URI_x86_64_v2_rust-dotenvy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dotenvy+default-devel-0.15.7-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dotenvy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dotenvy+default-devel}"
SRC_URI[x86_64_v2_rust-dotenvy+default-devel.sha256sum] = "3249a12184a9d07505953e767e8fabea336c7cc579d73809de3791769defd13b"

URI_x86_64_v2_rust-dotenvy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dotenvy-devel-0.15.7-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dotenvy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dotenvy-devel}"
SRC_URI[x86_64_v2_rust-dotenvy-devel.sha256sum] = "f541009351d552b7c40e24aade339af41e80d5fe6c2bf30d21245b6b1911d699"

URI_aarch64_dotenvy = "${EPEL_MIRROR}/aarch64/Packages/d/dotenvy-0.15.7-6.el10_0.aarch64.rpm;name=aarch64_dotenvy;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotenvy}"
SRC_URI[aarch64_dotenvy.sha256sum] = "6293d90ded7332279eb8e4d99ac0ec9995f459de348109092d9cec6873056284"

URI_aarch64_rust-dotenvy+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dotenvy+clap-devel-0.15.7-6.el10_0.noarch.rpm;name=aarch64_rust-dotenvy+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dotenvy+clap-devel}"
SRC_URI[aarch64_rust-dotenvy+clap-devel.sha256sum] = "fd02bce0852206df8ea900241486d4407479b5feac03feffbcf9fab0a5bde96f"

URI_aarch64_rust-dotenvy+cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dotenvy+cli-devel-0.15.7-6.el10_0.noarch.rpm;name=aarch64_rust-dotenvy+cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dotenvy+cli-devel}"
SRC_URI[aarch64_rust-dotenvy+cli-devel.sha256sum] = "221d17b66cbf2cbe99f11008cd30cda8be4a83c36a3fb12d0eb84aa5c3d0b3fc"

URI_aarch64_rust-dotenvy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dotenvy+default-devel-0.15.7-6.el10_0.noarch.rpm;name=aarch64_rust-dotenvy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dotenvy+default-devel}"
SRC_URI[aarch64_rust-dotenvy+default-devel.sha256sum] = "46632f65dbc666c30dc53a3aaf558174a9cc3d05e76596ba871d212e5c7fca80"

URI_aarch64_rust-dotenvy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dotenvy-devel-0.15.7-6.el10_0.noarch.rpm;name=aarch64_rust-dotenvy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dotenvy-devel}"
SRC_URI[aarch64_rust-dotenvy-devel.sha256sum] = "1123e1778820ac7f4b82d3eb05932732d13e67b125ba9890af9d143454cf9109"

RDEPENDS:dotenvy = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-dotenvy+clap-devel = " \
 cargo \
 rust-clap+default-devel \
 rust-dotenvy-devel \
 "
RDEPENDS:rust-dotenvy+cli-devel = " \
 cargo \
 rust-dotenvy+clap-devel \
 rust-dotenvy-devel \
 "
RDEPENDS:rust-dotenvy+default-devel = " \
 cargo \
 rust-dotenvy-devel \
 "
RDEPENDS:rust-dotenvy-devel = " \
 cargo \
 rust \
 "
