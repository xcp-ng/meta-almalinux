# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tor"
PV = "0.4.8.17"
PR = "1.el10_1"
PACKAGES = " \
 tor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tor-0.4.8.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a66cfe4f0a036ee00897bf89f2c38634549c77c039187ed77c7b0929f99f0ad"

URI_x86_64_v2_tor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tor-0.4.8.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tor}"
SRC_URI[x86_64_v2_tor.sha256sum] = "f9665645e2ff09ac7538a919ec44c611b96b8dfbb6d58a23aa2b7aa8afb23651"

URI_aarch64_tor = "${EPEL_MIRROR}/aarch64/Packages/t/tor-0.4.8.17-1.el10_1.aarch64.rpm;name=aarch64_tor;unpack=0"
SRC_URI:append = " ${URI_aarch64_tor}"
SRC_URI[aarch64_tor.sha256sum] = "82839c9c130ee2034fe3bb1e59048b37a45fbab6be0203492746ddb0f229b1c7"

RDEPENDS:tor:x86_64_v2 = " \
 bash \
 glibc \
 libcap \
 libevent \
 libgcc \
 libseccomp \
 libzstd \
 openssl-libs \
 shadow-utils \
 systemd-libs \
 torsocks \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:tor:aarch64 = " \
 bash \
 glibc \
 libcap \
 libevent \
 libgcc \
 libzstd \
 openssl-libs \
 shadow-utils \
 systemd-libs \
 torsocks \
 xz-libs \
 zlib-ng-compat \
"
