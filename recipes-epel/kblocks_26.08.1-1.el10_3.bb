# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kblocks"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kblocks \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kblocks-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f56ff4030528dd57b4bd1cd835e4f7e943c8789aa56fd7530cc78406ff640ecf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kblocks-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kblocks;unpack=0"
SRC_URI[x86_64_v2_kblocks.sha256sum] = "4662e7a24e470ddad8bb6448d2496f850051ce7c7c9281ee896f42741a602a71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kblocks-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kblocks;unpack=0"
SRC_URI[aarch64_kblocks.sha256sum] = "dc0313ac6795facd19dfa7a3083120387336c0ef98059d55c2bc27ec840b1035"

RDEPENDS:kblocks = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
