# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dkms"
PV = "3.3.0"
PR = "1.el10_0"
PACKAGES = " \
 dkms \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dkms-3.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36c1a1dba3aa3620671f75ae9493e94a6ab72ef95e1287532d3ac503ce2c0014"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - dkms: (kernel-64k-devel-matched if kernel-64k-core)
# - dkms: (kernel-rt-debug-devel if kernel-rt-debug-core)
# - dkms: (kernel-rt-devel if kernel-rt-core)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - dkms: (kernel-rt-debug-devel if kernel-rt-debug-core)
# - dkms: (kernel-rt-devel if kernel-rt-core)

URI_x86_64_v2_dkms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dkms-3.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dkms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dkms}"
SRC_URI[x86_64_v2_dkms.sha256sum] = "42825df7d8ca4dcd69177cb18f3b0e3d059709698a7e6c6ad443ad986629c366"

URI_aarch64_dkms = "${EPEL_MIRROR}/aarch64/Packages/d/dkms-3.3.0-1.el10_0.noarch.rpm;name=aarch64_dkms;unpack=0"
SRC_URI:append = " ${URI_aarch64_dkms}"
SRC_URI[aarch64_dkms.sha256sum] = "ccb5daf66dab22b84284a913a6b7d3fc2a97d8ec49df8af00c92b2907f3610e2"

RDEPENDS:dkms:x86_64_v2 = " \
 bash \
 cpio \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 gzip \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmod \
 make \
 patch \
 sed \
 tar \
 virtual/coreutils \
 which \
"
RDEPENDS:dkms:aarch64 = " \
 bash \
 cpio \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 gzip \
 kernel-64k-devel-matched \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmod \
 make \
 patch \
 sed \
 tar \
 virtual/coreutils \
 which \
"
