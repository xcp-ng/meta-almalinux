# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yaml-rust"
PV = "0.4.5"
PR = "11.el10_0"
PACKAGES = " \
 rust-yaml-rust+default-devel \
 rust-yaml-rust-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-yaml-rust-0.4.5-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "369ba5585d774b42d1de7d68f51c87068f576fd559b8c61d7ffd26c255f0abfa"

URI_x86_64_v2_rust-yaml-rust+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust+default-devel-0.4.5-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yaml-rust+default-devel}"
SRC_URI[x86_64_v2_rust-yaml-rust+default-devel.sha256sum] = "80e400e4f68fdf9a6a27099448dd426732dfe40cc2645357d77db39a7bee9e81"

URI_x86_64_v2_rust-yaml-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yaml-rust-devel-0.4.5-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yaml-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yaml-rust-devel}"
SRC_URI[x86_64_v2_rust-yaml-rust-devel.sha256sum] = "6bf9b8eeb368cb147f407fdb5f854d9b4ba5cf169996c5815bf48f21f7dd1a03"

URI_aarch64_rust-yaml-rust+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust+default-devel-0.4.5-11.el10_0.noarch.rpm;name=aarch64_rust-yaml-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yaml-rust+default-devel}"
SRC_URI[aarch64_rust-yaml-rust+default-devel.sha256sum] = "34ea9062066158d0d182b90186903911ec7f58496d4223c529dff5e186eca681"

URI_aarch64_rust-yaml-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yaml-rust-devel-0.4.5-11.el10_0.noarch.rpm;name=aarch64_rust-yaml-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yaml-rust-devel}"
SRC_URI[aarch64_rust-yaml-rust-devel.sha256sum] = "36861fef8fa486112227cc13638d54701c29b328df8eb9635f4d471a89936766"

RDEPENDS:rust-yaml-rust+default-devel = " \
 cargo \
 rust-yaml-rust-devel \
 "
RDEPENDS:rust-yaml-rust-devel = " \
 cargo \
 rust-linked-hash-map+default-devel \
 "
