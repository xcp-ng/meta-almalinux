# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Date-Holidays-DE"
PV = "2.07"
PR = "1.el10_0"
PACKAGES = " \
 perl-Date-Holidays-DE \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Date-Holidays-DE-2.07-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9cc759a48a2c7402072524ee8d400f58ee8e9d6dcd07f23085eed09816c01a93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Date-Holidays-DE-2.07-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Date-Holidays-DE;unpack=0"
SRC_URI[x86_64_v2_perl-Date-Holidays-DE.sha256sum] = "cd5fd73f3ef7879b8a978bfafb6c474ed842adfe484c34cf1aac846620b8c2f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Date-Holidays-DE-2.07-1.el10_0.noarch.rpm;name=aarch64_perl-Date-Holidays-DE;unpack=0"
SRC_URI[aarch64_perl-Date-Holidays-DE.sha256sum] = "33603bb66cd1d2c3c0edb3d40f700905e1bfc0c327e45010cd8d3310245fbcc4"

RDEPENDS:perl-Date-Holidays-DE = " \
 perl-Date-Calc \
 perl-Exporter \
 perl-POSIX \
 perl-Time-Local \
 perl-libs \
 "
