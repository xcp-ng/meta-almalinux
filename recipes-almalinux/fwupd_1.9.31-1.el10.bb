# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fwupd"
PV = "1.9.31"
PR = "1.el10"
PACKAGES = " \
 fwupd \
 fwupd-devel \
 fwupd-plugin-flashrom \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/fwupd-1.9.31-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6719e3a3c732efcef6bfa3950d305f0f63eaf05f4dddba210bc881d2fa1f384c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/fwupd-1.9.31-1.el10.x86_64_v2.rpm;name=x86_64_v2_fwupd;unpack=0"
SRC_URI[x86_64_v2_fwupd.sha256sum] = "bdc98d421aee24d57dc1899dae70e9b3f77a923f51b62f3d3d93fefb1f870f99"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fwupd-devel-1.9.31-1.el10.x86_64_v2.rpm;name=x86_64_v2_fwupd-devel;unpack=0"
SRC_URI[x86_64_v2_fwupd-devel.sha256sum] = "6a07e9cbf2c97544c18981c4dd381311abd50cf0d00798355aec9cfdbc288e4f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fwupd-plugin-flashrom-1.9.31-1.el10.x86_64_v2.rpm;name=x86_64_v2_fwupd-plugin-flashrom;unpack=0"
SRC_URI[x86_64_v2_fwupd-plugin-flashrom.sha256sum] = "8ba836a1b9c48d64de15845372adc342f5a6d9a31646c9e9acd01c8235a33e82"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/fwupd-1.9.31-1.el10.aarch64.rpm;name=aarch64_fwupd;unpack=0"
SRC_URI[aarch64_fwupd.sha256sum] = "bd667ef6634fdd297e2539571327a5e30a9bf2d7e47e5bc29084757f6554c8a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fwupd-devel-1.9.31-1.el10.aarch64.rpm;name=aarch64_fwupd-devel;unpack=0"
SRC_URI[aarch64_fwupd-devel.sha256sum] = "2a10f8043c98964b4c9498a04bf2edcabfed1e02d4f3acd5c7ceaa930735eae3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fwupd-plugin-flashrom-1.9.31-1.el10.aarch64.rpm;name=aarch64_fwupd-plugin-flashrom;unpack=0"
SRC_URI[aarch64_fwupd-plugin-flashrom.sha256sum] = "f4460b55ffacade59ae2903a7e8a3d785f70b46fd65fc715a4570e69396d7f9d"

RDEPENDS:fwupd = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 json-glib \
 libarchive \
 libgcc \
 libgudev \
 libgusb \
 libjcat \
 libxmlb \
 polkit-libs \
 shared-mime-info \
 sqlite-libs \
 systemd \
 systemd-libs \
 tpm2-tss \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:fwupd-devel = " \
 fwupd \
 glib2-devel \
 json-glib-devel \
 libcurl-devel \
 libjcat-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:fwupd-plugin-flashrom = " \
 flashrom \
 fwupd \
 glib2 \
 glibc \
 libgcc \
 "
