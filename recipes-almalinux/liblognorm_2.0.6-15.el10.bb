# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liblognorm"
PV = "2.0.6"
PR = "15.el10"
PACKAGES = " \
 liblognorm \
 liblognorm-devel \
 liblognorm-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/liblognorm-2.0.6-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2547f6141400ec4b2243d833d3b4afcd82ccdb475133037050a0995bde358707"

URI_x86_64_v2_liblognorm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liblognorm-2.0.6-15.el10.x86_64_v2.rpm;name=x86_64_v2_liblognorm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblognorm}"
SRC_URI[x86_64_v2_liblognorm.sha256sum] = "c4862fd6a5584a3942b0106d3e0ab25a58eb486c5153358905f82889c370ca6a"

URI_x86_64_v2_liblognorm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/liblognorm-devel-2.0.6-15.el10.x86_64_v2.rpm;name=x86_64_v2_liblognorm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblognorm-devel}"
SRC_URI[x86_64_v2_liblognorm-devel.sha256sum] = "e3665baa410eb58b4b6d335a0b402cc4a91fdfa8cd0c30c1a45fab6645e6ed43"

URI_x86_64_v2_liblognorm-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liblognorm-doc-2.0.6-15.el10.x86_64_v2.rpm;name=x86_64_v2_liblognorm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblognorm-doc}"
SRC_URI[x86_64_v2_liblognorm-doc.sha256sum] = "f718330b1c66f7df98b64339db373dcd8ea85f591e254d70e5abc1872f6bcd2f"

URI_aarch64_liblognorm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liblognorm-2.0.6-15.el10.aarch64.rpm;name=aarch64_liblognorm;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblognorm}"
SRC_URI[aarch64_liblognorm.sha256sum] = "fd99728ad69b0e2c69232f30a0d1f05d1360201375e32cfd9ed1025528f6a8c2"

URI_aarch64_liblognorm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/liblognorm-devel-2.0.6-15.el10.aarch64.rpm;name=aarch64_liblognorm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblognorm-devel}"
SRC_URI[aarch64_liblognorm-devel.sha256sum] = "a0227400cccf38c2c03d111caf2567ec0423bb70440a55161a4001f79d0959e8"

URI_aarch64_liblognorm-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liblognorm-doc-2.0.6-15.el10.aarch64.rpm;name=aarch64_liblognorm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblognorm-doc}"
SRC_URI[aarch64_liblognorm-doc.sha256sum] = "e562736e9fd0bf31b208502957699ddb94342cfd8abae7250a8ff463e95754b4"

RDEPENDS:liblognorm = " \
 glibc \
 libestr \
 libfastjson \
 pcre2 \
 "
RDEPENDS:liblognorm-devel = " \
 json-c-devel \
 libestr-devel \
 libfastjson-devel \
 liblognorm \
 pkgconf-pkg-config \
 "
RDEPENDS:liblognorm-doc = " \
 "
