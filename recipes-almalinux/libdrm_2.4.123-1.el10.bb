# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdrm"
PV = "2.4.123"
PR = "1.el10"
PACKAGES = " \
 libdrm \
 libdrm-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libdrm-2.4.123-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7129e2d7b66814abb0076c0f1903d00740d9ac98dac0f32384f3bb396c518b5e"

URI_x86_64_v2_libdrm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libdrm-2.4.123-1.el10.x86_64_v2.rpm;name=x86_64_v2_libdrm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdrm}"
SRC_URI[x86_64_v2_libdrm.sha256sum] = "7bfe34a751539df2ca1fbd84175549383ca5e9b09485ffa813e5fbf95c05f00b"

URI_x86_64_v2_libdrm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libdrm-devel-2.4.123-1.el10.x86_64_v2.rpm;name=x86_64_v2_libdrm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdrm-devel}"
SRC_URI[x86_64_v2_libdrm-devel.sha256sum] = "43fbf578d39632cff063e7932b7bece399c0e9637cc70a0160a176927ffd6b31"

URI_aarch64_libdrm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libdrm-2.4.123-1.el10.aarch64.rpm;name=aarch64_libdrm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdrm}"
SRC_URI[aarch64_libdrm.sha256sum] = "3dd78bf5fdcd2aa4b13afce213f0e538ef954e16a2269b5c4205da8ba288388c"

URI_aarch64_libdrm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libdrm-devel-2.4.123-1.el10.aarch64.rpm;name=aarch64_libdrm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdrm-devel}"
SRC_URI[aarch64_libdrm-devel.sha256sum] = "860d8e643e6ee1dca706f1d3a3e8a55eb1b104c5ffbd62b98780942e143341e2"

RDEPENDS:libdrm = " \
 glibc \
 libpciaccess \
 "
RDEPENDS:libdrm-devel = " \
 kernel-headers \
 libdrm \
 libdrm-devel \
 libpciaccess-devel \
 pkgconf-pkg-config \
 "
