# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Future"
PV = "0.52"
PR = "3.el10_2"
PACKAGES = " \
 perl-Future \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Future-0.52-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83479e4bfd21301beda786e339d61a44c2753391d06742c627757f31af6c4515"

URI_x86_64_v2_perl-Future = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Future-0.52-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Future;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Future}"
SRC_URI[x86_64_v2_perl-Future.sha256sum] = "158212c2bddb99483a6e17bc66f915bbb0dd8990952654d75bbc90ff389fc023"

URI_aarch64_perl-Future = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Future-0.52-3.el10_2.noarch.rpm;name=aarch64_perl-Future;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Future}"
SRC_URI[aarch64_perl-Future.sha256sum] = "e573fe0fc1566dcbadcd2fadb7919bd95d7862d8bf1b2d9eb8af8ca4a8d59496"

RDEPENDS:perl-Future = " \
 perl-B \
 perl-Carp \
 perl-Exporter \
 perl-Future \
 perl-Scalar-List-Utils \
 perl-Test-Simple \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-libs \
 perl-overload \
 "
