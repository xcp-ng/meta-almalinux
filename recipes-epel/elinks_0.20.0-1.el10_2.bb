# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "elinks"
PV = "0.20.0"
PR = "1.el10_2"
PACKAGES = " \
 elinks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/elinks-0.20.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e1b5053fc740fde961668aef01817cf1d4766fe36f78f1b0bb01e8237be4e3b"

URI_x86_64_v2_elinks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/elinks-0.20.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_elinks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elinks}"
SRC_URI[x86_64_v2_elinks.sha256sum] = "f4dd4d9370e578e66f11f312d3af2951a765b247d1fc6d289a24b1fcaec740bd"
RPROVIDES:elinks:x86_64_v2 = "virtual/text-www-browser"

URI_aarch64_elinks = "${EPEL_MIRROR}/aarch64/Packages/e/elinks-0.20.0-1.el10_2.aarch64.rpm;name=aarch64_elinks;unpack=0"
SRC_URI:append = " ${URI_aarch64_elinks}"
SRC_URI[aarch64_elinks.sha256sum] = "510736bf7c41faa6cf632406084a3d0995b1e6e0b614179d56c0e228cee0637c"
RPROVIDES:elinks:aarch64 = "virtual/text-www-browser"

RDEPENDS:elinks = " \
 alternatives \
 bash \
 bzip2-libs \
 expat \
 glibc \
 krb5-libs \
 libgcc \
 libidn2 \
 libstdc++ \
 lua-libs \
 openssl-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/text-www-browser"

PROVIDES:append:aarch64 = " rpm/virtual/text-www-browser"
