# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Array-Diff"
PE = "1"
PV = "0.09"
PR = "14.el10_0"
PACKAGES = " \
 perl-Array-Diff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Array-Diff-0.09-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "576423ef83d70f551f19922bc18ad47976cc1df2a3471cd4771c75ec8378e094"

URI_x86_64_v2_perl-Array-Diff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Array-Diff-0.09-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Array-Diff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Array-Diff}"
SRC_URI[x86_64_v2_perl-Array-Diff.sha256sum] = "58df828d589d09603ff4cb9c93d7aac7a6363d44bf44290721e9b36698ca9a56"

URI_aarch64_perl-Array-Diff = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Array-Diff-0.09-14.el10_0.noarch.rpm;name=aarch64_perl-Array-Diff;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Array-Diff}"
SRC_URI[aarch64_perl-Array-Diff.sha256sum] = "46b0699d06a15f9245102c24ac7501909daa2f66f4fff48c1fb83ee31ad6cb2b"

RDEPENDS:perl-Array-Diff = " \
 perl-Algorithm-Diff \
 perl-Class-Accessor \
 perl-base \
 perl-libs \
 "
