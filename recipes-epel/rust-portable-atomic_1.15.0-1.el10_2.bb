# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-portable-atomic"
PV = "1.15.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-portable-atomic+critical-section-devel \
 rust-portable-atomic+default-devel \
 rust-portable-atomic+disable-fiq-devel \
 rust-portable-atomic+fallback-devel \
 rust-portable-atomic+float-devel \
 rust-portable-atomic+force-amo-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic+s-mode-devel \
 rust-portable-atomic+serde-devel \
 rust-portable-atomic+std-devel \
 rust-portable-atomic+unsafe-assume-privileged-devel \
 rust-portable-atomic+unsafe-assume-single-core-devel \
 rust-portable-atomic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-portable-atomic-1.15.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "353f281558b0ef3098e513a07349c40fcfbc24dcece5539fb07a5e5eb4266a69"

URI_x86_64_v2_rust-portable-atomic+critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+critical-section-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+critical-section-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+critical-section-devel.sha256sum] = "07d31f02a86962655b91d11822ed147a48676cb34a58abbc157eefb84598954a"

URI_x86_64_v2_rust-portable-atomic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+default-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+default-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+default-devel.sha256sum] = "53006065afab46e9661454c745690111581eabf13dedb5a1a38e9e141ec62250"

URI_x86_64_v2_rust-portable-atomic+disable-fiq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+disable-fiq-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+disable-fiq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+disable-fiq-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+disable-fiq-devel.sha256sum] = "cfc59e04fae5b1ff48ad86b1d8d763a42532a76c7dc6565d8e585ffba336f725"

URI_x86_64_v2_rust-portable-atomic+fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+fallback-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+fallback-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+fallback-devel.sha256sum] = "0ff8e4d31efd03cc9d4d912da764306d2f10b28b42dfd17ca4974895ede5c014"

URI_x86_64_v2_rust-portable-atomic+float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+float-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+float-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+float-devel.sha256sum] = "c31f8cc9cce8d461eb957ed310bb1df4d1e7366315c932f17a2d86c6d24e0d67"

URI_x86_64_v2_rust-portable-atomic+force-amo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+force-amo-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+force-amo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+force-amo-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+force-amo-devel.sha256sum] = "be0802b932bc0f6371694dffefc1495dbceb1db9f862042293f1ff3b54d75dba"

URI_x86_64_v2_rust-portable-atomic+require-cas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+require-cas-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+require-cas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+require-cas-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+require-cas-devel.sha256sum] = "bd3376da5db57072bc4a7ff91dd99decc059e0a6d54d37951a853c5713178d0e"

URI_x86_64_v2_rust-portable-atomic+s-mode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+s-mode-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+s-mode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+s-mode-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+s-mode-devel.sha256sum] = "a01d7dbe7a8f50d3d217bd944426f16671b6c8020ca53f88da797a88e589ac5f"

URI_x86_64_v2_rust-portable-atomic+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+serde-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+serde-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+serde-devel.sha256sum] = "ab132182996e34be156159f944c445468af6a9d686919aea89b1e4a299afd3d3"

URI_x86_64_v2_rust-portable-atomic+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+std-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+std-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+std-devel.sha256sum] = "2881739227b5ea45a4edf2547897dd004f1c5fc459fa4ee3e1903ac3e0d2c6b4"

URI_x86_64_v2_rust-portable-atomic+unsafe-assume-privileged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+unsafe-assume-privileged-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+unsafe-assume-privileged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+unsafe-assume-privileged-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+unsafe-assume-privileged-devel.sha256sum] = "050e6f294412b63dc11396d439cfd78dd74e37a419cb5907c8cb7425465b4f7b"

URI_x86_64_v2_rust-portable-atomic+unsafe-assume-single-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+unsafe-assume-single-core-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+unsafe-assume-single-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+unsafe-assume-single-core-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+unsafe-assume-single-core-devel.sha256sum] = "92466fe7bbf570ea16e32a6d74ac4cfb9bedd7c5bce3fb72df7e14bf3c2bb42b"

URI_x86_64_v2_rust-portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-devel-1.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-devel.sha256sum] = "70dfad6a8f7d615874ff108bdb2cf8a724387b666a616f31b83c737f70c673a3"

URI_aarch64_rust-portable-atomic+critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+critical-section-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+critical-section-devel}"
SRC_URI[aarch64_rust-portable-atomic+critical-section-devel.sha256sum] = "29d4721f426c35972ee0c93084f155ea126bb65eefd30fcaa4ae0a6ac355ad90"

URI_aarch64_rust-portable-atomic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+default-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+default-devel}"
SRC_URI[aarch64_rust-portable-atomic+default-devel.sha256sum] = "f6827550dbba365b39f91d15a76f83280345e5caae09040171b7b61affeeb0a0"

URI_aarch64_rust-portable-atomic+disable-fiq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+disable-fiq-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic+disable-fiq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+disable-fiq-devel}"
SRC_URI[aarch64_rust-portable-atomic+disable-fiq-devel.sha256sum] = "43b84358bcb8bdaf44f6661326f98e3778afe149b9ed54ae488aa33975026550"

URI_aarch64_rust-portable-atomic+fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+fallback-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+fallback-devel}"
SRC_URI[aarch64_rust-portable-atomic+fallback-devel.sha256sum] = "6bc72233c155e3ac8cb13117f848000156fe6bae35bcceca4f2fd2804aaeec51"

URI_aarch64_rust-portable-atomic+float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+float-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic+float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+float-devel}"
SRC_URI[aarch64_rust-portable-atomic+float-devel.sha256sum] = "61e5ab42dd2800f3bdb33600dbf5e0b28f826fe855b4231f8c7d0b91a175fca7"

URI_aarch64_rust-portable-atomic+force-amo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+force-amo-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic+force-amo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+force-amo-devel}"
SRC_URI[aarch64_rust-portable-atomic+force-amo-devel.sha256sum] = "00045145914d6dd274c89d3e6397243a7ac0ef46c97123a6692466dc8598388e"

URI_aarch64_rust-portable-atomic+require-cas-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+require-cas-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic+require-cas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+require-cas-devel}"
SRC_URI[aarch64_rust-portable-atomic+require-cas-devel.sha256sum] = "288acb52c8f67f5d3fb932795db8b91be883292c66a6cbae1ac3fb996637153c"

URI_aarch64_rust-portable-atomic+s-mode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+s-mode-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic+s-mode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+s-mode-devel}"
SRC_URI[aarch64_rust-portable-atomic+s-mode-devel.sha256sum] = "ddbc6d53add0553d08c853932e0665fb90b50b0c1d39a5c75af98819111cbe78"

URI_aarch64_rust-portable-atomic+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+serde-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+serde-devel}"
SRC_URI[aarch64_rust-portable-atomic+serde-devel.sha256sum] = "2dae4b227eee8085b79a64aa85e30158fd40bdd19eb5b3dd1b7183c421513c6b"

URI_aarch64_rust-portable-atomic+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+std-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+std-devel}"
SRC_URI[aarch64_rust-portable-atomic+std-devel.sha256sum] = "083b49d5ba2a6f3151441539961175ab39fe3104405563b9029572223c26b490"

URI_aarch64_rust-portable-atomic+unsafe-assume-privileged-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+unsafe-assume-privileged-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic+unsafe-assume-privileged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+unsafe-assume-privileged-devel}"
SRC_URI[aarch64_rust-portable-atomic+unsafe-assume-privileged-devel.sha256sum] = "1217da07e6aeb7ab04e72c9016979df683989f887091dd1d65e6743a93b8cf60"

URI_aarch64_rust-portable-atomic+unsafe-assume-single-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+unsafe-assume-single-core-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic+unsafe-assume-single-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+unsafe-assume-single-core-devel}"
SRC_URI[aarch64_rust-portable-atomic+unsafe-assume-single-core-devel.sha256sum] = "ff5357bad6a5f08ec6500aa0472128f3fd40c186d6b2d5babc04f9ae57c78ebc"

URI_aarch64_rust-portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-devel-1.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-devel}"
SRC_URI[aarch64_rust-portable-atomic-devel.sha256sum] = "c0bc1871d3c74c2db92cff4c4f6e16d36d5c6fe4d1b193b3158df69758b349e8"

RDEPENDS:rust-portable-atomic+critical-section-devel = " \
 cargo \
 rust-critical-section+default-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+default-devel = " \
 cargo \
 rust-portable-atomic+fallback-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+disable-fiq-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+fallback-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+float-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+force-amo-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+require-cas-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+s-mode-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+serde-devel = " \
 cargo \
 rust-portable-atomic-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-portable-atomic+std-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+unsafe-assume-privileged-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+unsafe-assume-single-core-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic-devel = " \
 cargo \
 rust \
 "
