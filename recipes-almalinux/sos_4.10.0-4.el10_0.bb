# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sos"
PV = "4.10.0"
PR = "4.el10_0"
PACKAGES = " \
 sos \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sos-4.10.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "456dbe8e1281a041004888551ef6d66cb7ee233250f2b80cb5ba2877a37922ba"

URI_x86_64_v2_sos = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sos-4.10.0-4.el10_0.noarch.rpm;name=x86_64_v2_sos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sos}"
SRC_URI[x86_64_v2_sos.sha256sum] = "48219fec7104978d4599350a4a2040434684c48ee4850e0b105ce2925736f574"

URI_aarch64_sos = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sos-4.10.0-4.el10_0.noarch.rpm;name=aarch64_sos;unpack=0"
SRC_URI:append = " ${URI_aarch64_sos}"
SRC_URI[aarch64_sos.sha256sum] = "48219fec7104978d4599350a4a2040434684c48ee4850e0b105ce2925736f574"

RDEPENDS:sos = " \
 python3 \
 python3-packaging \
 python3-pexpect \
 python3-pyyaml \
 python3-requests \
 python3-setuptools \
 "
