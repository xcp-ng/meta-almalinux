# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtserialport"
PV = "6.9.1"
PR = "3.el10"
PACKAGES = " \
 qt6-qtserialport \
 qt6-qtserialport-devel \
 qt6-qtserialport-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtserialport-6.9.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d52c6119c44917e00e1297b539468f8c4dcca26e35a915119376ddd26033aa9"

URI_x86_64_v2_qt6-qtserialport = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtserialport-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialport}"
SRC_URI[x86_64_v2_qt6-qtserialport.sha256sum] = "c490eaef2e2dc4fbc7573478eae1d0f553f9dfadeed52ff3790e330da1336993"

URI_x86_64_v2_qt6-qtserialport-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtserialport-devel-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialport-devel}"
SRC_URI[x86_64_v2_qt6-qtserialport-devel.sha256sum] = "b5acc88fb623aa9203ccb1d3c5cd52225377e9146fb7e1ad9780ca96cb76fdd7"

URI_x86_64_v2_qt6-qtserialport-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtserialport-examples-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialport-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialport-examples}"
SRC_URI[x86_64_v2_qt6-qtserialport-examples.sha256sum] = "72ed1a7d28ed7196f24f8f06061c2b2136a029ab1a31ef54ac6664929b159c9f"

URI_aarch64_qt6-qtserialport = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtserialport-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtserialport;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialport}"
SRC_URI[aarch64_qt6-qtserialport.sha256sum] = "8a12958782ca810c67446b1eefe641a27356615d07e6d3293a48a96aa4cf4c36"

URI_aarch64_qt6-qtserialport-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtserialport-devel-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtserialport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialport-devel}"
SRC_URI[aarch64_qt6-qtserialport-devel.sha256sum] = "ab2ed718f1ee7b63e7824606e08af5cd071f1b3fee0c234eb60fabd8640f5492"

URI_aarch64_qt6-qtserialport-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtserialport-examples-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtserialport-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialport-examples}"
SRC_URI[aarch64_qt6-qtserialport-examples.sha256sum] = "45a616aca15bd6dac81b9d93ece45ddebd9383ba0be6769a4d1f0731b43177bb"

RDEPENDS:qt6-qtserialport = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 systemd-libs \
 "
RDEPENDS:qt6-qtserialport-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtserialport \
 "
RDEPENDS:qt6-qtserialport-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtserialport \
 "
