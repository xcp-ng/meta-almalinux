# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Object-Pad"
PV = "0.812"
PR = "1.el10_0"
PACKAGES = " \
 perl-Object-Pad \
 perl-Object-Pad-ExtensionBuilder \
 perl-Object-Pad-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Object-Pad-0.812-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "222659bc1ce1b6525fc28a4bfbfa9a2032a158f32798517a11b4190f1149724e"

URI_x86_64_v2_perl-Object-Pad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Object-Pad-0.812-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Object-Pad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Object-Pad}"
SRC_URI[x86_64_v2_perl-Object-Pad.sha256sum] = "5403f82ec3a6255dc7e7600b4eb37c3905fc67524ecc8a1f609628d28ba42953"

URI_x86_64_v2_perl-Object-Pad-ExtensionBuilder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Object-Pad-ExtensionBuilder-0.812-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Object-Pad-ExtensionBuilder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Object-Pad-ExtensionBuilder}"
SRC_URI[x86_64_v2_perl-Object-Pad-ExtensionBuilder.sha256sum] = "22677b9a86b9c3f824081ee46c04a5509c6a5934f72ba9d3966248bf9b189d09"

URI_x86_64_v2_perl-Object-Pad-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Object-Pad-tests-0.812-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Object-Pad-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Object-Pad-tests}"
SRC_URI[x86_64_v2_perl-Object-Pad-tests.sha256sum] = "c286de61589e108dc49f3feadaf5ef94c4b161fd31985afe69d9eec96da6f173"

URI_aarch64_perl-Object-Pad = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Object-Pad-0.812-1.el10_0.aarch64.rpm;name=aarch64_perl-Object-Pad;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Object-Pad}"
SRC_URI[aarch64_perl-Object-Pad.sha256sum] = "899c65fe44126d4cbae065da2047747a21d8b962f329c6dae2b0d28afebe1de6"

URI_aarch64_perl-Object-Pad-ExtensionBuilder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Object-Pad-ExtensionBuilder-0.812-1.el10_0.aarch64.rpm;name=aarch64_perl-Object-Pad-ExtensionBuilder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Object-Pad-ExtensionBuilder}"
SRC_URI[aarch64_perl-Object-Pad-ExtensionBuilder.sha256sum] = "7488eca5358a86f22871d1405a74800f8323baf63b00ec59ea12fcc1999eaa70"

URI_aarch64_perl-Object-Pad-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Object-Pad-tests-0.812-1.el10_0.noarch.rpm;name=aarch64_perl-Object-Pad-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Object-Pad-tests}"
SRC_URI[aarch64_perl-Object-Pad-tests.sha256sum] = "3efaeceaea6427046250f5ea60901d9c551c2045e4f7a6828a2e6b4c771f6be2"

RDEPENDS:perl-Object-Pad = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-Object-Pad \
 perl-XS-Parse-Keyword \
 perl-XS-Parse-Sublike \
 perl-experimental \
 perl-libs \
 perl-mro \
 "
RDEPENDS:perl-Object-Pad-ExtensionBuilder = " \
 perl-File-ShareDir \
 perl-Object-Pad \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 rpm \
 "
RDEPENDS:perl-Object-Pad-tests = " \
 bash \
 perl-Data-Dumper \
 perl-Object-Pad \
 perl-Object-Pad-ExtensionBuilder \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Test2-Suite \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-threads \
 "
