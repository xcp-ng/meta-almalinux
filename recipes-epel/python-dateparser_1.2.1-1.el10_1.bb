# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dateparser"
PV = "1.2.1"
PR = "1.el10_1"
PACKAGES = " \
 python-dateparser-doc \
 python3-dateparser \
 python3-dateparser+langdetect \
 python3-dateparser-scripts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-dateparser-1.2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "717e74b52bac6568e7a4d38bb9a299a6650c556158f8d56a9a6f27df4ac0c8bb"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3-dateparser-scripts: python3dist(gitpython)

URI_x86_64_v2_python-dateparser-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-dateparser-doc-1.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-dateparser-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-dateparser-doc}"
SRC_URI[x86_64_v2_python-dateparser-doc.sha256sum] = "a2e38901dc6319312e11ea060fb544426bca2e134a3e18facb2166806cdc6988"

URI_x86_64_v2_python3-dateparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dateparser-1.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dateparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dateparser}"
SRC_URI[x86_64_v2_python3-dateparser.sha256sum] = "9ae5e0caffbcb5d09d3556ff4add1d0ffd85cf857b0426c8f84d89e9bce475a1"

URI_x86_64_v2_python3-dateparser+langdetect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dateparser+langdetect-1.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dateparser+langdetect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dateparser+langdetect}"
SRC_URI[x86_64_v2_python3-dateparser+langdetect.sha256sum] = "e26af4bb7e18aa32ba607688f223ba964b32ec1ec9c5c02efc44d431352a61a3"

URI_x86_64_v2_python3-dateparser-scripts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dateparser-scripts-1.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dateparser-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dateparser-scripts}"
SRC_URI[x86_64_v2_python3-dateparser-scripts.sha256sum] = "114125bee7d60c4ddeb0c817f91b957d4ae1536f197672a0154d5b0d967077cf"

URI_aarch64_python-dateparser-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-dateparser-doc-1.2.1-1.el10_1.noarch.rpm;name=aarch64_python-dateparser-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-dateparser-doc}"
SRC_URI[aarch64_python-dateparser-doc.sha256sum] = "0bf78acee1d93d43f92c5c99b3987b1c00c4d5f7fbd4b8bec79de465eec67c28"

URI_aarch64_python3-dateparser = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dateparser-1.2.1-1.el10_1.noarch.rpm;name=aarch64_python3-dateparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dateparser}"
SRC_URI[aarch64_python3-dateparser.sha256sum] = "6bd737e1168f52b0671c70b6408e5b37517bb1ac6aaec9795a385e6ed123db6e"

URI_aarch64_python3-dateparser+langdetect = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dateparser+langdetect-1.2.1-1.el10_1.noarch.rpm;name=aarch64_python3-dateparser+langdetect;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dateparser+langdetect}"
SRC_URI[aarch64_python3-dateparser+langdetect.sha256sum] = "488c158a12527e005cf02d7ee474a819c4eb0d638fec21564e51c5baf44b465a"

URI_aarch64_python3-dateparser-scripts = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dateparser-scripts-1.2.1-1.el10_1.noarch.rpm;name=aarch64_python3-dateparser-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dateparser-scripts}"
SRC_URI[aarch64_python3-dateparser-scripts.sha256sum] = "e33769b5484e7eb6ae5e3ba8827029eef70c8598f18ba3f3eea45e2cf63fc405"

RDEPENDS:python-dateparser-doc = " \
 "
RDEPENDS:python3-dateparser = " \
 python3 \
 python3-dateutil \
 python3-pytz \
 python3-regex \
 python3-tzlocal \
 "
RDEPENDS:python3-dateparser+langdetect = " \
 python3 \
 python3-dateparser \
 python3-langdetect \
 "
RDEPENDS:python3-dateparser-scripts:x86_64_v2 = " \
 python3 \
 python3-dateparser \
 python3-parsel \
 python3-requests \
 python3-ruamel-yaml \
"
RDEPENDS:python3-dateparser-scripts:aarch64 = " \
 python3 \
 python3-GitPython \
 python3-dateparser \
 python3-parsel \
 python3-requests \
 python3-ruamel-yaml \
"
