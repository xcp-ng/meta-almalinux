# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "azure-protected-vm-secrets"
PV = "1.0.9"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 azure-protected-vm-secrets \
 azure-protected-vm-secrets-devel \
 azure-protected-vm-secrets-libs \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/azure-protected-vm-secrets-1.0.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7cba62cc9ca110e9ac601b707bdff9b75ae29c1cacc493bd917491f8e3a020d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/azure-protected-vm-secrets-1.0.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_azure-protected-vm-secrets;unpack=0"
SRC_URI[x86_64_v2_azure-protected-vm-secrets.sha256sum] = "2144f06997f0a0e231cc1806f75ac53e1f2d8fb870c8a1b89235810aa57dc13d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/azure-protected-vm-secrets-devel-1.0.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_azure-protected-vm-secrets-devel;unpack=0"
SRC_URI[x86_64_v2_azure-protected-vm-secrets-devel.sha256sum] = "ad5e41785492d1f3103fc53851199ca22421289f62ec61bda83ba0e5dafe5197"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/azure-protected-vm-secrets-libs-1.0.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_azure-protected-vm-secrets-libs;unpack=0"
SRC_URI[x86_64_v2_azure-protected-vm-secrets-libs.sha256sum] = "d65a131b44c43deb22119e9c8151cd0d2f430267d286fb3d416a05af1c6878c9"

RDEPENDS:azure-protected-vm-secrets = " \
 azure-protected-vm-secrets-libs \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 "
RDEPENDS:azure-protected-vm-secrets-devel = " \
 azure-protected-vm-secrets-libs \
 "
RDEPENDS:azure-protected-vm-secrets-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 systemd-libs \
 tpm2-tss \
 "
