# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtshadertools"
PV = "6.8.1"
PR = "4.el10"
PACKAGES = " \
 qt6-qtshadertools \
 qt6-qtshadertools-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtshadertools-6.8.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e67ffa7424b9ac3f827b65ee2a4f58387630b8d78faa72cdb20df752fe035d48"

URI_x86_64_v2_qt6-qtshadertools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtshadertools-6.8.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtshadertools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtshadertools}"
SRC_URI[x86_64_v2_qt6-qtshadertools.sha256sum] = "e17b3a552ddf342dbe14d062f9022058da905c90a9f9ee4a965a2e136f281a66"

URI_x86_64_v2_qt6-qtshadertools-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtshadertools-devel-6.8.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtshadertools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtshadertools-devel}"
SRC_URI[x86_64_v2_qt6-qtshadertools-devel.sha256sum] = "26b30d94ada99583e3352522aeaf8d2a4236f426d34c71ab629259323d550f32"

URI_aarch64_qt6-qtshadertools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtshadertools-6.8.1-4.el10.aarch64.rpm;name=aarch64_qt6-qtshadertools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtshadertools}"
SRC_URI[aarch64_qt6-qtshadertools.sha256sum] = "19c2f0ac2684deb97dfda131f810ac6438187a67fbf85a7ec343c8fcf09336f8"

URI_aarch64_qt6-qtshadertools-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtshadertools-devel-6.8.1-4.el10.aarch64.rpm;name=aarch64_qt6-qtshadertools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtshadertools-devel}"
SRC_URI[aarch64_qt6-qtshadertools-devel.sha256sum] = "27ec82d00abee846a663ae040f393c9b95270e995a5a46d728fe904165bcafec"

RDEPENDS:qt6-qtshadertools = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 spirv-tools-libs \
 "
RDEPENDS:qt6-qtshadertools-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtshadertools \
 spirv-tools \
 "
