# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tower-test"
PV = "0.4.0"
PR = "12.el10_2"
PACKAGES = " \
 rust-tower-test+default-devel \
 rust-tower-test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tower-test-0.4.0-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "402b5ffaa9d1e6feb0c5f58ab869556f66d105ae97915344c1115e7efa01a6f2"

URI_x86_64_v2_rust-tower-test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-test+default-devel-0.4.0-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-test+default-devel}"
SRC_URI[x86_64_v2_rust-tower-test+default-devel.sha256sum] = "00a6470e1bee99e227d781c255c00a36f8ea4f176e799fc3a1e7a723b577f64c"

URI_x86_64_v2_rust-tower-test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-test-devel-0.4.0-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-test-devel}"
SRC_URI[x86_64_v2_rust-tower-test-devel.sha256sum] = "076518ed5aff4700d1b7d2691c32cff7f463c1010898b689618820ddeeeba085"

URI_aarch64_rust-tower-test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-test+default-devel-0.4.0-12.el10_2.noarch.rpm;name=aarch64_rust-tower-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-test+default-devel}"
SRC_URI[aarch64_rust-tower-test+default-devel.sha256sum] = "ab519c11e4324f070bbcce687dbcd613e37969bd304c454977dae4d4f49bae38"

URI_aarch64_rust-tower-test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-test-devel-0.4.0-12.el10_2.noarch.rpm;name=aarch64_rust-tower-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-test-devel}"
SRC_URI[aarch64_rust-tower-test-devel.sha256sum] = "f3ad21b0a0d1b490fde0c45d3e5b5e7ab463363788c9b30be95b6b37d0661fb8"

RDEPENDS:rust-tower-test+default-devel = " \
 cargo \
 rust-tower-test-devel \
 "
RDEPENDS:rust-tower-test-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-pin-project+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tokio-test+default-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
