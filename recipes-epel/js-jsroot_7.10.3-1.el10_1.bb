# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "js-jsroot"
PV = "7.10.3"
PR = "1.el10_1"
PACKAGES = " \
 js-jsroot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/js-jsroot-7.10.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bbf95bee9b739aa66cf2490dab9a75031df9d1d8f709dde2f3d9523cf311001"

URI_x86_64_v2_js-jsroot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/js-jsroot-7.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_js-jsroot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_js-jsroot}"
SRC_URI[x86_64_v2_js-jsroot.sha256sum] = "b6a4b0116e5bc3d15aea989658c9b81b1aa37d7747887f0bd161fe8ad6d27e05"

URI_aarch64_js-jsroot = "${EPEL_MIRROR}/aarch64/Packages/j/js-jsroot-7.10.3-1.el10_1.noarch.rpm;name=aarch64_js-jsroot;unpack=0"
SRC_URI:append = " ${URI_aarch64_js-jsroot}"
SRC_URI[aarch64_js-jsroot.sha256sum] = "e8793ea114266685237c9bf721a3e5b2c6802ec6fb9c45077e743a753ad0711e"

RDEPENDS:js-jsroot = " \
 mathjax3 \
 web-assets-filesystem \
 "
