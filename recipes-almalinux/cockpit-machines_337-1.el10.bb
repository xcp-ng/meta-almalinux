# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-machines"
PV = "337"
PR = "1.el10"
PACKAGES = " \
 cockpit-machines \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-machines-337-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b2c5b407d94f6bb8fafb7d7cce0be675e116d70f72e232d0d429704c2375395"

URI_x86_64_v2_cockpit-machines = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-machines-337-1.el10.noarch.rpm;name=x86_64_v2_cockpit-machines;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-machines}"
SRC_URI[x86_64_v2_cockpit-machines.sha256sum] = "244483816a661bfe3a4b088533e0cdd9c9d49a8a7cc0df58614d1ee1aae6b503"

URI_aarch64_cockpit-machines = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-machines-337-1.el10.noarch.rpm;name=aarch64_cockpit-machines;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-machines}"
SRC_URI[aarch64_cockpit-machines.sha256sum] = "244483816a661bfe3a4b088533e0cdd9c9d49a8a7cc0df58614d1ee1aae6b503"

RDEPENDS:cockpit-machines = " \
 cockpit-bridge \
 libvirt-client \
 libvirt-daemon-config-network \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-storage-core \
 libvirt-dbus \
 qemu-kvm \
 virt-install \
 "
