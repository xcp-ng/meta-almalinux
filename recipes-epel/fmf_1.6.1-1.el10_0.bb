# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fmf"
PV = "1.6.1"
PR = "1.el10_0"
PACKAGES = " \
 fmf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fmf-1.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1c60631b5a64d8ef486f17e344e9247b52872c5c8087e33f7d05bfded54b510"

URI_x86_64_v2_fmf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fmf-1.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fmf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fmf}"
SRC_URI[x86_64_v2_fmf.sha256sum] = "fb26b664a0c2d0fa5b1b236d20abef6452807cd425e7cb28d53d69d183364fe0"

URI_aarch64_fmf = "${EPEL_MIRROR}/aarch64/Packages/f/fmf-1.6.1-1.el10_0.noarch.rpm;name=aarch64_fmf;unpack=0"
SRC_URI:append = " ${URI_aarch64_fmf}"
SRC_URI[aarch64_fmf.sha256sum] = "189e8534232b39d1a519bfe2c5387722175b8c02d116143a3e9588bde2dc654b"

RDEPENDS:fmf = " \
 git-core \
 python3 \
 python3-filelock \
 python3-jsonschema \
 python3-ruamel-yaml \
 "
