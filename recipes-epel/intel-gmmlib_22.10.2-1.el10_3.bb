# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-gmmlib"
PV = "22.10.2"
PR = "1.el10_3"
PACKAGES = " \
 intel-gmmlib \
 intel-gmmlib-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/i/intel-gmmlib-22.10.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0cc3d24581d10195cb0fe810ab615133c1be69723e8bfd3472a25eb03446021e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-gmmlib-22.10.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-gmmlib;unpack=0"
SRC_URI[x86_64_v2_intel-gmmlib.sha256sum] = "e9b4f29eee43aa453d93d9211429e1f8143f3dbabb3c95db83acf59c1c93e7c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-gmmlib-devel-22.10.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-gmmlib-devel;unpack=0"
SRC_URI[x86_64_v2_intel-gmmlib-devel.sha256sum] = "12546466fb75e0df48b5a7ea595bc5c9a5cff54cc55096f8c9dbdc2a0476d309"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/intel-gmmlib-22.10.2-1.el10_3.aarch64.rpm;name=aarch64_intel-gmmlib;unpack=0"
SRC_URI[aarch64_intel-gmmlib.sha256sum] = "ca367d6d41d6339a3a6baf9c591ba499ba55189e0b782bd289dc7daa5ba1f8a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/intel-gmmlib-devel-22.10.2-1.el10_3.aarch64.rpm;name=aarch64_intel-gmmlib-devel;unpack=0"
SRC_URI[aarch64_intel-gmmlib-devel.sha256sum] = "6650379c03f6ad564d9e90b15e36f709969edcfc1ab7f445f0e6ceb6f76e51b9"

RDEPENDS:intel-gmmlib = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-gmmlib-devel = " \
 intel-gmmlib \
 pkgconf-pkg-config \
 "
