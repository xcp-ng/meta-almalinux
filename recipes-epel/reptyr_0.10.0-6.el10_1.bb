# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "reptyr"
PV = "0.10.0"
PR = "6.el10_1"
PACKAGES = " \
 reptyr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/reptyr-0.10.0-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f322f9d13c9b2bcd29adf9c9c9d484367c7d6e0a1a9908ae82ae88a60ff92db"

URI_x86_64_v2_reptyr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/reptyr-0.10.0-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_reptyr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_reptyr}"
SRC_URI[x86_64_v2_reptyr.sha256sum] = "dd7fa777067251fac5d6e4040bf874b324bc62daad906822c3ed58072de7e873"

URI_aarch64_reptyr = "${EPEL_MIRROR}/aarch64/Packages/r/reptyr-0.10.0-6.el10_1.aarch64.rpm;name=aarch64_reptyr;unpack=0"
SRC_URI:append = " ${URI_aarch64_reptyr}"
SRC_URI[aarch64_reptyr.sha256sum] = "7b6986750e00842ebb580e6b5d3824bc593eac3728867dffe0e4cbcf2e50ebb9"

RDEPENDS:reptyr = " \
 glibc \
 pkgconf-pkg-config \
 "
