# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sgmllib3k"
PV = "1.0.0"
PR = "17.el10_1"
PACKAGES = " \
 python3-sgmllib3k \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sgmllib3k-1.0.0-17.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af66f7e28f8de6f2efe300b07fcdbd5c8e2d4972000e77765a651209fd0fb395"

URI_x86_64_v2_python3-sgmllib3k = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sgmllib3k-1.0.0-17.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sgmllib3k;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sgmllib3k}"
SRC_URI[x86_64_v2_python3-sgmllib3k.sha256sum] = "5117c1e5bff05c17527a522f3902408765903720b49916cd4d48a6c63d09aa82"

URI_aarch64_python3-sgmllib3k = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sgmllib3k-1.0.0-17.el10_1.noarch.rpm;name=aarch64_python3-sgmllib3k;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sgmllib3k}"
SRC_URI[aarch64_python3-sgmllib3k.sha256sum] = "ef1e56bd0576b8ae70539b5f4b654d0c3379c5023a667e1d9b71c61f4a7fb804"

RDEPENDS:python3-sgmllib3k = " \
 python3 \
 "
