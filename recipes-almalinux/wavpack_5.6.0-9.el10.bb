# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wavpack"
PV = "5.6.0"
PR = "9.el10"
PACKAGES = " \
 wavpack \
 wavpack-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wavpack-5.6.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6be0e975d35d625246679a2e8a65d24eab93928f839f15b88ac795b8e3a8f3f"

URI_x86_64_v2_wavpack = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wavpack-5.6.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_wavpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wavpack}"
SRC_URI[x86_64_v2_wavpack.sha256sum] = "fa5c7ab2b42cf724a45a3cbd640442ac9adf592f760d85672b401cc04c54209c"

URI_x86_64_v2_wavpack-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/wavpack-devel-5.6.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_wavpack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wavpack-devel}"
SRC_URI[x86_64_v2_wavpack-devel.sha256sum] = "62707a760426ae18671bc6915e5926480feb577952b613501f060e7b17ee066d"

URI_aarch64_wavpack = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wavpack-5.6.0-9.el10.aarch64.rpm;name=aarch64_wavpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_wavpack}"
SRC_URI[aarch64_wavpack.sha256sum] = "c8e7562331e3e7c654ae4f79dd4a53311f96dd96e05f4232a0c2fb05ef4eb9f1"

URI_aarch64_wavpack-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/wavpack-devel-5.6.0-9.el10.aarch64.rpm;name=aarch64_wavpack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wavpack-devel}"
SRC_URI[aarch64_wavpack-devel.sha256sum] = "a8c18dfbec68c42f540d3b4d1536a06066cf137bf116855e0cb64c2f3d31fd55"

RDEPENDS:wavpack = " \
 glibc \
 "
RDEPENDS:wavpack-devel = " \
 pkgconf-pkg-config \
 wavpack \
 "
