# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pangomm"
PV = "2.46.4"
PR = "3.el10_1"
PACKAGES = " \
 pangomm \
 pangomm-devel \
 pangomm-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pangomm-2.46.4-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d92f4201b669326c8061adadbff6a4548425b9b2e316d72c14fb0509345cb1c"

URI_x86_64_v2_pangomm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pangomm-2.46.4-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pangomm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pangomm}"
SRC_URI[x86_64_v2_pangomm.sha256sum] = "d798a95b908a55e2da6721665de897a7d9296979af8a15726c59f589c09d58f2"

URI_x86_64_v2_pangomm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pangomm-devel-2.46.4-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pangomm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pangomm-devel}"
SRC_URI[x86_64_v2_pangomm-devel.sha256sum] = "2085e08d933be5019319ff6910ba2b1a6e8a4dc79b70bf78b6cfbf1ec0c22aaf"

URI_x86_64_v2_pangomm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pangomm-doc-2.46.4-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pangomm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pangomm-doc}"
SRC_URI[x86_64_v2_pangomm-doc.sha256sum] = "41262fc33c4bb95840dbd72829de108d510360d4cc01d1dac1778b4a01daebd1"

URI_aarch64_pangomm = "${EPEL_MIRROR}/aarch64/Packages/p/pangomm-2.46.4-3.el10_1.aarch64.rpm;name=aarch64_pangomm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pangomm}"
SRC_URI[aarch64_pangomm.sha256sum] = "6edfef70d66e90f79894cfc441bc763be81104f0e8be141cd79b34fa11f74d69"

URI_aarch64_pangomm-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pangomm-devel-2.46.4-3.el10_1.aarch64.rpm;name=aarch64_pangomm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pangomm-devel}"
SRC_URI[aarch64_pangomm-devel.sha256sum] = "df03eaf6c0f2daea3a1ff32e6f3ac3f619e0dd45e6ff3021d37c1d438b9f8b5e"

URI_aarch64_pangomm-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pangomm-doc-2.46.4-3.el10_1.noarch.rpm;name=aarch64_pangomm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pangomm-doc}"
SRC_URI[aarch64_pangomm-doc.sha256sum] = "e032656bc1a62510df80ccf1de731ef68870780797f31ba766ef887768e29f9d"

RDEPENDS:pangomm = " \
 cairomm \
 glib2 \
 glibc \
 glibmm2.4 \
 libgcc \
 libsigc++20 \
 libstdc++ \
 pango \
 "
RDEPENDS:pangomm-devel = " \
 cairomm-devel \
 glibmm2.4-devel \
 pango-devel \
 pangomm \
 pkgconf-pkg-config \
 "
RDEPENDS:pangomm-doc = " \
 glibmm2.4-doc \
 libsigc++20-doc \
 pangomm \
 "
