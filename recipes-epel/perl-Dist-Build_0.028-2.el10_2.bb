# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Dist-Build"
PV = "0.028"
PR = "2.el10_2"
PACKAGES = " \
 perl-Dist-Build \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Dist-Build-0.028-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7103dfa358bc1d142bbd49f784a810645d854b34b0816446a26800e7df064cb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Dist-Build-0.028-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Dist-Build;unpack=0"
SRC_URI[x86_64_v2_perl-Dist-Build.sha256sum] = "4bd3e5009280ff81df704cbce76dc329a1090e94f721c9e540bdc698d4a3b499"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Dist-Build-0.028-2.el10_2.noarch.rpm;name=aarch64_perl-Dist-Build;unpack=0"
SRC_URI[aarch64_perl-Dist-Build.sha256sum] = "2a6edf6ec7edfea4ef7b4f553b1e9e2c3efa3658b21efa210ad069d774d336b9"

RDEPENDS:perl-Dist-Build = " \
 perl-CPAN-Meta \
 perl-CPAN-Requirements-Dynamic \
 perl-Carp \
 perl-Dist-Build \
 perl-Exporter \
 perl-ExtUtils-Builder \
 perl-ExtUtils-Builder-Compiler \
 perl-ExtUtils-Config \
 perl-ExtUtils-Helpers \
 perl-ExtUtils-Install \
 perl-ExtUtils-InstallPaths \
 perl-ExtUtils-Manifest \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Perl-OSType \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Text-ParseWords \
 perl-libs \
 perl-parent \
 perl-podlators \
 perl-version \
 "
