# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-pcov"
PV = "1.0.12"
PR = "1.el10_0"
PACKAGES = " \
 php-pecl-pcov \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-pcov-1.0.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bca977bc62a473a86b077ac66c565502a8a8e1a316b58015871325765b0bd23"

URI_x86_64_v2_php-pecl-pcov = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-pcov-1.0.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-pcov;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-pcov}"
SRC_URI[x86_64_v2_php-pecl-pcov.sha256sum] = "3153c519f786ac1a1f88e66300438a5d303c7439d0579d2f9ced2e4dff43dbaf"

URI_aarch64_php-pecl-pcov = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-pcov-1.0.12-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-pcov;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-pcov}"
SRC_URI[aarch64_php-pecl-pcov.sha256sum] = "09b03af61bbdbdee2780a1559cda5789aeaad39071b056c0df74906df97bc38d"

RDEPENDS:php-pecl-pcov = " \
 glibc \
 php-common \
 "
