# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "javacc"
PV = "7.0.13"
PR = "6.el10"
PACKAGES = " \
 javacc \
 javacc-demo \
 javacc-javadoc \
 javacc-manual \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/javacc-7.0.13-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3e6996c310c0cf2f37979aa548d2c45d424e295d62865a06bda76cd1c403514"

URI_x86_64_v2_javacc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/javacc-7.0.13-6.el10.noarch.rpm;name=x86_64_v2_javacc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javacc}"
SRC_URI[x86_64_v2_javacc.sha256sum] = "d12c5a1fbe275c4da8068e32a295f545c69c9e41497c1924734efcf1166b332d"

URI_x86_64_v2_javacc-demo = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/javacc-demo-7.0.13-6.el10.noarch.rpm;name=x86_64_v2_javacc-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javacc-demo}"
SRC_URI[x86_64_v2_javacc-demo.sha256sum] = "4c55f114520fa8db5a5f860dc3e00d7e8a0614f03417190c9c7967c2612c937f"

URI_x86_64_v2_javacc-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/javacc-javadoc-7.0.13-6.el10.noarch.rpm;name=x86_64_v2_javacc-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javacc-javadoc}"
SRC_URI[x86_64_v2_javacc-javadoc.sha256sum] = "1de599869b101f2471c69d406368afa3f5586add4cc28cf9aaea1c864d86be65"

URI_x86_64_v2_javacc-manual = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/javacc-manual-7.0.13-6.el10.noarch.rpm;name=x86_64_v2_javacc-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javacc-manual}"
SRC_URI[x86_64_v2_javacc-manual.sha256sum] = "c2499addef54f8a86d66c88e8d17e2d51712bc35b412c6d0e23d3d9aaa1898cd"

URI_aarch64_javacc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/javacc-7.0.13-6.el10.noarch.rpm;name=aarch64_javacc;unpack=0"
SRC_URI:append = " ${URI_aarch64_javacc}"
SRC_URI[aarch64_javacc.sha256sum] = "d12c5a1fbe275c4da8068e32a295f545c69c9e41497c1924734efcf1166b332d"

URI_aarch64_javacc-demo = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/javacc-demo-7.0.13-6.el10.noarch.rpm;name=aarch64_javacc-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_javacc-demo}"
SRC_URI[aarch64_javacc-demo.sha256sum] = "4c55f114520fa8db5a5f860dc3e00d7e8a0614f03417190c9c7967c2612c937f"

URI_aarch64_javacc-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/javacc-javadoc-7.0.13-6.el10.noarch.rpm;name=aarch64_javacc-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_javacc-javadoc}"
SRC_URI[aarch64_javacc-javadoc.sha256sum] = "1de599869b101f2471c69d406368afa3f5586add4cc28cf9aaea1c864d86be65"

URI_aarch64_javacc-manual = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/javacc-manual-7.0.13-6.el10.noarch.rpm;name=aarch64_javacc-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_javacc-manual}"
SRC_URI[aarch64_javacc-manual.sha256sum] = "c2499addef54f8a86d66c88e8d17e2d51712bc35b412c6d0e23d3d9aaa1898cd"

RDEPENDS:javacc = " \
 bash \
 javapackages-filesystem \
 javapackages-tools \
 "
RDEPENDS:javacc-demo = " \
 javacc \
 "
RDEPENDS:javacc-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:javacc-manual = " \
 "
