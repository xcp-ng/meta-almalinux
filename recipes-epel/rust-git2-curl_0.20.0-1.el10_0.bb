# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-git2-curl"
PV = "0.20.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-git2-curl+default-devel \
 rust-git2-curl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-git2-curl-0.20.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf81a453fb404fa850520c5a085da3583ff63553947e1d0b3b7c13aac1ed7373"

URI_x86_64_v2_rust-git2-curl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2-curl+default-devel-0.20.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2-curl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2-curl+default-devel}"
SRC_URI[x86_64_v2_rust-git2-curl+default-devel.sha256sum] = "19a289ecd33113e5c99d2d4eef965b7ef51c3001f765aea406e62c5cef8e971b"

URI_x86_64_v2_rust-git2-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2-curl-devel-0.20.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2-curl-devel}"
SRC_URI[x86_64_v2_rust-git2-curl-devel.sha256sum] = "181f8d376a9dfff9a5989c37621d5e0ca1ae5765feebf628f60398a124a23443"

URI_aarch64_rust-git2-curl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2-curl+default-devel-0.20.0-1.el10_0.noarch.rpm;name=aarch64_rust-git2-curl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2-curl+default-devel}"
SRC_URI[aarch64_rust-git2-curl+default-devel.sha256sum] = "d486a7d795a7abc44e0b242a44012c77147911c0b353f2c603c2eceb18f0c79b"

URI_aarch64_rust-git2-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2-curl-devel-0.20.0-1.el10_0.noarch.rpm;name=aarch64_rust-git2-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2-curl-devel}"
SRC_URI[aarch64_rust-git2-curl-devel.sha256sum] = "75dc3f5283da8dda070633a3be5b9c3b27b7334c8d574dd56a5d224dc6a6e42f"

RDEPENDS:rust-git2-curl+default-devel = " \
 cargo \
 rust-git2-curl-devel \
 "
RDEPENDS:rust-git2-curl-devel = " \
 cargo \
 rust-curl+default-devel \
 rust-git2-devel \
 rust-log+default-devel \
 rust-url+default-devel \
 "
