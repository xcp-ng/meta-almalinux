# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cobbler3.3"
PV = "3.3.7"
PR = "1.el10_0"
PACKAGES = " \
 cobbler3.3 \
 cobbler3.3-selinux \
 cobbler3.3-tests \
 cobbler3.3-tests-containers \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cobbler3.3-3.3.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "23d97aaf206e5c831ab638311095b78d20e3f736ddc7f4d7647412720dd03b77"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - cobbler3.3: (syslinux if (filesystem.x86_64 or filesystem.i686))

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cobbler3.3-3.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cobbler3.3;unpack=0"
SRC_URI[x86_64_v2_cobbler3.3.sha256sum] = "b4e67318c42dd8ce16ef6efb8d5c23001e94ac12ff89fa5eb879503da94019ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cobbler3.3-selinux-3.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cobbler3.3-selinux;unpack=0"
SRC_URI[x86_64_v2_cobbler3.3-selinux.sha256sum] = "e9d81f926eecaf722b7fbce57871c76eb744ff09ac63c4a3b90303c3ef17ef74"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cobbler3.3-tests-3.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cobbler3.3-tests;unpack=0"
SRC_URI[x86_64_v2_cobbler3.3-tests.sha256sum] = "da5d4588575907678e784003b38979801bf042bf14bac47022f9f7dbcd214747"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cobbler3.3-tests-containers-3.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cobbler3.3-tests-containers;unpack=0"
SRC_URI[x86_64_v2_cobbler3.3-tests-containers.sha256sum] = "b80a619e446e4f4516ee6aa940c9f534fb797c6e5d219fa4facbcb703795fe90"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cobbler3.3-3.3.7-1.el10_0.noarch.rpm;name=aarch64_cobbler3.3;unpack=0"
SRC_URI[aarch64_cobbler3.3.sha256sum] = "f879ef6b5212267631863ccca2143fe596599c657e28ee971094f940e1d472d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cobbler3.3-selinux-3.3.7-1.el10_0.noarch.rpm;name=aarch64_cobbler3.3-selinux;unpack=0"
SRC_URI[aarch64_cobbler3.3-selinux.sha256sum] = "e701d7a92c081d57c28743a2101fc08a024618589b032b00950cbcb347db2e08"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cobbler3.3-tests-3.3.7-1.el10_0.noarch.rpm;name=aarch64_cobbler3.3-tests;unpack=0"
SRC_URI[aarch64_cobbler3.3-tests.sha256sum] = "ae457eb4305208b9206a6cb4fe481ecd2f67ac417b5ac86d34289379183b3771"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cobbler3.3-tests-containers-3.3.7-1.el10_0.noarch.rpm;name=aarch64_cobbler3.3-tests-containers;unpack=0"
SRC_URI[aarch64_cobbler3.3-tests-containers.sha256sum] = "7d86114681d2436b04cd2eeaae2924793bba8e1a781a8a01600946ff8b7ce332"

RDEPENDS:cobbler3.3:x86_64_v2 = " \
 bash \
 cobbler3.3-selinux \
 createrepo_c \
 dnf-plugins-core \
 dosfstools \
 genisoimage \
 httpd \
 python3 \
 python3-cheetah \
 python3-distro \
 python3-dns \
 python3-file-magic \
 python3-ldap \
 python3-mod_wsgi \
 python3-netaddr \
 python3-pymongo \
 python3-pyyaml \
 python3-requests \
 python3-schema \
 rsync \
 syslinux \
 systemd \
 tftp-server \
 xorriso \
"
RDEPENDS:cobbler3.3:aarch64 = " \
 bash \
 cobbler3.3-selinux \
 createrepo_c \
 dnf-plugins-core \
 dosfstools \
 genisoimage \
 httpd \
 python3 \
 python3-cheetah \
 python3-distro \
 python3-dns \
 python3-file-magic \
 python3-ldap \
 python3-mod_wsgi \
 python3-netaddr \
 python3-pymongo \
 python3-pyyaml \
 python3-requests \
 python3-schema \
 rsync \
 systemd \
 tftp-server \
 xorriso \
"
RDEPENDS:cobbler3.3-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:cobbler3.3-tests = " \
 cobbler3.3 \
 "
RDEPENDS:cobbler3.3-tests-containers = " \
 bash \
 cobbler3.3 \
 "
