# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "microcode_ctl"
PE = "4"
PV = "20260512"
PR = "1.1.el10_2"
PACKAGES = " \
 microcode_ctl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/microcode_ctl-20260512-1.1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18c792a5550e36828c9377ad03ae180fdb9416eb512c1d64948e67a317091e86"

URI_x86_64_v2_microcode_ctl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/microcode_ctl-20260512-1.1.el10_2.noarch.rpm;name=x86_64_v2_microcode_ctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_microcode_ctl}"
SRC_URI[x86_64_v2_microcode_ctl.sha256sum] = "08e1934bf0f2c38ac64a52d508d77d009bec16b63916f2e7e773d6ec7d95c166"

URI_aarch64_microcode_ctl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/microcode_ctl-20260512-1.1.el10_2.noarch.rpm;name=aarch64_microcode_ctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_microcode_ctl}"
SRC_URI[aarch64_microcode_ctl.sha256sum] = "08e1934bf0f2c38ac64a52d508d77d009bec16b63916f2e7e773d6ec7d95c166"

RDEPENDS:microcode_ctl = " \
 bash \
 dracut \
 systemd \
 virtual/coreutils \
 "
