# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-tpi"
PV = "0.07"
PR = "27.el10"
PACKAGES = " \
 hunspell-tpi \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-tpi-0.07-27.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6069ea865167ae7b196211f0e12b367e67a10db498b67adbaffefcb3cbcf6f12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-tpi-0.07-27.el10.noarch.rpm;name=x86_64_v2_hunspell-tpi;unpack=0"
SRC_URI[x86_64_v2_hunspell-tpi.sha256sum] = "1573ccc5fa8665474fbcc239b353f2a2e038cd272af6e55d9cd05cea3e3c687a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-tpi-0.07-27.el10.noarch.rpm;name=aarch64_hunspell-tpi;unpack=0"
SRC_URI[aarch64_hunspell-tpi.sha256sum] = "1573ccc5fa8665474fbcc239b353f2a2e038cd272af6e55d9cd05cea3e3c687a"

RDEPENDS:hunspell-tpi = " \
 hunspell-filesystem \
 "
