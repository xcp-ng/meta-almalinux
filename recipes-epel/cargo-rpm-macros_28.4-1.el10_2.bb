# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cargo-rpm-macros"
PV = "28.4"
PR = "1.el10_2"
PACKAGES = " \
 cargo-rpm-macros \
 rust-srpm-macros-epel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cargo-rpm-macros-28.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afbc06c4afbcbef9f494643d83b46bf21f3857474e343b4f496a46a985e637e8"

URI_x86_64_v2_cargo-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo-rpm-macros-28.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_cargo-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo-rpm-macros}"
SRC_URI[x86_64_v2_cargo-rpm-macros.sha256sum] = "a05350dd5442b020036dac62cccce1d1f81fed8cd6194715b0d9a56d76d25af8"

URI_x86_64_v2_rust-srpm-macros-epel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-srpm-macros-epel-28.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-srpm-macros-epel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-srpm-macros-epel}"
SRC_URI[x86_64_v2_rust-srpm-macros-epel.sha256sum] = "08644615715f940c3858d06d07691839f2c2a8d171bed5722d03ad77b0cad55d"

URI_aarch64_cargo-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/c/cargo-rpm-macros-28.4-1.el10_2.noarch.rpm;name=aarch64_cargo-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo-rpm-macros}"
SRC_URI[aarch64_cargo-rpm-macros.sha256sum] = "ad17fb2df1d18f220a84cc32cfb7f2894bd39de0ab196a5ecf95b433bc668681"

URI_aarch64_rust-srpm-macros-epel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-srpm-macros-epel-28.4-1.el10_2.noarch.rpm;name=aarch64_rust-srpm-macros-epel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-srpm-macros-epel}"
SRC_URI[aarch64_rust-srpm-macros-epel.sha256sum] = "7a1ff17679fb84ca1752c57edfe07a14f23e5e297a5cd75c87d9ed1273fac871"

RDEPENDS:cargo-rpm-macros = " \
 cargo \
 cargo2rpm \
 gawk \
 grep \
 rust-srpm-macros-epel \
 "
RDEPENDS:rust-srpm-macros-epel = " \
 rust-toolset-srpm-macros \
 "
