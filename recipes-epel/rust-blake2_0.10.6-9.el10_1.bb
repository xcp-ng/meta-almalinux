# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blake2"
PV = "0.10.6"
PR = "9.el10_1"
PACKAGES = " \
 rust-blake2+default-devel \
 rust-blake2+reset-devel \
 rust-blake2+simd-devel \
 rust-blake2+simd_asm-devel \
 rust-blake2+simd_opt-devel \
 rust-blake2+size_opt-devel \
 rust-blake2+std-devel \
 rust-blake2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blake2-0.10.6-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73ab61519ed33de9b96bad9b2b807254ab00fbf54fa034ad2b7cee52c1262fe9"

URI_x86_64_v2_rust-blake2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+default-devel-0.10.6-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+default-devel}"
SRC_URI[x86_64_v2_rust-blake2+default-devel.sha256sum] = "60c1918aa29e27c2f37ba73951eb98c848602b57e5c6c2c65bc0499db8e76b95"

URI_x86_64_v2_rust-blake2+reset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+reset-devel-0.10.6-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+reset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+reset-devel}"
SRC_URI[x86_64_v2_rust-blake2+reset-devel.sha256sum] = "c326861df54e8b309f227ae29ef7294b46a8a980b161a6c195a88237b792c176"

URI_x86_64_v2_rust-blake2+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+simd-devel-0.10.6-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+simd-devel}"
SRC_URI[x86_64_v2_rust-blake2+simd-devel.sha256sum] = "fda7ed33216bbf6863b62367e1da336fe479c176a417c882037bf96453987fdc"

URI_x86_64_v2_rust-blake2+simd_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+simd_asm-devel-0.10.6-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+simd_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+simd_asm-devel}"
SRC_URI[x86_64_v2_rust-blake2+simd_asm-devel.sha256sum] = "403cacc2b55da9a270f3799ea7bf95498444b7d614539b5b3bba2f6e56102d06"

URI_x86_64_v2_rust-blake2+simd_opt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+simd_opt-devel-0.10.6-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+simd_opt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+simd_opt-devel}"
SRC_URI[x86_64_v2_rust-blake2+simd_opt-devel.sha256sum] = "d9452c74581e712b74fe19774d917673bb308658ab6ba363e21c818d9cea77cb"

URI_x86_64_v2_rust-blake2+size_opt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+size_opt-devel-0.10.6-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+size_opt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+size_opt-devel}"
SRC_URI[x86_64_v2_rust-blake2+size_opt-devel.sha256sum] = "34bc82e82f206dd3e9e498121222829e619c440b0525e058be927dd5ead7516f"

URI_x86_64_v2_rust-blake2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2+std-devel-0.10.6-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2+std-devel}"
SRC_URI[x86_64_v2_rust-blake2+std-devel.sha256sum] = "b38bfff453a3ab543fedd7f1e6c6c06d1fc840fada8a29473ffda5c7c33e3e3d"

URI_x86_64_v2_rust-blake2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2-devel-0.10.6-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake2-devel}"
SRC_URI[x86_64_v2_rust-blake2-devel.sha256sum] = "f4a675faa0093f4524c6e50c006e95b2a3b4473ed06887cec467905e10752727"

URI_aarch64_rust-blake2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+default-devel-0.10.6-9.el10_1.noarch.rpm;name=aarch64_rust-blake2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+default-devel}"
SRC_URI[aarch64_rust-blake2+default-devel.sha256sum] = "02689a2c89d99bebc291bff2fdbfb3fe8eceeb28f080fc675b021b415415949c"

URI_aarch64_rust-blake2+reset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+reset-devel-0.10.6-9.el10_1.noarch.rpm;name=aarch64_rust-blake2+reset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+reset-devel}"
SRC_URI[aarch64_rust-blake2+reset-devel.sha256sum] = "29f4e9af586b0f2b839139c77915d8fffd3c9f904d938ba7ce8ceada818a54a6"

URI_aarch64_rust-blake2+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+simd-devel-0.10.6-9.el10_1.noarch.rpm;name=aarch64_rust-blake2+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+simd-devel}"
SRC_URI[aarch64_rust-blake2+simd-devel.sha256sum] = "10b89a92d46aff55318a40a720fa445555d1113d8dd3746c2702f15f385ceea4"

URI_aarch64_rust-blake2+simd_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+simd_asm-devel-0.10.6-9.el10_1.noarch.rpm;name=aarch64_rust-blake2+simd_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+simd_asm-devel}"
SRC_URI[aarch64_rust-blake2+simd_asm-devel.sha256sum] = "125d1af75229d811d69e3aafdc0147006982150b06c4827ab2de5879814e9fb4"

URI_aarch64_rust-blake2+simd_opt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+simd_opt-devel-0.10.6-9.el10_1.noarch.rpm;name=aarch64_rust-blake2+simd_opt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+simd_opt-devel}"
SRC_URI[aarch64_rust-blake2+simd_opt-devel.sha256sum] = "38ea332ca8ef03f63ceb9da2cd78be16ab390119a9a90eb7f7e521556379dd7a"

URI_aarch64_rust-blake2+size_opt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+size_opt-devel-0.10.6-9.el10_1.noarch.rpm;name=aarch64_rust-blake2+size_opt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+size_opt-devel}"
SRC_URI[aarch64_rust-blake2+size_opt-devel.sha256sum] = "d7b22a03baf473e0c8054f643d2b85bb1522aae7aa1356d0cd283c84772b54d2"

URI_aarch64_rust-blake2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2+std-devel-0.10.6-9.el10_1.noarch.rpm;name=aarch64_rust-blake2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2+std-devel}"
SRC_URI[aarch64_rust-blake2+std-devel.sha256sum] = "0d7a4ee6d815bec73c57edfe09960cd6e05b5510a61859ec09f1f69a4de647f4"

URI_aarch64_rust-blake2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2-devel-0.10.6-9.el10_1.noarch.rpm;name=aarch64_rust-blake2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake2-devel}"
SRC_URI[aarch64_rust-blake2-devel.sha256sum] = "02c48d52804d5e0c4d6de7e95cf87ec28fb412628acac86986b7e9cbc703ea65"

RDEPENDS:rust-blake2+default-devel = " \
 cargo \
 rust-blake2+std-devel \
 rust-blake2-devel \
 "
RDEPENDS:rust-blake2+reset-devel = " \
 cargo \
 rust-blake2-devel \
 "
RDEPENDS:rust-blake2+simd-devel = " \
 cargo \
 rust-blake2-devel \
 "
RDEPENDS:rust-blake2+simd_asm-devel = " \
 cargo \
 rust-blake2+simd_opt-devel \
 rust-blake2-devel \
 "
RDEPENDS:rust-blake2+simd_opt-devel = " \
 cargo \
 rust-blake2+simd-devel \
 rust-blake2-devel \
 "
RDEPENDS:rust-blake2+size_opt-devel = " \
 cargo \
 rust-blake2-devel \
 "
RDEPENDS:rust-blake2+std-devel = " \
 cargo \
 rust-blake2-devel \
 rust-digest0.10+std-devel \
 "
RDEPENDS:rust-blake2-devel = " \
 cargo \
 rust-digest0.10+default-devel \
 rust-digest0.10+mac-devel \
 "
