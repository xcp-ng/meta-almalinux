# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_pathchk"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_pathchk+default-devel \
 rust-uu_pathchk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_pathchk-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd846772b14535f57bee744abb4bd36fb54dca7eae9c0c50e1720c58022dd340"

URI_x86_64_v2_rust-uu_pathchk+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_pathchk+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_pathchk+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_pathchk+default-devel}"
SRC_URI[x86_64_v2_rust-uu_pathchk+default-devel.sha256sum] = "3f0ff30ef678de8fcd2a1e2acdbcca4973efca7ae9bb82ea5ab669c93f51d7ae"

URI_x86_64_v2_rust-uu_pathchk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_pathchk-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_pathchk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_pathchk-devel}"
SRC_URI[x86_64_v2_rust-uu_pathchk-devel.sha256sum] = "fb3fa81b7a72d89e2030365fd799abe4fa3070c76198822a5101fa2555c259c3"

URI_aarch64_rust-uu_pathchk+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_pathchk+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_pathchk+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_pathchk+default-devel}"
SRC_URI[aarch64_rust-uu_pathchk+default-devel.sha256sum] = "f20127274d9e256a48bde5f40f52e3b48620c245660e0180f719858228833a50"

URI_aarch64_rust-uu_pathchk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_pathchk-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_pathchk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_pathchk-devel}"
SRC_URI[aarch64_rust-uu_pathchk-devel.sha256sum] = "d0d85900990114588895a648443ddd2b3afb4d4e4ea8d6185f80576780a4be88"

RDEPENDS:rust-uu_pathchk+default-devel = " \
 cargo \
 rust-uu_pathchk-devel \
 "
RDEPENDS:rust-uu_pathchk-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-libc+default-devel \
 rust-uucore+default-devel \
 "
