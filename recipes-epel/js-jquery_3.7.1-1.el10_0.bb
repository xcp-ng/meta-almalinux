# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "js-jquery"
PV = "3.7.1"
PR = "1.el10_0"
PACKAGES = " \
 js-jquery \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/js-jquery-3.7.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e8b79579a7e788871b760d0dbcba7ae25fa06b47bcba0c16f2070e780f6557b"

URI_x86_64_v2_js-jquery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/js-jquery-3.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_js-jquery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_js-jquery}"
SRC_URI[x86_64_v2_js-jquery.sha256sum] = "de2fd4e5c29849ccf4cb32ecfb2064da503fc72c4a0ed9a259ef8f145e3c7b45"

URI_aarch64_js-jquery = "${EPEL_MIRROR}/aarch64/Packages/j/js-jquery-3.7.1-1.el10_0.noarch.rpm;name=aarch64_js-jquery;unpack=0"
SRC_URI:append = " ${URI_aarch64_js-jquery}"
SRC_URI[aarch64_js-jquery.sha256sum] = "1e2bceac3ff17a48e55a0e98990c95c173a24819671671bbc1de1359c04b50a3"

RDEPENDS:js-jquery = " \
 web-assets-filesystem \
 "
