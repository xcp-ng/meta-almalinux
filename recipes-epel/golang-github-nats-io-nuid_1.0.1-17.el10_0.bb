# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-nats-io-nuid"
PV = "1.0.1"
PR = "17.el10_0"
PACKAGES = " \
 golang-github-nats-io-nuid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-nats-io-nuid-1.0.1-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7e5be4a28428fd8fb91553db2ccc4ac5ec296a224ad2e5c0a77672787eef469"

URI_x86_64_v2_golang-github-nats-io-nuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-nats-io-nuid-devel-1.0.1-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-nats-io-nuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-nats-io-nuid-devel}"
SRC_URI[x86_64_v2_golang-github-nats-io-nuid-devel.sha256sum] = "9cde7a72dc9f36e2a3a9b2944ead70d74917d64d425aede456df9785db4af263"

URI_aarch64_golang-github-nats-io-nuid-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-nats-io-nuid-devel-1.0.1-17.el10_0.noarch.rpm;name=aarch64_golang-github-nats-io-nuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-nats-io-nuid-devel}"
SRC_URI[aarch64_golang-github-nats-io-nuid-devel.sha256sum] = "889f8fad189b41b399431135c475c15256728ad1dc9f5716e1befaf78e5ebf67"

RDEPENDS:golang-github-nats-io-nuid-devel = " \
 go-filesystem \
 "
