# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "syncthing"
PV = "2.1.3"
PR = "1.el10_3"
PACKAGES = " \
 syncthing \
 syncthing-tools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/syncthing-2.1.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8a510b0c978f186c12affbe1d39370bde3e90218be881661d7f8d390e4e0767d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syncthing-2.1.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syncthing;unpack=0"
SRC_URI[x86_64_v2_syncthing.sha256sum] = "aade270275995bcee9a334f323fa712c8de97e8599b26732a86d9d7a6291358c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syncthing-tools-2.1.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syncthing-tools;unpack=0"
SRC_URI[x86_64_v2_syncthing-tools.sha256sum] = "52e14c3eaebde8c6d64c735a9efbe668129b9e4394610768cf1339e9ba6c9d43"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/syncthing-2.1.3-1.el10_3.aarch64.rpm;name=aarch64_syncthing;unpack=0"
SRC_URI[aarch64_syncthing.sha256sum] = "ba8eaf63cc6f7ad087cb5d8f59b444797eeb88bf98fb29747949a90ba69adf32"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/syncthing-tools-2.1.3-1.el10_3.aarch64.rpm;name=aarch64_syncthing-tools;unpack=0"
SRC_URI[aarch64_syncthing-tools.sha256sum] = "63704be8911ceebbc202373a19d613411f134f9d73d2251ad6d64e386a8ef32a"

RDEPENDS:syncthing = " \
 bash \
 glibc \
 hicolor-icon-theme \
 sqlite-libs \
 "
RDEPENDS:syncthing-tools = " \
 glibc \
 syncthing \
 "
