# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtsvg"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtsvg \
 qt5-qtsvg-devel \
 qt5-qtsvg-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtsvg-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "734ec0c3dc82f1fdb9d8c4db823cfecfdaef879e19a2e0e1f3160769b6a9b2e0"

URI_x86_64_v2_qt5-qtsvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsvg-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsvg}"
SRC_URI[x86_64_v2_qt5-qtsvg.sha256sum] = "1875f5f287a4ac588dbfb8a1256c78c24baa3b9d9708e3e79683f0e410cd0cf1"

URI_x86_64_v2_qt5-qtsvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsvg-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsvg-devel}"
SRC_URI[x86_64_v2_qt5-qtsvg-devel.sha256sum] = "5b34938746c1d52759ec09be9ce2ed72076b335ae47f21da6912257283e53657"

URI_x86_64_v2_qt5-qtsvg-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsvg-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsvg-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsvg-examples}"
SRC_URI[x86_64_v2_qt5-qtsvg-examples.sha256sum] = "28e1b515a46574abeb8bb338761ef7b6a3efc761fa41576ac5a0963b3e53f37e"

URI_aarch64_qt5-qtsvg = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsvg-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtsvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsvg}"
SRC_URI[aarch64_qt5-qtsvg.sha256sum] = "f2a4b743a729032b0fe5e3276d81a535c46ae59334f354358a8d2087b9ffeade"

URI_aarch64_qt5-qtsvg-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsvg-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtsvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsvg-devel}"
SRC_URI[aarch64_qt5-qtsvg-devel.sha256sum] = "1d01f94b9dc96acde002d3771c836db5f1bfa2a2beba633d50e2214285ac0ab0"

URI_aarch64_qt5-qtsvg-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsvg-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtsvg-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsvg-examples}"
SRC_URI[aarch64_qt5-qtsvg-examples.sha256sum] = "f40db2ba4de0b77825fbbe7c25372833fdfb5fc8073e63ca64d146f194e883fe"

RDEPENDS:qt5-qtsvg = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtsvg-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtsvg \
 "
RDEPENDS:qt5-qtsvg-examples = " \
 glibc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtsvg \
 "
