# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "multicat"
PV = "2.4"
PR = "2.el10_2"
PACKAGES = " \
 multicat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/multicat-2.4-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf5f0f9acb92d65f07d5a3ce18d23e5c12fa1a7f62ae6af8c1a74446d213d3fb"

URI_x86_64_v2_multicat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/multicat-2.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_multicat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_multicat}"
SRC_URI[x86_64_v2_multicat.sha256sum] = "2a506485292c470636ccbc9135e6db189db70b4deb593327d24f75f3c3efac1e"

URI_aarch64_multicat = "${EPEL_MIRROR}/aarch64/Packages/m/multicat-2.4-2.el10_2.aarch64.rpm;name=aarch64_multicat;unpack=0"
SRC_URI:append = " ${URI_aarch64_multicat}"
SRC_URI[aarch64_multicat.sha256sum] = "c948cf2b219fbea7024da7ef3b0da5733c03b6cf411a7ce4354961f81f1b281e"

RDEPENDS:multicat = " \
 glibc \
 "
