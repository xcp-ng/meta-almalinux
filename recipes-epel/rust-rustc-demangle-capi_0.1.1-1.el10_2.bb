# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustc-demangle-capi"
PV = "0.1.1"
PR = "1.el10_2"
PACKAGES = " \
 librustc_demangle \
 librustc_demangle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustc-demangle-capi-0.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b6ad2f53968809b51ac2fb209cefefbd3c94d2bddc46c0311fd41ef83a51abf"

URI_x86_64_v2_librustc_demangle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librustc_demangle-0.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librustc_demangle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librustc_demangle}"
SRC_URI[x86_64_v2_librustc_demangle.sha256sum] = "26635c172bb8c85b60ac08a39842ef52b06e4c5ac85849d9eb1ff9193fa45347"

URI_x86_64_v2_librustc_demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librustc_demangle-devel-0.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librustc_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librustc_demangle-devel}"
SRC_URI[x86_64_v2_librustc_demangle-devel.sha256sum] = "1090075a5b1a8d466ddccde76226d8b6f15677ebb4e00e5cbd1846866c130596"

URI_aarch64_librustc_demangle = "${EPEL_MIRROR}/aarch64/Packages/l/librustc_demangle-0.1.1-1.el10_2.aarch64.rpm;name=aarch64_librustc_demangle;unpack=0"
SRC_URI:append = " ${URI_aarch64_librustc_demangle}"
SRC_URI[aarch64_librustc_demangle.sha256sum] = "0457a3b16b415a7f5478e418626bd4a13cb699ffbdf29ac3bf4416b36343c96c"

URI_aarch64_librustc_demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librustc_demangle-devel-0.1.1-1.el10_2.aarch64.rpm;name=aarch64_librustc_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librustc_demangle-devel}"
SRC_URI[aarch64_librustc_demangle-devel.sha256sum] = "215a735489f454cdeded284956575fa57612f91f129a3e17f0ebe03c8f3ac474"

RDEPENDS:librustc_demangle = " \
 glibc \
 libgcc \
 "
RDEPENDS:librustc_demangle-devel = " \
 librustc_demangle \
 pkgconf-pkg-config \
 "
