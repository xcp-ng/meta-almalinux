# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cbc"
PV = "0.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-cbc+alloc-devel \
 rust-cbc+block-padding-devel \
 rust-cbc+default-devel \
 rust-cbc+zeroize-devel \
 rust-cbc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cbc-0.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c043a370e6138f8fe03c4738f6307c51979cc6fa6ff0e8d82fe607ba6e37837c"

URI_x86_64_v2_rust-cbc+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc+alloc-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc+alloc-devel}"
SRC_URI[x86_64_v2_rust-cbc+alloc-devel.sha256sum] = "3621a7547bc0619ae33c686df05c544a1b9730a392cdcac4b5a545bfcc6ba698"

URI_x86_64_v2_rust-cbc+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc+block-padding-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc+block-padding-devel}"
SRC_URI[x86_64_v2_rust-cbc+block-padding-devel.sha256sum] = "598337b79d7b1de8f2878361360b588940383ee6f0e59330a31fc8caca4a14c8"

URI_x86_64_v2_rust-cbc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc+default-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc+default-devel}"
SRC_URI[x86_64_v2_rust-cbc+default-devel.sha256sum] = "85022449af353085094966b5b3263ce581346139347d8ef61ac8293222801e95"

URI_x86_64_v2_rust-cbc+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc+zeroize-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc+zeroize-devel}"
SRC_URI[x86_64_v2_rust-cbc+zeroize-devel.sha256sum] = "986fe2f190ff22e7092d5529adf70ef78daf7b895461dcecfb0e49adf899d531"

URI_x86_64_v2_rust-cbc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc-devel}"
SRC_URI[x86_64_v2_rust-cbc-devel.sha256sum] = "9f2a7c4d2230422aad9a21a11ab8acc7de7a74dc62404c296a6e483a6b4da948"

URI_aarch64_rust-cbc+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc+alloc-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-cbc+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc+alloc-devel}"
SRC_URI[aarch64_rust-cbc+alloc-devel.sha256sum] = "9114b521f3c74bccc193efc0a7205b6b625554c5f84b2c2659ee13a9a70ddd12"

URI_aarch64_rust-cbc+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc+block-padding-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-cbc+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc+block-padding-devel}"
SRC_URI[aarch64_rust-cbc+block-padding-devel.sha256sum] = "ee8fd2f861e80bd5948f1649187b97997c20594e83b9a6cdb86c49584a467ef0"

URI_aarch64_rust-cbc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc+default-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-cbc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc+default-devel}"
SRC_URI[aarch64_rust-cbc+default-devel.sha256sum] = "1d29e4d5d3b134cbf1dc39f7b3e7a549d192b16067bb21586379d2675b392ff4"

URI_aarch64_rust-cbc+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc+zeroize-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-cbc+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc+zeroize-devel}"
SRC_URI[aarch64_rust-cbc+zeroize-devel.sha256sum] = "852353d088d91ab1b27295ed519c1ed1b27008a7efe7a1645a1b4eae63f7f3d6"

URI_aarch64_rust-cbc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-cbc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc-devel}"
SRC_URI[aarch64_rust-cbc-devel.sha256sum] = "9775fcbae22a30fa5f6427df3913509d1f50644377cef89a57b5527c5300f50a"

RDEPENDS:rust-cbc+alloc-devel = " \
 cargo \
 rust-cbc-devel \
 rust-cipher+alloc-devel \
 "
RDEPENDS:rust-cbc+block-padding-devel = " \
 cargo \
 rust-cbc-devel \
 rust-cipher+block-padding-devel \
 "
RDEPENDS:rust-cbc+default-devel = " \
 cargo \
 rust-cbc+block-padding-devel \
 rust-cbc-devel \
 "
RDEPENDS:rust-cbc+zeroize-devel = " \
 cargo \
 rust-cbc-devel \
 rust-cipher+zeroize-devel \
 "
RDEPENDS:rust-cbc-devel = " \
 cargo \
 rust \
 rust-cipher+default-devel \
 "
