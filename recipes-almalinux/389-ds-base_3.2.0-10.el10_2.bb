# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "389-ds-base"
PV = "3.2.0"
PR = "10.el10_2"
PACKAGES = " \
 389-ds-base \
 389-ds-base-bdb \
 389-ds-base-devel \
 389-ds-base-libs \
 389-ds-base-snmp \
 python3-lib389 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/389-ds-base-3.2.0-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b8c802b446a40dc37cfd27aa5f29bc64bc2a8d3d04dfb07a17530f98d64cf04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-3.2.0-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_389-ds-base;unpack=0"
SRC_URI[x86_64_v2_389-ds-base.sha256sum] = "4a92d9ccd74c06b4ae05142cce8025aaf47104e4dfd14268459d067b76af2e7d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/389-ds-base-bdb-3.2.0-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-bdb;unpack=0"
SRC_URI[x86_64_v2_389-ds-base-bdb.sha256sum] = "b226d0c901967ce10db92e68f988c5c5d84827d1eb8b7d930b2a8e6b0c088e16"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/389-ds-base-devel-3.2.0-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-devel;unpack=0"
SRC_URI[x86_64_v2_389-ds-base-devel.sha256sum] = "600c68d916b225e1d14dedd96343eabd72bdf80ba4d291c4ef6cb12af5d798e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-libs-3.2.0-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-libs;unpack=0"
SRC_URI[x86_64_v2_389-ds-base-libs.sha256sum] = "0ef90550775b2e51eb648379904a267fc10aef98112d943fdcafb0f808f45265"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-snmp-3.2.0-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-snmp;unpack=0"
SRC_URI[x86_64_v2_389-ds-base-snmp.sha256sum] = "8f91aecd5b03e08fb1840bbd80ac9a1c4c1d1fe012dc804a1e5661030e32f96e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lib389-3.2.0-10.el10_2.noarch.rpm;name=x86_64_v2_python3-lib389;unpack=0"
SRC_URI[x86_64_v2_python3-lib389.sha256sum] = "307a5e67b7efa8839b6753d9a1070e7d39a56a06e6b646f7e9121a21f6a89d52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-3.2.0-10.el10_2.aarch64.rpm;name=aarch64_389-ds-base;unpack=0"
SRC_URI[aarch64_389-ds-base.sha256sum] = "29ddde3ffba68417234cc4bf71503d73cad02a0dc426f9f6413dac48e1f9e860"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/389-ds-base-bdb-3.2.0-10.el10_2.aarch64.rpm;name=aarch64_389-ds-base-bdb;unpack=0"
SRC_URI[aarch64_389-ds-base-bdb.sha256sum] = "5ff976467786ed27aba9cad917242800a357c9f1d7b4b1b087288292c43e7643"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/389-ds-base-devel-3.2.0-10.el10_2.aarch64.rpm;name=aarch64_389-ds-base-devel;unpack=0"
SRC_URI[aarch64_389-ds-base-devel.sha256sum] = "bf427f234ebeb9b67c39acb8ec98da0e8bbd3ebc345204b8d0aa384c9b689642"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-libs-3.2.0-10.el10_2.aarch64.rpm;name=aarch64_389-ds-base-libs;unpack=0"
SRC_URI[aarch64_389-ds-base-libs.sha256sum] = "13ac9df2009fe04c2d3b2cee0fe1707300a5a6d05ebb8cd827cd9aaa7246e26f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-snmp-3.2.0-10.el10_2.aarch64.rpm;name=aarch64_389-ds-base-snmp;unpack=0"
SRC_URI[aarch64_389-ds-base-snmp.sha256sum] = "4ea19b89cd1ec1a8b2141cd1f9a6553393c59c2adfb1bfa11a451e6481553ee8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lib389-3.2.0-10.el10_2.noarch.rpm;name=aarch64_python3-lib389;unpack=0"
SRC_URI[aarch64_python3-lib389.sha256sum] = "307a5e67b7efa8839b6753d9a1070e7d39a56a06e6b646f7e9121a21f6a89d52"

RDEPENDS:389-ds-base = " \
 389-ds-base-libs \
 acl \
 bash \
 cracklib \
 cracklib-dicts \
 cyrus-sasl-gssapi \
 cyrus-sasl-lib \
 cyrus-sasl-md5 \
 cyrus-sasl-plain \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libicu \
 libstdc++ \
 libxcrypt \
 lmdb-libs \
 nspr \
 nss \
 nss-tools \
 nss-util \
 openldap \
 openldap-clients \
 openssl-libs \
 pam-libs \
 pcre2 \
 perl-Archive-Tar \
 perl-debugger \
 perl-interpreter \
 perl-sigtrap \
 policycoreutils-python-utils \
 python3 \
 python3-file-magic \
 python3-lib389 \
 python3-libsemanage \
 shadow-utils \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:389-ds-base-bdb = " \
 389-ds-base \
 389-ds-base-libs \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 lmdb-libs \
 nspr \
 nss \
 nss-util \
 openldap \
 openssl-libs \
 pcre2 \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:389-ds-base-devel = " \
 389-ds-base-libs \
 nspr-devel \
 nss-devel \
 openldap-devel \
 pkgconf-pkg-config \
 systemd-libs \
 "
RDEPENDS:389-ds-base-libs = " \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 nss-util \
 openldap \
 openssl-libs \
 pcre2 \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:389-ds-base-snmp = " \
 389-ds-base \
 bash \
 glibc \
 net-snmp-agent-libs \
 net-snmp-libs \
 nspr \
 openldap \
 "
RDEPENDS:python3-lib389 = " \
 389-ds-base \
 iproute \
 openssl \
 openssl-perl \
 python3 \
 python3-argcomplete \
 python3-cryptography \
 python3-dateutil \
 python3-distro \
 python3-ldap \
 python3-libselinux \
 python3-psutil \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-setuptools \
 "
