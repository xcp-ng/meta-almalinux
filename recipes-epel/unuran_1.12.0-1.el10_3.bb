# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unuran"
PV = "1.12.0"
PR = "1.el10_3"
PACKAGES = " \
 unuran \
 unuran-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/unuran-1.12.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2402975b4ed0f60ffaa27f076db5f52f9dfccc0b49adfce2ab772cb98f2506a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unuran-1.12.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unuran;unpack=0"
SRC_URI[x86_64_v2_unuran.sha256sum] = "3e5bf2ea1faccd61f6d1f178db61d0595d013695d98524b79eef0a9776e3f7a3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unuran-devel-1.12.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unuran-devel;unpack=0"
SRC_URI[x86_64_v2_unuran-devel.sha256sum] = "0b26bc6510d8bee10723ab3ea7ba3144601fa1497c1675020463fe2ca04c386c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/unuran-1.12.0-1.el10_3.aarch64.rpm;name=aarch64_unuran;unpack=0"
SRC_URI[aarch64_unuran.sha256sum] = "d05b4cffdd044122b304a3c14a183d088a1f1b3ed9e17c14c7b38093ccb4c326"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/unuran-devel-1.12.0-1.el10_3.aarch64.rpm;name=aarch64_unuran-devel;unpack=0"
SRC_URI[aarch64_unuran-devel.sha256sum] = "006cc051a91fa043ebf72e19754b5f3c92ec09d060d4edc52353dd6bf57810e8"

RDEPENDS:unuran = " \
 glibc \
 "
RDEPENDS:unuran-devel = " \
 unuran \
 "
