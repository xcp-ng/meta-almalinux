# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "luksmeta"
PV = "10"
PR = "1.el10"
PACKAGES = " \
 libluksmeta \
 libluksmeta-devel \
 luksmeta \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/luksmeta-10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e043557b04adece0df945db9d4ad4609a7b70a8be2659533b49cf70bd356ace1"

URI_x86_64_v2_libluksmeta = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libluksmeta-10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libluksmeta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libluksmeta}"
SRC_URI[x86_64_v2_libluksmeta.sha256sum] = "5fed210edcd96a6e8331cbddddda883a86976488b3669c0f573ab08b95e77214"

URI_x86_64_v2_libluksmeta-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libluksmeta-devel-10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libluksmeta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libluksmeta-devel}"
SRC_URI[x86_64_v2_libluksmeta-devel.sha256sum] = "00807394e05fa9383262b51352ed8efa0cf117ea784bac47222deeab66951ab4"

URI_x86_64_v2_luksmeta = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/luksmeta-10-1.el10.x86_64_v2.rpm;name=x86_64_v2_luksmeta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_luksmeta}"
SRC_URI[x86_64_v2_luksmeta.sha256sum] = "75d9ef72a9cf03b507d931037ffb8bb027e8341ddfa4f436736b0a92d6c22405"

URI_aarch64_libluksmeta = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libluksmeta-10-1.el10.aarch64.rpm;name=aarch64_libluksmeta;unpack=0"
SRC_URI:append = " ${URI_aarch64_libluksmeta}"
SRC_URI[aarch64_libluksmeta.sha256sum] = "ea084cd0d1d1192df7debc68425819ba5ef048308f237c87ff0f85dba51bd288"

URI_aarch64_libluksmeta-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libluksmeta-devel-10-1.el10.aarch64.rpm;name=aarch64_libluksmeta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libluksmeta-devel}"
SRC_URI[aarch64_libluksmeta-devel.sha256sum] = "a1035d6b6836e84696afb8773860331c354c7385f56e77f5e5d4e9e3f6ff70f2"

URI_aarch64_luksmeta = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/luksmeta-10-1.el10.aarch64.rpm;name=aarch64_luksmeta;unpack=0"
SRC_URI:append = " ${URI_aarch64_luksmeta}"
SRC_URI[aarch64_luksmeta.sha256sum] = "6e868b38171e802a98eebefdd385ae2d144bb16e2183723b13ecef5d86f83fb4"

RDEPENDS:libluksmeta = " \
 cryptsetup-libs \
 glibc \
 "
RDEPENDS:libluksmeta-devel = " \
 cryptsetup-devel \
 libluksmeta \
 pkgconf-pkg-config \
 "
RDEPENDS:luksmeta = " \
 cryptsetup-libs \
 glibc \
 libluksmeta \
 "
