# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-id"
PV = "1.5.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-id \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-id-1.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39a70f9c979803b8c29636ff4a944313401bf18e46e234adce5dea6605e33ecf"

URI_x86_64_v2_python3-id = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-id-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-id;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-id}"
SRC_URI[x86_64_v2_python3-id.sha256sum] = "11eed3750c6e31126d3142db42b5a36656936a131ccd4e9fc7e30d9a0b8012cb"

URI_aarch64_python3-id = "${EPEL_MIRROR}/aarch64/Packages/p/python3-id-1.5.0-1.el10_0.noarch.rpm;name=aarch64_python3-id;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-id}"
SRC_URI[aarch64_python3-id.sha256sum] = "ad1079c933f3231af28a6b8b459e40c1586a1dafe098135cb54e05389caebe85"

RDEPENDS:python3-id = " \
 python3 \
 python3-requests \
 "
