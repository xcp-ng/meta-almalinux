# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-UUID"
PV = "1.227"
PR = "3.el10"
PACKAGES = " \
 perl-Data-UUID \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Data-UUID-1.227-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2af2c93703206c1ea6d8a064cd3c43430cf8aca3566e7561f921d8e069faadc8"

URI_x86_64_v2_perl-Data-UUID = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Data-UUID-1.227-3.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Data-UUID;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-UUID}"
SRC_URI[x86_64_v2_perl-Data-UUID.sha256sum] = "cf1d7a2632b5db1c90d877b9c092dbddf5f5f1a29da38bb47f515029647e6c5f"

URI_aarch64_perl-Data-UUID = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Data-UUID-1.227-3.el10.aarch64.rpm;name=aarch64_perl-Data-UUID;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-UUID}"
SRC_URI[aarch64_perl-Data-UUID.sha256sum] = "11d61f986b588fbd29f249b145e9ffe7f97bb67c329194521977858ccbab4d69"

RDEPENDS:perl-Data-UUID = " \
 glibc \
 perl-Carp \
 perl-Digest-MD5 \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
