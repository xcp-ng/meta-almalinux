# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sereal-Encoder"
PV = "5.006"
PR = "1.el10_2"
PACKAGES = " \
 perl-Sereal-Encoder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sereal-Encoder-5.006-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fe34c607dd332938f223e9ca1028251da4f9c79dcb868028eeb4acf7492944f"

URI_x86_64_v2_perl-Sereal-Encoder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sereal-Encoder-5.006-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sereal-Encoder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sereal-Encoder}"
SRC_URI[x86_64_v2_perl-Sereal-Encoder.sha256sum] = "b97bb81b863d9d216e7ca288ab09faf8ea2f41cdecadd62290f08d1c6571298f"

URI_aarch64_perl-Sereal-Encoder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sereal-Encoder-5.006-1.el10_2.aarch64.rpm;name=aarch64_perl-Sereal-Encoder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sereal-Encoder}"
SRC_URI[aarch64_perl-Sereal-Encoder.sha256sum] = "05e8dc60feb6c2db24c74895883092b65c309e57d381f319ae112d37e91f6317"

RDEPENDS:perl-Sereal-Encoder = " \
 csnappy \
 glibc \
 libzstd \
 miniz \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
