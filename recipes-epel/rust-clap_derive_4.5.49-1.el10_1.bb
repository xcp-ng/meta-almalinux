# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_derive"
PV = "4.5.49"
PR = "1.el10_1"
PACKAGES = " \
 rust-clap_derive+debug-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive+raw-deprecated-devel \
 rust-clap_derive+unstable-markdown-devel \
 rust-clap_derive+unstable-v5-devel \
 rust-clap_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_derive-4.5.49-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76046d6aad45aa16553f589add835c2c17fb7c73fa63de830258937e6c94d2a3"

URI_x86_64_v2_rust-clap_derive+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+debug-devel-4.5.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+debug-devel.sha256sum] = "86723fc63e0ce77d50c751dc2ebd136f2e48b8a9f14d37728806d2f6468e0dfc"

URI_x86_64_v2_rust-clap_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+default-devel-4.5.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+default-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+default-devel.sha256sum] = "bf2b327a00749aa741967199490b2d8fe1ecaa315bfe8ee318d80733fca58786"

URI_x86_64_v2_rust-clap_derive+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+deprecated-devel-4.5.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+deprecated-devel.sha256sum] = "fac664cd07378d5ac95336e75d0e2c185d2cd679505d6eeec82a5314c44e7ec1"

URI_x86_64_v2_rust-clap_derive+raw-deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+raw-deprecated-devel-4.5.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+raw-deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+raw-deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+raw-deprecated-devel.sha256sum] = "01a8a3d316671b26acaea22d7140d1b7a1b84aab7e5a96f681d3953931f1c307"

URI_x86_64_v2_rust-clap_derive+unstable-markdown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+unstable-markdown-devel-4.5.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+unstable-markdown-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+unstable-markdown-devel.sha256sum] = "88aee134d5f2ed1c3c5d0425ada310a1c5c2080b5408acf5d3ec598a50c140e9"

URI_x86_64_v2_rust-clap_derive+unstable-v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+unstable-v5-devel-4.5.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+unstable-v5-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+unstable-v5-devel.sha256sum] = "d2291b2361b4673e49f226004947d76ca2df0fd55ba982f63432e49c1bbba3f6"

URI_x86_64_v2_rust-clap_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive-devel-4.5.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive-devel}"
SRC_URI[x86_64_v2_rust-clap_derive-devel.sha256sum] = "1ffa5d96f1d6739caa9eff0223970522314d3e358e9acf584554e0086e15eae2"

URI_aarch64_rust-clap_derive+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+debug-devel-4.5.49-1.el10_1.noarch.rpm;name=aarch64_rust-clap_derive+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+debug-devel}"
SRC_URI[aarch64_rust-clap_derive+debug-devel.sha256sum] = "c9c69e3e19230e128ef2c2b588be2365c353979c399ee5c470736349f2735c33"

URI_aarch64_rust-clap_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+default-devel-4.5.49-1.el10_1.noarch.rpm;name=aarch64_rust-clap_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+default-devel}"
SRC_URI[aarch64_rust-clap_derive+default-devel.sha256sum] = "307782f14dc704c1a4e1c9a047ad8b7d4e15e3ef3dd8d3699a3224d2626f5d93"

URI_aarch64_rust-clap_derive+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+deprecated-devel-4.5.49-1.el10_1.noarch.rpm;name=aarch64_rust-clap_derive+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+deprecated-devel}"
SRC_URI[aarch64_rust-clap_derive+deprecated-devel.sha256sum] = "3897ff5ee54053a2795eede7b80e8cf38abca058931068d7bdd2e8b5150be3cf"

URI_aarch64_rust-clap_derive+raw-deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+raw-deprecated-devel-4.5.49-1.el10_1.noarch.rpm;name=aarch64_rust-clap_derive+raw-deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+raw-deprecated-devel}"
SRC_URI[aarch64_rust-clap_derive+raw-deprecated-devel.sha256sum] = "2e3a13af34667104835246022714728a5ade2ce89bd3e5c41e76ab074bf54def"

URI_aarch64_rust-clap_derive+unstable-markdown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+unstable-markdown-devel-4.5.49-1.el10_1.noarch.rpm;name=aarch64_rust-clap_derive+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+unstable-markdown-devel}"
SRC_URI[aarch64_rust-clap_derive+unstable-markdown-devel.sha256sum] = "6cbfcfd8d6b6abfae4761bc12b8b2b87b67f747d76af767f2557fcb05678e8b4"

URI_aarch64_rust-clap_derive+unstable-v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+unstable-v5-devel-4.5.49-1.el10_1.noarch.rpm;name=aarch64_rust-clap_derive+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+unstable-v5-devel}"
SRC_URI[aarch64_rust-clap_derive+unstable-v5-devel.sha256sum] = "b4baa0d77cd8a62ddf46a517949f2d0fe82c0f7d590681da389aff2b3c54d400"

URI_aarch64_rust-clap_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive-devel-4.5.49-1.el10_1.noarch.rpm;name=aarch64_rust-clap_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive-devel}"
SRC_URI[aarch64_rust-clap_derive-devel.sha256sum] = "cb3dabcfe87ed9f9baf47515b92873f9a6b45499ad655779706ed37970d90abd"

RDEPENDS:rust-clap_derive+debug-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+default-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+deprecated-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+raw-deprecated-devel = " \
 cargo \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+unstable-markdown-devel = " \
 cargo \
 rust-anstyle+default-devel \
 rust-clap_derive-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-clap_derive+unstable-v5-devel = " \
 cargo \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
