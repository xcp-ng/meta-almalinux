# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aggregate6"
PV = "1.0.14"
PR = "1.el10_0"
PACKAGES = " \
 aggregate6 \
 python3-aggregate6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aggregate6-1.0.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54b1441a1550bcb6527262541dac3c5ed6e2fbfd78da32148348cbc75f742e3e"

URI_x86_64_v2_aggregate6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aggregate6-1.0.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_aggregate6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aggregate6}"
SRC_URI[x86_64_v2_aggregate6.sha256sum] = "947ed59ec2da30aa1704fc1f952f45e66187dee6ba7e8c5412913b778b48657d"

URI_x86_64_v2_python3-aggregate6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aggregate6-1.0.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aggregate6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aggregate6}"
SRC_URI[x86_64_v2_python3-aggregate6.sha256sum] = "d5c05780a318db57a4e44ecfbf05ef0df7c418b852e4004a4a19700436047142"

URI_aarch64_aggregate6 = "${EPEL_MIRROR}/aarch64/Packages/a/aggregate6-1.0.14-1.el10_0.noarch.rpm;name=aarch64_aggregate6;unpack=0"
SRC_URI:append = " ${URI_aarch64_aggregate6}"
SRC_URI[aarch64_aggregate6.sha256sum] = "a8eec235aebccf534eed2f5239eacf90fb4d6d239e4337690b6da1ea210c336b"

URI_aarch64_python3-aggregate6 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aggregate6-1.0.14-1.el10_0.noarch.rpm;name=aarch64_python3-aggregate6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aggregate6}"
SRC_URI[aarch64_python3-aggregate6.sha256sum] = "07565565c1d060a58afc1558a30fcf303a58bdc918fb989757f83fb48036a4ef"

RDEPENDS:aggregate6 = " \
 python3 \
 python3-aggregate6 \
 "
RDEPENDS:python3-aggregate6 = " \
 python3 \
 python3-py-radix \
 "
