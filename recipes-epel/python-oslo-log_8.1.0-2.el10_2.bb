# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-log"
PV = "8.1.0"
PR = "2.el10_2"
PACKAGES = " \
 python-oslo-log-doc \
 python-oslo-log-lang \
 python3-oslo-log \
 python3-oslo-log-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oslo-log-8.1.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "874c5511a6c93751a7e2e6f7783af8c3720bbdcb8c80ae536a28ced893459fe4"

URI_x86_64_v2_python-oslo-log-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-log-doc-8.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-log-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-log-doc}"
SRC_URI[x86_64_v2_python-oslo-log-doc.sha256sum] = "91855238ed650ead34d15bc381545211f4d57ccdaa3729f05b2a9c5a230b9359"

URI_x86_64_v2_python-oslo-log-lang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-log-lang-8.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-log-lang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-log-lang}"
SRC_URI[x86_64_v2_python-oslo-log-lang.sha256sum] = "3d51a785384d7bb1ecb6440a821c9faad8caec36481729474e69237c6f70a1be"

URI_x86_64_v2_python3-oslo-log = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-log-8.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-log}"
SRC_URI[x86_64_v2_python3-oslo-log.sha256sum] = "1c74a397dc157f3052d8176ae016d4e3d46ca81eb7b9c14d6c63d009eafa9dff"

URI_x86_64_v2_python3-oslo-log-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-log-tests-8.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-log-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-log-tests}"
SRC_URI[x86_64_v2_python3-oslo-log-tests.sha256sum] = "d727b2dc8c6e1443dd5fd92ce41647acefa35fa6aca924056e71c2194158a6d8"

URI_aarch64_python-oslo-log-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-log-doc-8.1.0-2.el10_2.noarch.rpm;name=aarch64_python-oslo-log-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-log-doc}"
SRC_URI[aarch64_python-oslo-log-doc.sha256sum] = "f7c43d4751a94e0805660ba19a9d9d48d0cd25975883a60ff292335b8afbab8b"

URI_aarch64_python-oslo-log-lang = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-log-lang-8.1.0-2.el10_2.noarch.rpm;name=aarch64_python-oslo-log-lang;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-log-lang}"
SRC_URI[aarch64_python-oslo-log-lang.sha256sum] = "e8a32b893b4b59fb26d8c74e6134392049035de53b312a6c2b2d68cfe657f244"

URI_aarch64_python3-oslo-log = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-log-8.1.0-2.el10_2.noarch.rpm;name=aarch64_python3-oslo-log;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-log}"
SRC_URI[aarch64_python3-oslo-log.sha256sum] = "735fbdcf76f6dc44c7f58023f61dad4da7c74cc1c0609398b27779f4ccb631e1"

URI_aarch64_python3-oslo-log-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-log-tests-8.1.0-2.el10_2.noarch.rpm;name=aarch64_python3-oslo-log-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-log-tests}"
SRC_URI[aarch64_python3-oslo-log-tests.sha256sum] = "a7f1816334a2d2e1a1e88fa75485f98127ea5a1c37f9ca0b13cff39fff53ef56"

RDEPENDS:python-oslo-log-doc = " \
 "
RDEPENDS:python-oslo-log-lang = " \
 "
RDEPENDS:python3-oslo-log = " \
 python-oslo-log-lang \
 python3 \
 python3-dateutil \
 python3-debtcollector \
 python3-oslo-config \
 python3-oslo-context \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 "
RDEPENDS:python3-oslo-log-tests = " \
 python3 \
 python3-oslo-log \
 "
