# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nickle"
PV = "2.103"
PR = "1.el10_0"
PACKAGES = " \
 nickle \
 nickle-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nickle-2.103-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "601176926c3aafc6523c1e0688bca5e99f42da68e872213635be2721e18af570"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nickle-2.103-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nickle;unpack=0"
SRC_URI[x86_64_v2_nickle.sha256sum] = "e99a1d7f2a7c46e931af8696215121ae2e87fa0ffd7fb8e9095eb238481efd23"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nickle-devel-2.103-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nickle-devel;unpack=0"
SRC_URI[x86_64_v2_nickle-devel.sha256sum] = "cc9128ffbf80f0e39e703c909a38bf5b1b73ecd566a3d58adbfcc55a3ce70655"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nickle-2.103-1.el10_0.aarch64.rpm;name=aarch64_nickle;unpack=0"
SRC_URI[aarch64_nickle.sha256sum] = "84e6c3097329cd1def345fc3ad25fa6a11444923fed10bd3cd258dc7112afbf5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nickle-devel-2.103-1.el10_0.aarch64.rpm;name=aarch64_nickle-devel;unpack=0"
SRC_URI[aarch64_nickle-devel.sha256sum] = "fdc68534c2ff5f0e04aac5b2498900f87e607ff10ed09e8351cefdab3cca1ae9"

RDEPENDS:nickle = " \
 bash \
 glibc \
 readline \
 "
RDEPENDS:nickle-devel = " \
 nickle \
 "
