# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-options"
PV = "0.7.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-cargo-options+default-devel \
 rust-cargo-options+serde-devel \
 rust-cargo-options-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-options-0.7.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfee6c79193b5253552bc96d28c60b8b20ceef90656afa8b6b49d9752f11793c"

URI_x86_64_v2_rust-cargo-options+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-options+default-devel-0.7.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-options+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-options+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-options+default-devel.sha256sum] = "1d78ea22d9995423fa4ecfb642c7b63417222a627bda40d8ffc455744ec9ed26"

URI_x86_64_v2_rust-cargo-options+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-options+serde-devel-0.7.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-options+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-options+serde-devel}"
SRC_URI[x86_64_v2_rust-cargo-options+serde-devel.sha256sum] = "b1382e18177a89ee9247cb50420afd45a97d674eff149e949b8d97697d43bff4"

URI_x86_64_v2_rust-cargo-options-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-options-devel-0.7.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-options-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-options-devel}"
SRC_URI[x86_64_v2_rust-cargo-options-devel.sha256sum] = "b63ad19505dc2b7261171a2259d568983c3a433d1ef6aedd640eaab669ee5379"

URI_aarch64_rust-cargo-options+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-options+default-devel-0.7.6-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-options+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-options+default-devel}"
SRC_URI[aarch64_rust-cargo-options+default-devel.sha256sum] = "cc15e423607ad0010b6c71bdbc05d2eca95770720588d24719213ab2e481b5b6"

URI_aarch64_rust-cargo-options+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-options+serde-devel-0.7.6-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-options+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-options+serde-devel}"
SRC_URI[aarch64_rust-cargo-options+serde-devel.sha256sum] = "f6886014f8518b3a7c1cd4bf78c0237e73d3d0f0d2e5928fbf5ab264dfa0e8e7"

URI_aarch64_rust-cargo-options-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-options-devel-0.7.6-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-options-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-options-devel}"
SRC_URI[aarch64_rust-cargo-options-devel.sha256sum] = "0f2ba7d1cadbe0252132cf85c965ffc2b2087bcaa70ff6fa1418174a6e9135ee"

RDEPENDS:rust-cargo-options+default-devel = " \
 cargo \
 rust-cargo-options-devel \
 "
RDEPENDS:rust-cargo-options+serde-devel = " \
 cargo \
 rust-cargo-options-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-cargo-options-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+unstable-styles-devel \
 rust-clap+wrap_help-devel \
 "
