# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashbrown0.16"
PV = "0.16.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-hashbrown0.16+allocator-api2-devel \
 rust-hashbrown0.16+default-devel \
 rust-hashbrown0.16+default-hasher-devel \
 rust-hashbrown0.16+equivalent-devel \
 rust-hashbrown0.16+inline-more-devel \
 rust-hashbrown0.16+raw-entry-devel \
 rust-hashbrown0.16+rayon-devel \
 rust-hashbrown0.16+serde-devel \
 rust-hashbrown0.16-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hashbrown0.16-0.16.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c17519121a051d004a3369e912faa064c3e81b062863afac48d5a9cc50da1e4"

URI_x86_64_v2_rust-hashbrown0.16+allocator-api2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.16+allocator-api2-devel-0.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.16+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.16+allocator-api2-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.16+allocator-api2-devel.sha256sum] = "5401d98288747e579aac78dec8f6327d7ecf44aa49e0af2e7f37e6ecc5c5cf9d"

URI_x86_64_v2_rust-hashbrown0.16+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.16+default-devel-0.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.16+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.16+default-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.16+default-devel.sha256sum] = "c501d251082e1c38923e78fc4faa61f93ec9c5512b77d86de34f536e63cf6c13"

URI_x86_64_v2_rust-hashbrown0.16+default-hasher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.16+default-hasher-devel-0.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.16+default-hasher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.16+default-hasher-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.16+default-hasher-devel.sha256sum] = "9eef623866d2a38e70e1f56f46ec5d5d6c0cca68bbd2e5928c8158611cd984f6"
RPROVIDES:rust-hashbrown0.16+default-hasher-devel:x86_64_v2 = "virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~"

URI_x86_64_v2_rust-hashbrown0.16+equivalent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.16+equivalent-devel-0.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.16+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.16+equivalent-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.16+equivalent-devel.sha256sum] = "d531bf6a1ac7948f7c73a7de6f57c4bf57a07adb742a3be22f34764ff8d3546a"

URI_x86_64_v2_rust-hashbrown0.16+inline-more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.16+inline-more-devel-0.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.16+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.16+inline-more-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.16+inline-more-devel.sha256sum] = "f49c0d2852b17ecc9c7c9fdd837a9a470dc56ec2a10f8cc9888ade7a1ec89fb6"
RPROVIDES:rust-hashbrown0.16+inline-more-devel:x86_64_v2 = "virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~"

URI_x86_64_v2_rust-hashbrown0.16+raw-entry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.16+raw-entry-devel-0.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.16+raw-entry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.16+raw-entry-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.16+raw-entry-devel.sha256sum] = "e64e083fca91357a0085c481f061185e66c4635fbedac4bbc02ba780e468374d"

URI_x86_64_v2_rust-hashbrown0.16+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.16+rayon-devel-0.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.16+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.16+rayon-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.16+rayon-devel.sha256sum] = "a4557bfcb778efde7e76c7dd8d5adaf91bea93dc1689f284faedd1b33daf7667"

URI_x86_64_v2_rust-hashbrown0.16+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.16+serde-devel-0.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.16+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.16+serde-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.16+serde-devel.sha256sum] = "5044162b441b0b270004eaeb271e0854ccf5682a12cabfabb85d12e8ca715630"

URI_x86_64_v2_rust-hashbrown0.16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.16-devel-0.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.16-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.16-devel.sha256sum] = "80ec4b5bdb5d47c25282686ba5263fd954d1436fc2cffb74ac0d104e24161e4a"
RPROVIDES:rust-hashbrown0.16-devel:x86_64_v2 = "virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~ virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"

URI_aarch64_rust-hashbrown0.16+allocator-api2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.16+allocator-api2-devel-0.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown0.16+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.16+allocator-api2-devel}"
SRC_URI[aarch64_rust-hashbrown0.16+allocator-api2-devel.sha256sum] = "f8f13d08b0c0fb4c9097ece010b5430b512e4c2c1379e6124a76ddd952fb672e"

URI_aarch64_rust-hashbrown0.16+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.16+default-devel-0.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown0.16+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.16+default-devel}"
SRC_URI[aarch64_rust-hashbrown0.16+default-devel.sha256sum] = "6fefa111d8751236c076bb49c78e96c1ba4550b9f3b615003841f2b4b16000b0"

URI_aarch64_rust-hashbrown0.16+default-hasher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.16+default-hasher-devel-0.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown0.16+default-hasher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.16+default-hasher-devel}"
SRC_URI[aarch64_rust-hashbrown0.16+default-hasher-devel.sha256sum] = "727dbc891fb1aa5238768aeeacfb782e7faae5b99b9986fe22c7fea1265e95b6"
RPROVIDES:rust-hashbrown0.16+default-hasher-devel:aarch64 = "virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~"

URI_aarch64_rust-hashbrown0.16+equivalent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.16+equivalent-devel-0.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown0.16+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.16+equivalent-devel}"
SRC_URI[aarch64_rust-hashbrown0.16+equivalent-devel.sha256sum] = "7c311e685f942d2a6caaef83e0131d2e4c8daf441565a554342cdddf8d760644"

URI_aarch64_rust-hashbrown0.16+inline-more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.16+inline-more-devel-0.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown0.16+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.16+inline-more-devel}"
SRC_URI[aarch64_rust-hashbrown0.16+inline-more-devel.sha256sum] = "f38b0fa578d0ecfd9d103f34eb7ab031a2e5a580a63f05ab00999ee8e0780ff2"
RPROVIDES:rust-hashbrown0.16+inline-more-devel:aarch64 = "virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~"

URI_aarch64_rust-hashbrown0.16+raw-entry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.16+raw-entry-devel-0.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown0.16+raw-entry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.16+raw-entry-devel}"
SRC_URI[aarch64_rust-hashbrown0.16+raw-entry-devel.sha256sum] = "c4e63ce0206b79f6fbae8d66cf44fc133538d7ab1ad6aa25bd1d4fc74ba6f095"

URI_aarch64_rust-hashbrown0.16+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.16+rayon-devel-0.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown0.16+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.16+rayon-devel}"
SRC_URI[aarch64_rust-hashbrown0.16+rayon-devel.sha256sum] = "c841568c2ed799a9f0b4f00469523879d5aca1b3f9f791f6d55c8f100d9851e8"

URI_aarch64_rust-hashbrown0.16+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.16+serde-devel-0.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown0.16+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.16+serde-devel}"
SRC_URI[aarch64_rust-hashbrown0.16+serde-devel.sha256sum] = "e6bf28e5928cf3b452f44d58e5801c68ea512391f529b658df513a7ad986e999"

URI_aarch64_rust-hashbrown0.16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.16-devel-0.16.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown0.16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.16-devel}"
SRC_URI[aarch64_rust-hashbrown0.16-devel.sha256sum] = "cac593bea9a879e16767e79d3e61f72c1233e198479aa4f8029cb605e2923d45"
RPROVIDES:rust-hashbrown0.16-devel:aarch64 = "virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~ virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"

RDEPENDS:rust-hashbrown0.16+allocator-api2-devel = " \
 cargo \
 rust-allocator-api2+alloc-devel \
 rust-allocator-api2-devel \
 rust-hashbrown0.16-devel \
 "
RDEPENDS:rust-hashbrown0.16+default-devel = " \
 cargo \
 rust-hashbrown0.16+allocator-api2-devel \
 rust-hashbrown0.16+default-hasher-devel \
 rust-hashbrown0.16+equivalent-devel \
 rust-hashbrown0.16+inline-more-devel \
 rust-hashbrown0.16+raw-entry-devel \
 rust-hashbrown0.16-devel \
 "
RDEPENDS:rust-hashbrown0.16+default-hasher-devel = " \
 cargo \
 rust-foldhash-devel \
 rust-hashbrown0.16-devel \
 "
RDEPENDS:rust-hashbrown0.16+equivalent-devel = " \
 cargo \
 rust-equivalent-devel \
 rust-hashbrown0.16-devel \
 "
RDEPENDS:rust-hashbrown0.16+inline-more-devel = " \
 cargo \
 rust-hashbrown0.16-devel \
 "
RDEPENDS:rust-hashbrown0.16+raw-entry-devel = " \
 cargo \
 rust-hashbrown0.16-devel \
 "
RDEPENDS:rust-hashbrown0.16+rayon-devel = " \
 cargo \
 rust-hashbrown0.16-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-hashbrown0.16+serde-devel = " \
 cargo \
 rust-hashbrown0.16-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-hashbrown0.16-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~ rpm/virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~ rpm/virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~ rpm/virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~ rpm/virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~ rpm/virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~ rpm/virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"
