# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-lockfile"
PE = "1"
PV = "0.12.2"
PR = "16.el10_0"
PACKAGES = " \
 python-lockfile-doc \
 python3-lockfile \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-lockfile-0.12.2-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b3f3895b34fb0932ad1e5cfe03e660aad4d79c0dfe9cfa9ddf11345985ce6356"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-lockfile-doc-0.12.2-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-lockfile-doc;unpack=0"
SRC_URI[x86_64_v2_python-lockfile-doc.sha256sum] = "fe3076e7548947ec407e227d39c141468d2d0e168bd164cd9d972ca150036174"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lockfile-0.12.2-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-lockfile;unpack=0"
SRC_URI[x86_64_v2_python3-lockfile.sha256sum] = "d73013678e6ca64d069688e3ca649d11a73f3e6e13ad2733c3d1476f8212ec36"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-lockfile-doc-0.12.2-16.el10_0.noarch.rpm;name=aarch64_python-lockfile-doc;unpack=0"
SRC_URI[aarch64_python-lockfile-doc.sha256sum] = "0ea26eb488632ac13af61a681d7b9f81d598a7886102f5460dd0edffac298500"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-lockfile-0.12.2-16.el10_0.noarch.rpm;name=aarch64_python3-lockfile;unpack=0"
SRC_URI[aarch64_python3-lockfile.sha256sum] = "dfd39ee57296abdd917057ffcfb4901db2f4a80c61bb7f2fa32cdab81899d9cb"

RDEPENDS:python-lockfile-doc = " \
 "
RDEPENDS:python3-lockfile = " \
 python3 \
 "
