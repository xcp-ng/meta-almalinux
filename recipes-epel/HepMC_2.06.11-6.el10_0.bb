# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "HepMC"
PV = "2.06.11"
PR = "6.el10_0"
PACKAGES = " \
 HepMC \
 HepMC-devel \
 HepMC-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/HepMC-2.06.11-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a4ba3e071848ce32eab7ddce617c36ac182502fcc07d79d0a893c09bae417220"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC-2.06.11-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC;unpack=0"
SRC_URI[x86_64_v2_HepMC.sha256sum] = "bb81ef3aaa78ea6df38660773e4283b04fba7b31a325f1ba9af393411592c570"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC-devel-2.06.11-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC-devel;unpack=0"
SRC_URI[x86_64_v2_HepMC-devel.sha256sum] = "90494970aa399b4263519aa50b8290b196896b38f51bc8be9e70f07e6530a9e8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC-doc-2.06.11-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_HepMC-doc;unpack=0"
SRC_URI[x86_64_v2_HepMC-doc.sha256sum] = "076c1d2b239939d262247ab596b2f6aab0d58715635cb4bc3117768a6480e7dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/HepMC-2.06.11-6.el10_0.aarch64.rpm;name=aarch64_HepMC;unpack=0"
SRC_URI[aarch64_HepMC.sha256sum] = "6d4bf8d22d05380850400a1a82a9f33812075fca4d18c1a6392e338efaab33fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/HepMC-devel-2.06.11-6.el10_0.aarch64.rpm;name=aarch64_HepMC-devel;unpack=0"
SRC_URI[aarch64_HepMC-devel.sha256sum] = "c87fefb6abebac69bfa7131b865f85d4042cbb13a65a0f5b1dfbac9b734d98d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/HepMC-doc-2.06.11-6.el10_0.noarch.rpm;name=aarch64_HepMC-doc;unpack=0"
SRC_URI[aarch64_HepMC-doc.sha256sum] = "1fed0a981c60277819fbf3fd84a5d4c437219c38d3ad600b6d35116c5537dc4a"

RDEPENDS:HepMC = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:HepMC-devel = " \
 HepMC \
 "
RDEPENDS:HepMC-doc = " \
 "
