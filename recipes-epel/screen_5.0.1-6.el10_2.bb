# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "screen"
PV = "5.0.1"
PR = "6.el10_2"
PACKAGES = " \
 screen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/screen-5.0.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b41e8dbdde000cff22b86f9a289972ac96e85dbbade85bc0bb87ccd29e0711f0"

URI_x86_64_v2_screen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/screen-5.0.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_screen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_screen}"
SRC_URI[x86_64_v2_screen.sha256sum] = "95d0d7f2f66bf600bcf4c9430f8b346049c555211b7665b436315966e23a2a6b"

URI_aarch64_screen = "${EPEL_MIRROR}/aarch64/Packages/s/screen-5.0.1-6.el10_2.aarch64.rpm;name=aarch64_screen;unpack=0"
SRC_URI:append = " ${URI_aarch64_screen}"
SRC_URI[aarch64_screen.sha256sum] = "a7c21e6435299e307985f2dbaaecb3eb3284d61bc7d78a55db2c7f570492ee40"

RDEPENDS:screen = " \
 glibc \
 ncurses-libs \
 pam-libs \
 "
