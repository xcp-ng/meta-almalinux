# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustversion"
PV = "1.0.23"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustversion+default-devel \
 rust-rustversion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustversion-1.0.23-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a05e4136ab696eee20f288da81bc4a5789f32701e7da734641bb2e566253fa52"

URI_x86_64_v2_rust-rustversion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustversion+default-devel-1.0.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustversion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustversion+default-devel}"
SRC_URI[x86_64_v2_rust-rustversion+default-devel.sha256sum] = "6343bea2e47b6b03cd6701e063762c991067cc82928c5bf6ce0c538a28dd0c6b"

URI_x86_64_v2_rust-rustversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustversion-devel-1.0.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustversion-devel}"
SRC_URI[x86_64_v2_rust-rustversion-devel.sha256sum] = "c53e58c441cf5723a50cb53ba0e15a514e8533433045ffdf7352dbc7b35089dd"

URI_aarch64_rust-rustversion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustversion+default-devel-1.0.23-1.el10_3.noarch.rpm;name=aarch64_rust-rustversion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustversion+default-devel}"
SRC_URI[aarch64_rust-rustversion+default-devel.sha256sum] = "f2e05c88acf6fc5e354c3b5bed1e154c96eb1cfcbfca1b4f5e5b9cf7c8c011e1"

URI_aarch64_rust-rustversion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustversion-devel-1.0.23-1.el10_3.noarch.rpm;name=aarch64_rust-rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustversion-devel}"
SRC_URI[aarch64_rust-rustversion-devel.sha256sum] = "3c93c63ddb6714cd97edce6122d2122ea37fde34c2daee9c72130bdd11511beb"

RDEPENDS:rust-rustversion+default-devel = " \
 cargo \
 rust-rustversion-devel \
 "
RDEPENDS:rust-rustversion-devel = " \
 cargo \
 rust \
 "
