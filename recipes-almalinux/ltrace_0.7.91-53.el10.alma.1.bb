# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ltrace"
PV = "0.7.91"
PR = "53.el10.alma.1"
PACKAGES = " \
 ltrace \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ltrace-0.7.91-53.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "88c4673fa7703d594555b839b644e1a308f176371972555fb4fdf14496384944"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ltrace-0.7.91-53.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_ltrace;unpack=0"
SRC_URI[x86_64_v2_ltrace.sha256sum] = "a0d126e5a4cdd27957e1ee96d4966306f37ad359b4da6b09580620b678be778a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ltrace-0.7.91-53.el10.alma.1.aarch64.rpm;name=aarch64_ltrace;unpack=0"
SRC_URI[aarch64_ltrace.sha256sum] = "c7de75aed8a44ffafbadd0b3383224a291bcbc6fe1c529f68f991c1ce2635e68"

RDEPENDS:ltrace = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libselinux \
 libstdc++ \
 "
