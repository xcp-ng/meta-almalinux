# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libs3"
PV = "4.1"
PR = "0.20.20190408git287e4be.el10_0"
PACKAGES = " \
 libs3 \
 libs3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libs3-4.1-0.20.20190408git287e4be.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c68f2229d1e7e8a2ad1a7ddf01a478aa787540ce5a444bfdd28a2ee8112cf02"

URI_x86_64_v2_libs3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libs3-4.1-0.20.20190408git287e4be.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libs3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libs3}"
SRC_URI[x86_64_v2_libs3.sha256sum] = "45d36f6bbfa3e2001d814a10ecca7377a99ef8e9b009d69fef475f24e3d05cd4"

URI_x86_64_v2_libs3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libs3-devel-4.1-0.20.20190408git287e4be.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libs3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libs3-devel}"
SRC_URI[x86_64_v2_libs3-devel.sha256sum] = "32d9d277c83b3c9547fbe5a63f75de06651adb9492ccf02f9df3069537bcacd5"

URI_aarch64_libs3 = "${EPEL_MIRROR}/aarch64/Packages/l/libs3-4.1-0.20.20190408git287e4be.el10_0.aarch64.rpm;name=aarch64_libs3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libs3}"
SRC_URI[aarch64_libs3.sha256sum] = "0a9c561972b622718f757ebe9135ba25f671e13dbc07fcdec3a2bb6800d6abfd"

URI_aarch64_libs3-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libs3-devel-4.1-0.20.20190408git287e4be.el10_0.aarch64.rpm;name=aarch64_libs3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libs3-devel}"
SRC_URI[aarch64_libs3-devel.sha256sum] = "166b37449081624fd462c4d3f3fc2b09cc799dc0b3a9c6c7394d8b349433a2dc"

RDEPENDS:libs3 = " \
 glibc \
 libxml2 \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libs3-devel = " \
 libs3 \
 "
