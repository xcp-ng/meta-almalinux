# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gzip"
PV = "1.13"
PR = "4.el10"
PACKAGES = " \
 gzip \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gzip-1.13-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5a18d87647b15c76acff2c84e7a826b4844782ce5719cf80300fa1ca898d720e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gzip-1.13-4.el10.x86_64_v2.rpm;name=x86_64_v2_gzip;unpack=0"
SRC_URI[x86_64_v2_gzip.sha256sum] = "e853f6d7fa2d36218f77ca95d11a15d901dc9de3fd81999becef513037e2e818"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gzip-1.13-4.el10.aarch64.rpm;name=aarch64_gzip;unpack=0"
SRC_URI[aarch64_gzip.sha256sum] = "5bc51903500824fedf633eb558db9f161978f14ad5475c5f3f6a3786ad39ae73"

RDEPENDS:gzip = " \
 bash \
 glibc \
 virtual/coreutils \
 "
