# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-msgpack"
PV = "1.1.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-msgpack \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-msgpack-1.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e12a90c6f0c84cdc11445302a2b93252f524e7b04f789691f71d6978a8b9f19f"

URI_x86_64_v2_python3-msgpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-msgpack-1.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-msgpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-msgpack}"
SRC_URI[x86_64_v2_python3-msgpack.sha256sum] = "304af1335acc842ea98504a31ce22f1dfb9fd9b12b707c4155d84f462d755c0f"

URI_aarch64_python3-msgpack = "${EPEL_MIRROR}/aarch64/Packages/p/python3-msgpack-1.1.0-2.el10_0.aarch64.rpm;name=aarch64_python3-msgpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-msgpack}"
SRC_URI[aarch64_python3-msgpack.sha256sum] = "754f0b86421749dfc1001ed962dd68f928ae478b93422d21a174a1f76c81524c"

RDEPENDS:python3-msgpack = " \
 glibc \
 python3 \
 "
