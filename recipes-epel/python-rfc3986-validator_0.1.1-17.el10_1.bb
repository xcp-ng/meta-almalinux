# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rfc3986-validator"
PV = "0.1.1"
PR = "17.el10_1"
PACKAGES = " \
 python3-rfc3986-validator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rfc3986-validator-0.1.1-17.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "172ef4532ca9be669f053540279baf54542fd7a53dae33d4741c4503820076d1"

URI_x86_64_v2_python3-rfc3986-validator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rfc3986-validator-0.1.1-17.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rfc3986-validator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rfc3986-validator}"
SRC_URI[x86_64_v2_python3-rfc3986-validator.sha256sum] = "799271052882ac377a500db64ce1629c21bfa929905189458b37bd2d992feb56"

URI_aarch64_python3-rfc3986-validator = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rfc3986-validator-0.1.1-17.el10_1.noarch.rpm;name=aarch64_python3-rfc3986-validator;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rfc3986-validator}"
SRC_URI[aarch64_python3-rfc3986-validator.sha256sum] = "3a5758f2ae1bd7d75aaf247150888ca7fb30200e65b164a41331f1a1b42a537c"

RDEPENDS:python3-rfc3986-validator = " \
 python3 \
 "
