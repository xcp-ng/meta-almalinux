# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cube"
PV = "4.9.1"
PR = "1.el10_1"
PACKAGES = " \
 cube \
 cube-devel \
 cube-doc \
 cube-guilib \
 cube-guilib-devel \
 cube-libs \
 cube-libs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cube-4.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8e3166724440733f9e0436e1ff38e27b2a673d7fca6dd055aeca6a26cfc985e"

URI_x86_64_v2_cube = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-4.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube}"
SRC_URI[x86_64_v2_cube.sha256sum] = "f5c6ada37b58a7a7c0a1ac365b55819f5d7f453926f3aa5cbb9d63e7c8516002"

URI_x86_64_v2_cube-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-devel-4.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-devel}"
SRC_URI[x86_64_v2_cube-devel.sha256sum] = "349b6249883c640e420aa8152027285a6a7cf9e358ea0efa69bb4640f371ed69"

URI_x86_64_v2_cube-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-doc-4.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_cube-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-doc}"
SRC_URI[x86_64_v2_cube-doc.sha256sum] = "e7505c063938bfdad1ec3409f0a6749f5fe6e6c5fe95de8cbd4f5366af66e26b"

URI_x86_64_v2_cube-guilib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-guilib-4.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-guilib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-guilib}"
SRC_URI[x86_64_v2_cube-guilib.sha256sum] = "acb9172124c3d22327c8e7835db15a3baf1ba08a2c7f9f55ce6aaac579da942e"

URI_x86_64_v2_cube-guilib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-guilib-devel-4.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-guilib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-guilib-devel}"
SRC_URI[x86_64_v2_cube-guilib-devel.sha256sum] = "00199d01ca4d2fbaf9fc2bfc70292af62c880f45e3a08af5673cea038865d51f"

URI_x86_64_v2_cube-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-libs-4.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-libs}"
SRC_URI[x86_64_v2_cube-libs.sha256sum] = "2bd0f6a826f078eee4fa44f3b6105ba02f7fa476db247c4e9d0b1cd7d0205395"

URI_x86_64_v2_cube-libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cube-libs-devel-4.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cube-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cube-libs-devel}"
SRC_URI[x86_64_v2_cube-libs-devel.sha256sum] = "2745110743b9ca3364af315ca980f790b9fcd0dc029dda6f3e22788ab54e50f2"

URI_aarch64_cube = "${EPEL_MIRROR}/aarch64/Packages/c/cube-4.9.1-1.el10_1.aarch64.rpm;name=aarch64_cube;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube}"
SRC_URI[aarch64_cube.sha256sum] = "3346448f918671ae31eaa1cc054c61988dd3591569221b7879bcf867ce0cb67b"

URI_aarch64_cube-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cube-devel-4.9.1-1.el10_1.aarch64.rpm;name=aarch64_cube-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-devel}"
SRC_URI[aarch64_cube-devel.sha256sum] = "5c4cd39eb7676fb259cfaff09a9d9957e40c87026fc200a3d84fbdef55b5d89c"

URI_aarch64_cube-doc = "${EPEL_MIRROR}/aarch64/Packages/c/cube-doc-4.9.1-1.el10_1.noarch.rpm;name=aarch64_cube-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-doc}"
SRC_URI[aarch64_cube-doc.sha256sum] = "9b2043f1ffba0771e454e4eebea7bc774378a209f75b2fdc00292dc59c4c6c02"

URI_aarch64_cube-guilib = "${EPEL_MIRROR}/aarch64/Packages/c/cube-guilib-4.9.1-1.el10_1.aarch64.rpm;name=aarch64_cube-guilib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-guilib}"
SRC_URI[aarch64_cube-guilib.sha256sum] = "b6c73eb092f1a889e8303a074bb356e0348d8d56d565f2a54776f0992a9470bc"

URI_aarch64_cube-guilib-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cube-guilib-devel-4.9.1-1.el10_1.aarch64.rpm;name=aarch64_cube-guilib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-guilib-devel}"
SRC_URI[aarch64_cube-guilib-devel.sha256sum] = "1f229ba05eb87a603d9c5090de8f6e4b2686c825fbc91334503813ab185d864d"

URI_aarch64_cube-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cube-libs-4.9.1-1.el10_1.aarch64.rpm;name=aarch64_cube-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-libs}"
SRC_URI[aarch64_cube-libs.sha256sum] = "5bbb27d11b561b324cc462611221b6fa18bf330d6e4742fc9733cca69f37422d"

URI_aarch64_cube-libs-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cube-libs-devel-4.9.1-1.el10_1.aarch64.rpm;name=aarch64_cube-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cube-libs-devel}"
SRC_URI[aarch64_cube-libs-devel.sha256sum] = "5e60434edf5fc3ff0c5feb1be773ac4773072176ab6a22103131935d8cc423f2"

RDEPENDS:cube = " \
 bash \
 cube-guilib \
 cube-libs \
 dbus-libs \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:cube-devel = " \
 cube-guilib-devel \
 cube-libs-devel \
 "
RDEPENDS:cube-doc = " \
 "
RDEPENDS:cube-guilib = " \
 cube-libs \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:cube-guilib-devel = " \
 cmake-filesystem \
 cube-guilib \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:cube-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:cube-libs-devel = " \
 cmake-filesystem \
 cube-guilib \
 cube-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
