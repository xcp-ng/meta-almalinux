# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-semver"
PV = "3.0.2"
PR = "2.el10_0"
PACKAGES = " \
 python3-semver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-semver-3.0.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac5ae136a53e8079ffb9ee2c7973e03c12252d7cd48ab66a63052157a5589c1f"

URI_x86_64_v2_python3-semver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-semver-3.0.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-semver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-semver}"
SRC_URI[x86_64_v2_python3-semver.sha256sum] = "ad03c248d3383611b9a24b490a2b2df497316b77c99864b216a240d4bf38bf82"

URI_aarch64_python3-semver = "${EPEL_MIRROR}/aarch64/Packages/p/python3-semver-3.0.2-2.el10_0.noarch.rpm;name=aarch64_python3-semver;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-semver}"
SRC_URI[aarch64_python3-semver.sha256sum] = "2c7c10e145f467d459bb53eec023653e69d45d8e982aa5dda6e92654dae9a364"

RDEPENDS:python3-semver = " \
 python3 \
 "
