# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "novnc"
PV = "1.5.0"
PR = "1.el10_0"
PACKAGES = " \
 novnc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/novnc-1.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3b7fafe5a1c5052a166c54bf967a9ffaa6c32b471dd223ed28f817135a2e968d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/novnc-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_novnc;unpack=0"
SRC_URI[x86_64_v2_novnc.sha256sum] = "ff8b0686056277b23621eaf396a5618a5810b966afbcf9e5d48a781593e6179a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/novnc-1.5.0-1.el10_0.noarch.rpm;name=aarch64_novnc;unpack=0"
SRC_URI[aarch64_novnc.sha256sum] = "eaf31a5330159df9bb6e996fff84066f01b33d088f9e1301a2e392c4e1040a06"

RDEPENDS:novnc = " \
 bash \
 python3-websockify \
 which \
 "
