# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libebur128"
PV = "1.2.6"
PR = "12.el10_1"
PACKAGES = " \
 libebur128 \
 libebur128-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libebur128-1.2.6-12.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "218faa64fb249de2209902b7d771a4dcd22be8b31966f48ed3411373105195bc"

URI_x86_64_v2_libebur128 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libebur128-1.2.6-12.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libebur128;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libebur128}"
SRC_URI[x86_64_v2_libebur128.sha256sum] = "2731f9d05a400b572a24247f3bfaa2ec0fc87e0aee90a8c2edcc8c35653d0f78"

URI_x86_64_v2_libebur128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libebur128-devel-1.2.6-12.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libebur128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libebur128-devel}"
SRC_URI[x86_64_v2_libebur128-devel.sha256sum] = "0d7ec37c877e78b63f46fc8b1671963088f9d45ce1557b8e7adf5c3637e6c068"

URI_aarch64_libebur128 = "${EPEL_MIRROR}/aarch64/Packages/l/libebur128-1.2.6-12.el10_1.aarch64.rpm;name=aarch64_libebur128;unpack=0"
SRC_URI:append = " ${URI_aarch64_libebur128}"
SRC_URI[aarch64_libebur128.sha256sum] = "644d1ccf1702529da0b59e485016007148b78ee6f133a26fcc929039697d70f3"

URI_aarch64_libebur128-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libebur128-devel-1.2.6-12.el10_1.aarch64.rpm;name=aarch64_libebur128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libebur128-devel}"
SRC_URI[aarch64_libebur128-devel.sha256sum] = "cfab46fb3779014957647a6d6a04dedcb46e39d0e76c4c10f33f275c27308fc6"

RDEPENDS:libebur128 = " \
 glibc \
 "
RDEPENDS:libebur128-devel = " \
 libebur128 \
 pkgconf-pkg-config \
 "
