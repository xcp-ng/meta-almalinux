# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadiconsole"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 akonadiconsole \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadiconsole-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c1330ee5cbf2b2dafa69ef02c5d5d83d59bfe58b5c13712e72fc2e8739387c6"

URI_x86_64_v2_akonadiconsole = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadiconsole-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadiconsole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadiconsole}"
SRC_URI[x86_64_v2_akonadiconsole.sha256sum] = "77c7f9d8b359105fe2add810ed94e10ae44b83f088eef82956dbda3287dfa248"

URI_aarch64_akonadiconsole = "${EPEL_MIRROR}/aarch64/Packages/a/akonadiconsole-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akonadiconsole;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadiconsole}"
SRC_URI[aarch64_akonadiconsole.sha256sum] = "0360c51b5c0dc02072363b4a02cc50a3798e040a4f14463b4d2f8fd25a23314c"

RDEPENDS:akonadiconsole = " \
 akonadi-calendar-tools \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 calendarsupport \
 glibc \
 kf6-kcalendarcore \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kmime \
 libgcc \
 libkdepim \
 libstdc++ \
 messagelib \
 qt6-qtbase \
 qt6-qtbase-gui \
 xapian-core-libs \
 "
