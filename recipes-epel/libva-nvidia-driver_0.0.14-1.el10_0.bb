# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libva-nvidia-driver"
PV = "0.0.14"
PR = "1.el10_0"
PACKAGES = " \
 libva-nvidia-driver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libva-nvidia-driver-0.0.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cb1496a866af31b859c82110a77caea41563b3f0aef22ab2f5a37660fc23f2b"

URI_x86_64_v2_libva-nvidia-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libva-nvidia-driver-0.0.14-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libva-nvidia-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libva-nvidia-driver}"
SRC_URI[x86_64_v2_libva-nvidia-driver.sha256sum] = "b84fcfe10849c3d1c76d8f54309660cb9a63f70bc961035a21a3d06763e83f10"

URI_aarch64_libva-nvidia-driver = "${EPEL_MIRROR}/aarch64/Packages/l/libva-nvidia-driver-0.0.14-1.el10_0.aarch64.rpm;name=aarch64_libva-nvidia-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_libva-nvidia-driver}"
SRC_URI[aarch64_libva-nvidia-driver.sha256sum] = "c7d486b0046118f1002beb25cca62c81bc036dffb165bee7a0880625a8a52258"

RDEPENDS:libva-nvidia-driver = " \
 glibc \
 gstreamer1-plugins-bad-free-libs \
 libglvnd-egl \
 "
