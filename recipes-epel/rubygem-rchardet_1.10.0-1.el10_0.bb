# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-rchardet"
PV = "1.10.0"
PR = "1.el10_0"
PACKAGES = " \
 rubygem-rchardet \
 rubygem-rchardet-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-rchardet-1.10.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8592fc95f07f1c261a39115aa188f703678abbd058328fe18b5be05123affb23"

URI_x86_64_v2_rubygem-rchardet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rchardet-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rchardet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rchardet}"
SRC_URI[x86_64_v2_rubygem-rchardet.sha256sum] = "3274918b3835ab2d7fed71239acc687f0c2271975eaf0aec9a7d6c5002b8d22f"

URI_x86_64_v2_rubygem-rchardet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rchardet-doc-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rchardet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rchardet-doc}"
SRC_URI[x86_64_v2_rubygem-rchardet-doc.sha256sum] = "5f17d40f90002e71b8b9b18e4108ec20f676d7986176c0eb9aaae137fa34c045"

URI_aarch64_rubygem-rchardet = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rchardet-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rubygem-rchardet;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rchardet}"
SRC_URI[aarch64_rubygem-rchardet.sha256sum] = "9d30511e556d38e2cdbe7951d125b6768df8eeaea22729fbf92c56060d662e81"

URI_aarch64_rubygem-rchardet-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rchardet-doc-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rubygem-rchardet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rchardet-doc}"
SRC_URI[aarch64_rubygem-rchardet-doc.sha256sum] = "be7c7eef81ae1599cf6c411fb2869c96af51233b1218d1301a4454238350d201"

RDEPENDS:rubygem-rchardet = " \
 rubygems \
 "
RDEPENDS:rubygem-rchardet-doc = " \
 rubygem-rchardet \
 "
