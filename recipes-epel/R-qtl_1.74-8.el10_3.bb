# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-qtl"
PV = "1.74"
PR = "8.el10_3"
PACKAGES = " \
 R-qtl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-qtl-1.74-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73ca72047fd73b055b0558e24727a17adfe89335cab19c641215ac293e75cdff"

URI_x86_64_v2_R-qtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-qtl-1.74-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-qtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-qtl}"
SRC_URI[x86_64_v2_R-qtl.sha256sum] = "23f6f0a0a6242400a30f342c13c73f0da54b0c2b4e3a99c2a4e3b261aef7adf7"

URI_aarch64_R-qtl = "${EPEL_MIRROR}/aarch64/Packages/r/R-qtl-1.74-8.el10_3.aarch64.rpm;name=aarch64_R-qtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-qtl}"
SRC_URI[aarch64_R-qtl.sha256sum] = "1f954b3ac2d2d602f6ce0af7d16c8b0b0d4f06ac73664b1cd7391f2eab66e22a"

RDEPENDS:R-qtl = " \
 R-core \
 bash \
 flexiblas-netlib \
 glibc \
 ruby \
 "
