# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blowfish"
PV = "0.10.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-blowfish+bcrypt-devel \
 rust-blowfish+default-devel \
 rust-blowfish+zeroize-devel \
 rust-blowfish-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blowfish-0.10.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87f072aaf9f499b65e263c07c574f6e124159e05e2a9598441c03f853b64449f"

URI_x86_64_v2_rust-blowfish+bcrypt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blowfish+bcrypt-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blowfish+bcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blowfish+bcrypt-devel}"
SRC_URI[x86_64_v2_rust-blowfish+bcrypt-devel.sha256sum] = "a35fafebf7aa39b661f5fd2186dd380d7b431df63a16120bc38c392ca3f7c497"

URI_x86_64_v2_rust-blowfish+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blowfish+default-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blowfish+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blowfish+default-devel}"
SRC_URI[x86_64_v2_rust-blowfish+default-devel.sha256sum] = "f5084322f876d0ec2083ea23e2cd4f4dfe10c0baecaf62500874d6e3d096192e"

URI_x86_64_v2_rust-blowfish+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blowfish+zeroize-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blowfish+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blowfish+zeroize-devel}"
SRC_URI[x86_64_v2_rust-blowfish+zeroize-devel.sha256sum] = "f8e2cd96cb99ac198b96cf67190709d52cc88f2b89f582275daba887df3dace2"

URI_x86_64_v2_rust-blowfish-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blowfish-devel-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blowfish-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blowfish-devel}"
SRC_URI[x86_64_v2_rust-blowfish-devel.sha256sum] = "606c1038c1fb5e9d7659ff391c0cf05528324b2a341f986cbce66732e028bce8"

URI_aarch64_rust-blowfish+bcrypt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blowfish+bcrypt-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-blowfish+bcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blowfish+bcrypt-devel}"
SRC_URI[aarch64_rust-blowfish+bcrypt-devel.sha256sum] = "92427f3e3c6a05d8ce19f481f28075f944c920a15237152abebc40ddcac1c811"

URI_aarch64_rust-blowfish+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blowfish+default-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-blowfish+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blowfish+default-devel}"
SRC_URI[aarch64_rust-blowfish+default-devel.sha256sum] = "1527e9ff1f52241d3cc38fab44b8c9613c66559c37a4abd53ccf2bccd52b0327"

URI_aarch64_rust-blowfish+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blowfish+zeroize-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-blowfish+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blowfish+zeroize-devel}"
SRC_URI[aarch64_rust-blowfish+zeroize-devel.sha256sum] = "0f3617b96790ef646433c433fcc9afdd070c19abebea857f922513af7f7abcfb"

URI_aarch64_rust-blowfish-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blowfish-devel-0.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-blowfish-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blowfish-devel}"
SRC_URI[aarch64_rust-blowfish-devel.sha256sum] = "44d947e84478daf811db1a8a5c38b931688e8caad2d9758ebfeeb88390f1b6a4"

RDEPENDS:rust-blowfish+bcrypt-devel = " \
 cargo \
 rust-blowfish-devel \
 "
RDEPENDS:rust-blowfish+default-devel = " \
 cargo \
 rust-blowfish-devel \
 "
RDEPENDS:rust-blowfish+zeroize-devel = " \
 cargo \
 rust-blowfish-devel \
 rust-cipher+zeroize-devel \
 "
RDEPENDS:rust-blowfish-devel = " \
 cargo \
 rust \
 rust-byteorder-devel \
 rust-cipher+default-devel \
 "
