# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-threads-shared"
PV = "1.69"
PR = "511.el10"
PACKAGES = " \
 perl-threads-shared \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-threads-shared-1.69-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4e87b45d67096a5bca822fc7571e625c08c5b72247ea82c6ace38925eb886bd"

URI_x86_64_v2_perl-threads-shared = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-threads-shared-1.69-511.el10.x86_64_v2.rpm;name=x86_64_v2_perl-threads-shared;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-threads-shared}"
SRC_URI[x86_64_v2_perl-threads-shared.sha256sum] = "bd632da68ce2a80728c6ac2d8c307198bb98191157712670be9a8857cabb1712"

URI_aarch64_perl-threads-shared = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-threads-shared-1.69-511.el10.aarch64.rpm;name=aarch64_perl-threads-shared;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-threads-shared}"
SRC_URI[aarch64_perl-threads-shared.sha256sum] = "b7ca76bbc9f6435180a3bd22fd96a22c224afdea5576998154e993583195f4a4"

RDEPENDS:perl-threads-shared = " \
 glibc \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-threads \
 "
