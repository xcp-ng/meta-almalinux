# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytecount"
PV = "0.6.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-bytecount+default-devel \
 rust-bytecount+generic-simd-devel \
 rust-bytecount+html_report-devel \
 rust-bytecount+runtime-dispatch-simd-devel \
 rust-bytecount-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytecount-0.6.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "055f6c92d618bba4839b599303e26c222880fd99d018ee8d265d1a2ac3aa82e8"

URI_x86_64_v2_rust-bytecount+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecount+default-devel-0.6.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecount+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecount+default-devel}"
SRC_URI[x86_64_v2_rust-bytecount+default-devel.sha256sum] = "998403d0305fbeab68d417397a53e272c365f4d3f83d1e214fe458e7f9ee2f40"

URI_x86_64_v2_rust-bytecount+generic-simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecount+generic-simd-devel-0.6.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecount+generic-simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecount+generic-simd-devel}"
SRC_URI[x86_64_v2_rust-bytecount+generic-simd-devel.sha256sum] = "f79d3894bcd10d25a8d2c541b371e891020479f4fb14cce81f6daa42d0218c23"

URI_x86_64_v2_rust-bytecount+html_report-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecount+html_report-devel-0.6.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecount+html_report-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecount+html_report-devel}"
SRC_URI[x86_64_v2_rust-bytecount+html_report-devel.sha256sum] = "21cad57e2e1fa5dc48d6e3dd34f194ef566e330ac184e80b6525e686cff7fac9"

URI_x86_64_v2_rust-bytecount+runtime-dispatch-simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecount+runtime-dispatch-simd-devel-0.6.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecount+runtime-dispatch-simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecount+runtime-dispatch-simd-devel}"
SRC_URI[x86_64_v2_rust-bytecount+runtime-dispatch-simd-devel.sha256sum] = "c312c30eefa3dc91938765e03dec4e863833447afaba7b84ceca85eaaef8c131"

URI_x86_64_v2_rust-bytecount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecount-devel-0.6.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecount-devel}"
SRC_URI[x86_64_v2_rust-bytecount-devel.sha256sum] = "9d40002863e71af21eac6f4d163cb2d029c6756fd76c3227d157378423fa87bf"

URI_aarch64_rust-bytecount+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecount+default-devel-0.6.9-1.el10_1.noarch.rpm;name=aarch64_rust-bytecount+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecount+default-devel}"
SRC_URI[aarch64_rust-bytecount+default-devel.sha256sum] = "b764d065ebe5ccf9c28b403d0b99402d8e71a9b8f6732cf3903df9b3429103a7"

URI_aarch64_rust-bytecount+generic-simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecount+generic-simd-devel-0.6.9-1.el10_1.noarch.rpm;name=aarch64_rust-bytecount+generic-simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecount+generic-simd-devel}"
SRC_URI[aarch64_rust-bytecount+generic-simd-devel.sha256sum] = "ee93814b5ba7e2c2c436d844e5ff49022d3379b0928b0f63512a0bda3695538c"

URI_aarch64_rust-bytecount+html_report-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecount+html_report-devel-0.6.9-1.el10_1.noarch.rpm;name=aarch64_rust-bytecount+html_report-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecount+html_report-devel}"
SRC_URI[aarch64_rust-bytecount+html_report-devel.sha256sum] = "a0810e86d6f858c03efaea64f5e330ccbbe78b6e0c8e9b21da453eb4a80206bc"

URI_aarch64_rust-bytecount+runtime-dispatch-simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecount+runtime-dispatch-simd-devel-0.6.9-1.el10_1.noarch.rpm;name=aarch64_rust-bytecount+runtime-dispatch-simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecount+runtime-dispatch-simd-devel}"
SRC_URI[aarch64_rust-bytecount+runtime-dispatch-simd-devel.sha256sum] = "548b0a50278da742dfec9c8501f565070b9ca6f0c4b8696f838d7124427e6704"

URI_aarch64_rust-bytecount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecount-devel-0.6.9-1.el10_1.noarch.rpm;name=aarch64_rust-bytecount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecount-devel}"
SRC_URI[aarch64_rust-bytecount-devel.sha256sum] = "cb18744678a68181b43aeee69d79674dff17cdf638f978be516642948fb42984"

RDEPENDS:rust-bytecount+default-devel = " \
 cargo \
 rust-bytecount-devel \
 "
RDEPENDS:rust-bytecount+generic-simd-devel = " \
 cargo \
 rust-bytecount-devel \
 "
RDEPENDS:rust-bytecount+html_report-devel = " \
 cargo \
 rust-bytecount-devel \
 "
RDEPENDS:rust-bytecount+runtime-dispatch-simd-devel = " \
 cargo \
 rust-bytecount-devel \
 "
RDEPENDS:rust-bytecount-devel = " \
 bash \
 cargo \
 "
