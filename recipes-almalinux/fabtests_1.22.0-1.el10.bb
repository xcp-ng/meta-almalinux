# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fabtests"
PV = "1.22.0"
PR = "1.el10"
PACKAGES = " \
 fabtests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/fabtests-1.22.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1aa217017b99ebc25d53415c35181b4746eee59d54731a4681a9f1f424989c10"

URI_x86_64_v2_fabtests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fabtests-1.22.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_fabtests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fabtests}"
SRC_URI[x86_64_v2_fabtests.sha256sum] = "4e51674f1adce1438ddf72a16de8cbabc748bb7cc91feb4d2cd36b344b39bab9"

URI_aarch64_fabtests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fabtests-1.22.0-1.el10.aarch64.rpm;name=aarch64_fabtests;unpack=0"
SRC_URI:append = " ${URI_aarch64_fabtests}"
SRC_URI[aarch64_fabtests.sha256sum] = "cad3b7a6b734954e30cae2cc10f6c210fd0cc0895bc7b5c7b5330cac6c769157"

RDEPENDS:fabtests = " \
 bash \
 glibc \
 libfabric \
 python3 \
 python3-pytest \
 ruby \
 "
