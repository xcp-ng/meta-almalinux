# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libb64"
PV = "1.2"
PR = "19.el10_3"
PACKAGES = " \
 libb64-devel \
 libb64-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libb64-1.2-19.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7861a3bf5577a571d70355ce53d9a64075ffc9ef04b5f671b4d09a586aafa0a8"

URI_x86_64_v2_libb64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libb64-devel-1.2-19.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libb64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libb64-devel}"
SRC_URI[x86_64_v2_libb64-devel.sha256sum] = "c83603570ce98d805397e081ce4e8f37d6155c90ce58dd3b5552590634d22903"

URI_x86_64_v2_libb64-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libb64-tools-1.2-19.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libb64-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libb64-tools}"
SRC_URI[x86_64_v2_libb64-tools.sha256sum] = "9865ed88b862e205baf4f2c7aa89f31446058998568ef53bfa78a3e3a047a8e7"

URI_aarch64_libb64-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libb64-devel-1.2-19.el10_3.aarch64.rpm;name=aarch64_libb64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libb64-devel}"
SRC_URI[aarch64_libb64-devel.sha256sum] = "aefbe832efad909cfad25368f4f68fd9933e675dd5fd824ee3cccdf50945bb05"

URI_aarch64_libb64-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libb64-tools-1.2-19.el10_3.aarch64.rpm;name=aarch64_libb64-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libb64-tools}"
SRC_URI[aarch64_libb64-tools.sha256sum] = "0c033679ef7f8a5c4726dfed2b7290622c518abbd1dd9cf83097931cdd00dd94"

RDEPENDS:libb64-devel = " \
 "
RDEPENDS:libb64-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 "
