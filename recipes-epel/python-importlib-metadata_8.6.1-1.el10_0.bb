# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-importlib-metadata"
PV = "8.6.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-importlib-metadata \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-importlib-metadata-8.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "262734182b92b4218c4aace6adcc71fca7cc94413417a115669b6e0609f00d80"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-importlib-metadata-8.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-importlib-metadata;unpack=0"
SRC_URI[x86_64_v2_python3-importlib-metadata.sha256sum] = "91ac55afd7878f3da2c1d7762ae68070518e5f67fdb4ca1e607af71fa2cb992c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-importlib-metadata-8.6.1-1.el10_0.noarch.rpm;name=aarch64_python3-importlib-metadata;unpack=0"
SRC_URI[aarch64_python3-importlib-metadata.sha256sum] = "36fc9f3187ba3ad59e8f5fe32b6d8be68d1ba4634b10ebeae4e3e6d7a3bd077d"

RDEPENDS:python3-importlib-metadata = " \
 python3 \
 python3-zipp \
 "
